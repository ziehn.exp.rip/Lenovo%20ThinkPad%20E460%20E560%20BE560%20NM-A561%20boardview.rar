# Allegro board Lenovo ThinkPad E460 E560 BE560 NM-A561 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_HDA_RST#: length 141
  TOP w0.114: RPC2.1 104.94,64.95 105.4,64.49 105.4,62.74 v4(107.42,60.73) 109.06,59.08 120.77,59.08 v3(122.64,60.95) ; UA1.9 207.78,23.77 207.32,24.22 207.32,24.96 205.95,26.33 205.95,27.78 202.66,31.07 190.76,31.07 190.05,31.78 171.52,31.78 v3(170.74,32.55)
  IN2 w0.14: v3(122.64,60.95) 122.92,60.67 125.97,60.67 126.54,61.24 129.22,61.24 130.75,59.72 131.65,59.72 131.85,59.93 136.74,59.93 138.28,58.38 140.52,58.38 144.37,54.54 153.26,54.54 164.37,43.42 164.37,38.93 165.78,37.52 165.78,37.32 165.01,36.55 165.01,36.35 165.27,36.09 165.47,36.09 166.24,36.86 166.44,36.86 166.81,36.49 166.81,36.29 165.72,35.21 165.72,35.01 165.98,34.75 166.18,34.75 167.26,35.84 167.46,35.84 167.72,35.57 167.72,35.38 166.64,34.29 166.64,34.09 166.9,33.83 167.1,33.83 168.18,34.92 168.38,34.92 168.64,34.66 168.64,34.46 167.55,33.38 167.55,33.18 167.81,32.92 168.01,32.92 169.1,34 169.29,34 v3(170.74,32.55)
PCH_HDA_SDIN0: length 149.7
  TOP w0.114: v3(172.14,32.55) 172.43,32.26 190.25,32.26 190.96,31.55 202.86,31.55 205.25,29.16 208.96,29.16 209.86,28.26 RA5.1 ; v3(99.88,77.88) 101.45,76.3 101.45,74.21 101.99,73.67 101.99,70.22 102.7,69.51 102.7,69.03 RC297.1 RC301.1 103.23,67.3 103.43,67.1 105.33,67.1 v4(107.12,65.3) 107.68,64.74 107.68,62.86 109.89,60.64 119.16,60.64 v3(120.28,61.76)
  IN2 w0.14: v3(120.28,61.76) 120.71,62.19 123.98,62.19 124.8,63.01 131.98,63.01 134,60.99 137.18,60.99 138.63,59.54 140.87,59.54 144.81,55.6 153.7,55.6 164.1,45.2 166.99,45.2 171.66,40.53 171.66,35.07 172.14,34.58 v3(172.14,32.55)
  BOTTOM w0.076: UC1.BA21 98.12,83.28 98.12,82.04 98.26,81.91 98.26,81.3 98.81,80.75 98.81,79.93 99.49,79.25 99.49,78.54
  BOTTOM w0.102: 99.49,78.54 99.49,78.27 v3(99.88,77.88)
PCH_HDA_SDIN0_R: length 3.3
  TOP w0.114: RA5.2 209.96,25.97 v4(209.96,25.08) 209.96,25.03 208.98,24.05 UA1.6
PCH_HDA_SDOUT: length 135.2
  TOP w0.114: v3(171.63,34.25) 172.7,34.25 173.7,33.25 190.66,33.25 191.37,32.54 203.27,32.54 205.49,30.32 209.28,30.32 211,28.59 211,24.88 209.78,23.65 UA1.4 ; RPC2.3 105.34,65.95 106.39,64.9 106.39,63.26 109.58,60.07 120.17,60.07 v4(122.22,62.13) 123.93,62.13 124.32,62.52 v3(124.97,62.52)
  IN2 w0.14: v3(171.63,34.25) 171.34,34.55 171.34,40.36 166.8,44.9 164.02,44.9 153.59,55.34 144.7,55.34 140.77,59.26 138.54,59.26 137.07,60.73 132.35,60.73 130.99,62.09 130.85,62.09 130.21,62.74 125.19,62.74 v3(124.97,62.52)
PCH_HDA_SYNC: length 140.7
  TOP w0.114: UA1.8 208.18,23.77 207.68,24.27 207.68,25.06 206.28,26.46 206.28,27.79 202.76,31.31 190.86,31.31 190.15,32.02 171.99,32.02 v3(171.48,32.53) ; RPC2.4 105.4,66.45 107.04,64.81 107.04,62.95 109.68,60.31 119.49,60.31 v4(119.77,60.59) 120.45,61.28 v3(120.71,61.28)
  IN2 w0.14: v3(120.71,61.28) 121.35,61.93 125.11,61.93 125.22,61.83 129.39,61.83 130.18,61.04 131.66,61.04 132.24,60.46 136.96,60.46 138.42,58.99 140.66,58.99 144.59,55.07 153.48,55.07 163.91,44.64 166.69,44.64 167.69,43.64 167.69,41.29 167.83,41.15 169.11,41.15 169.25,41.01 169.25,40.64 169.11,40.5 167.83,40.5 167.69,40.36 167.69,39.99 167.83,39.85 169.28,39.85 169.42,39.71 169.42,39.34 169.28,39.2 167.83,39.2 167.69,39.07 167.69,38.7 167.83,38.56 169.82,38.56 169.96,38.42 169.96,38.05 169.82,37.91 167.83,37.91 167.69,37.77 167.69,37.52 171.48,33.72 v3(171.48,32.53)
PCH_INTRUDER#: length 24
  TOP w0.114: v3(110.78,75.05) 111.21,74.61 113.72,74.61 114.66,73.67 RC16.2
  IN3 w0.076: v3(100.17,87.02) 100.55,86.64 100.55,84.9 101.17,84.27 ; 109.86,75.96 v3(110.78,75.05)
  IN3 w0.114: 101.17,84.27 101.31,84.14 101.31,83.78 101.68,83.41 102.34,83.41 103.36,82.38 104.12,82.38 105.21,81.29 106.94,81.29 109.86,78.37 109.86,75.96
  BOTTOM w0.076: UC1.AP16 v3(100.17,87.02)
PCH_JTAG_TCK: length 16.3
  TOP w0.114: TC10.1 80.02,113.68 v1(79.13,112.79)
  BOTTOM w0.076: 77.45,110.53 77.45,110.4 77.68,110.17 77.68,109.39 76.82,108.53 76.82,106.74 77.55,106.01 77.56,106.01 77.66,105.91 77.66,105.9 77.69,105.87 77.69,105.3 77.51,105.12 77.51,104.86 77.58,104.72 77.58,104.51 UC1.B56
  BOTTOM w0.114: RC352.1 79.13,115.88 v1(79.13,112.79) 77.45,111.11 77.45,110.53
PCH_JTAG_TDI: length 20.9
  TOP w0.114: v1(77.2,114.8) 76.93,115.06 RC422.2 77.34,115.76 77.34,116.37 77.78,116.82 78.92,116.82 79.5,117.39 79.5,117.77 79.18,118.09 78.73,118.09 v4(78.61,117.96) 78.1,118.47 RC354.1
  BOTTOM w0.076: 76.94,110.53 76.94,110.42 77.37,109.98 77.37,109.53 76.43,108.59 76.43,106.62 76.7,106.36 76.7,105.35 76.86,105.19 76.86,104.83 76.82,104.73 76.82,104.54 76.86,104.45 76.86,104.2 76.72,103.72 76.72,103.61 76.64,103.34 UC1.D59
  BOTTOM w0.114: v1(77.2,114.8) 77.64,114.35 77.64,112.07 76.94,111.37 76.94,110.53
PCH_JTAG_TDO: length 10
  BOTTOM w0.076: UC1.A56 77.88,105.06 77.88,105.94 76.99,106.82 76.99,108.47 77.83,109.31 77.83,110.4 77.7,110.53
  BOTTOM w0.114: 77.7,110.53 77.7,110.76 v4(78.1,111.16) 78.94,111.99 79.37,111.99 79.69,112.31 RC423.2
PCH_JTAG_TMS: length 16.6
  TOP w0.114: v4(74.86,117.51) 74.86,117.45 75.27,117.04 75.27,116.68 75.02,116.44 74.67,116.44 74.54,116.31 74.54,115.61 74.77,115.38 RC353.1 RC424.2 75.62,114.78 76,114.4 76,111.36 76.96,110.4 v1(76.96,109.64)
  BOTTOM w0.076: UC1.C59 76.61,103.97 76.69,104.23 76.69,104.4 76.63,104.59 76.63,104.74 76.69,104.86 76.69,105.12 76.52,105.29 76.52,106.25 76.18,106.59 76.18,108.58 76.96,109.35 v1(76.96,109.64)
PCH_JTAG_TRST#: length 11.6
  BOTTOM w0.076: 74.89,110.53 74.89,109.13 74.3,108.55 74.3,106.55 75.04,105.81 75.04,105.36 74.87,105.19 74.87,104.82 74.88,104.79 74.9,104.73 74.9,104.12 74.91,104.11 74.91,104.05 UC1.C61
  BOTTOM w0.114: 74.89,110.53 74.89,112.09 v2(74.16,112.82) 74.61,113.26 75.14,113.26 RC425.2
PCH_JTAGX: length 14.4
  BOTTOM w0.076: 76.7,110.53 76.7,110.16 76.41,109.87 76.41,109.02 76.03,108.64 76.03,106.52 76.05,106.5 76.05,106.48 76.27,106.27 76.27,105.12 UC1.A59
  BOTTOM w0.114: RC415.2 73.5,113.23 74.29,114.02 74.54,114.02 74.99,114.47 76.64,114.47 v4(76.76,114.34) 77.4,113.7 77.4,112.21 76.7,111.51 76.7,110.53
PCH_MUX_AUX: length 100.2
  TOP w0.114: v5(31.5,68.59) 31.58,68.59 31.81,68.37 31.81,67.46 32.31,66.95 32.31,64.61 31.37,63.67 31.1,63.67 30.96,63.8 CX15.1
  IN3 w0.076: 76.64,108.1 76.64,108.08 76.62,108.06 76.62,107.23 80.58,103.26 80.58,101.74 80.66,101.66 80.79,101.66 v3(80.96,101.83)
  IN3 w0.114: v5(31.5,68.59) 31.74,68.59 31.86,68.71 31.86,69.09 31.67,69.28 28.45,69.28 27.13,70.6 27.13,77.61 29.29,79.78 29.29,80.85 29.52,81.07 29.52,83.71 30.79,84.98 35.95,84.98 37.62,86.65 37.62,91.3 42.5,96.18 44.89,96.18 47.86,99.15 47.86,101.85 56.54,110.53 59.21,110.53 59.77,111.09 61.71,111.09 62.57,110.23 64.56,110.23 65.11,109.67 68.47,109.67 68.9,109.23 71.45,109.23 72.11,109.89 75.07,109.89 76.64,108.33 76.64,108.1
  BOTTOM w0.076: UC1.F50 v3(80.96,101.83)
PCH_MUX_AUX#: length 100.2
  TOP w0.114: CX16.1 30.96,63.26 31.15,63.44 31.47,63.44 32.54,64.51 32.54,67.05 32.04,67.55 32.04,68.34 v5(32.29,68.59)
  IN3 w0.076: 76.43,108.1 76.43,108.08 76.45,108.06 76.45,107.16 80.42,103.2 80.42,101.67 80.59,101.49 80.78,101.49 80.96,101.31 v3(80.96,101.2)
  IN3 w0.114: v5(32.29,68.59) 32.06,68.83 32.06,69.18 31.76,69.48 28.53,69.48 27.33,70.68 27.33,77.53 29.5,79.69 29.5,80.76 29.72,80.99 29.72,83.62 30.88,84.77 36.03,84.77 37.83,86.57 37.83,91.22 42.58,95.98 44.97,95.98 48.06,99.07 48.06,101.77 56.62,110.33 59.3,110.33 59.86,110.89 61.63,110.89 62.49,110.02 64.47,110.02 65.03,109.46 68.38,109.46 68.81,109.03 71.53,109.03 72.19,109.69 74.99,109.69 76.43,108.24 76.43,108.1
  BOTTOM w0.076: UC1.G50 v3(80.96,101.2)
PCH_MUX_AUX#_C: length 2.1
  TOP w0.114: CX16.2 29.66,63.41 28.66,63.41 28.59,63.35 UX1.51
PCH_MUX_AUX_C: length 2.1
  TOP w0.114: CX15.2 29.78,63.64 28.79,63.64 28.69,63.75 UX1.52
PCH_MUX_CLK: length 150.8
  TOP w0.114: RC277.2 54.18,104.33 55.1,103.42 v3(55.1,103.32) 54.34,102.55 45.9,102.55 v3(43.64,104.81) ; v5(29.37,62.96) 29.28,62.87 28.72,62.87 28.64,62.95 UX1.50
  IN1 w0.14: v3(102.77,98.53) 101.79,98.53 101.63,98.69 100.92,98.69 100.82,98.8 100.82,99.25 100.01,100.06 97.22,100.06 96.98,100.29 96.73,100.29 96.04,100.98 96.04,102.83 96.5,103.29 96.5,105.98 96.73,106.21 96.73,112.31 95.33,113.71 86.42,113.71 84.65,111.94 84.65,108.18 82.61,106.14 82.61,104.81 81.4,103.61 81.4,100.95 81.08,100.62 73.39,100.62 72.84,100.08 71.24,100.08 70.91,100.41 65.92,100.41 65.33,99.82 55.42,99.82 54.46,100.78 54.46,102.55 55.1,103.19 v3(55.1,103.32)
  IN3 w0.114: v5(29.37,62.96) 30.25,63.83 30.25,66.05 29.62,66.67 28.94,66.67 25.67,69.94 25.67,75.5 21.91,79.25 21.91,83.23 25,86.31 25,91.02 25.9,91.92 31.22,91.92 43.14,103.84 43.14,104.31 v3(43.64,104.81)
  BOTTOM w0.076: UC1.L13 102.57,98.78 v3(102.77,98.53)
PCH_MUX_DAT: length 154.1
  TOP w0.114: v3(29.32,62.3) 29.32,62.37 29.06,62.63 28.68,62.63 28.6,62.55 UX1.49 ; v3(44.13,105.45) v4(46.13,103.44) 46.75,102.82 53.61,102.82 53.83,103.04 RC287.2 54.34,103.44 v3(54.46,103.32)
  IN1 w0.14: v3(54.46,103.32) 54.2,103.05 54.2,100.67 55.31,99.56 65.89,99.56 66.37,100.03 70.85,100.03 71.1,99.79 73.12,99.79 73.68,100.34 81.92,100.34 82.33,100.75 82.33,102.88 82.92,103.48 82.92,106.02 84.96,108.05 84.96,111.87 86.53,113.44 95.2,113.44 96.45,112.19 96.45,106.31 96.22,106.08 96.22,103.67 95.1,102.55 95.1,100.85 95.48,100.47 96.07,100.47 96.6,99.94 96.86,99.94 97.05,99.75 99.86,99.75 100.4,99.21 100.4,98.81 100.16,98.57 100.16,98.08 100.4,97.84 101.39,97.84 101.86,98.32 102.41,98.32 102.62,98.11 102.98,98.11 v3(103.4,98.53)
  IN3 w0.114: v3(29.32,62.3) 28.93,62.69 28.93,63.18 30,64.25 30,65.95 29.52,66.43 28.84,66.43 25.43,69.84 25.43,75.4 21.67,79.15 21.67,83.33 24.76,86.41 24.76,91.12 25.8,92.17 31.12,92.17 42.58,103.62 42.58,104.43 43.57,105.42 44.1,105.42 v3(44.13,105.45)
  BOTTOM w0.076: UC1.L12 v3(103.4,98.53)
PCH_MUX_HPD: length 301.5
  TOP w0.114: UX1.5 25.67,67.2 v2(25.99,67.53) 26.17,67.71 26.17,67.73 26.4,67.96 26.42,67.96 26.48,68.02 v3(26.6,68.02) ; v1(121.8,100.73) 121.65,100.57 118.1,100.57 117.99,100.46 RC288.1
  IN1 w0.076: 110,101.64 108.17,99.81 107.52,99.81 106.63,98.92 105.69,98.92 v3(105.31,98.53)
  IN1 w0.14: v3(155.16,37.71) 149.9,42.97 144.68,42.97 142.02,40.31 140.67,40.31 137.7,43.27 137.01,43.27 135.36,41.62 127.41,41.62 121.15,35.36 121.15,31.98 120.3,31.13 v3(120.3,25.47) ; 110,101.64 114.37,101.64 114.96,102.22 116.27,102.22 117.74,100.75 121.77,100.75 v1(121.8,100.73)
  IN2 w0.14: v1(121.8,100.73) 121.8,100.5 122.18,100.12 125.38,100.12 126.55,98.95 130.52,98.95 132.78,96.69 145.28,96.69 145.92,96.05 v1(145.92,95.92)
  IN3 w0.114: v3(120.3,25.47) 110.45,25.47 105.53,20.55 82.15,20.55 80.41,22.29 63.79,22.29 59.54,26.53 59.54,28.54 54.47,33.61 51.68,33.61 50.27,35.02 34.42,35.02 29.86,39.57 29.86,54.61 30.37,55.11 30.37,59.49 28.61,61.25 28.61,63.2 29.76,64.35 29.76,65.85 29.42,66.19 28.43,66.19 v3(26.6,68.02)
  BOTTOM w0.076: UC1.L9 v3(105.31,98.53)
  BOTTOM w0.114: v3(155.16,37.71) 155.16,39.02 155.77,39.63 155.77,59.07 154.41,60.43 154.41,62.39 149.36,67.44 149.36,72.05 148.91,72.5 148.91,77.16 147.85,78.22 147.85,81.69 148.79,82.63 148.79,84.56 148.27,85.08 148.27,89.21 148,89.47 148,89.75 147.48,90.27 147.15,90.27 146.34,91.09 146.34,92.45 146.92,93.03 146.92,94.67 145.92,95.67 v1(145.92,95.92)
PCH_OPIRCOMP: length 20
  TOP w0.305: RC55.2 110.67,72.35 110.67,73.7 v3(109.68,74.69)
  IN3 w0.203: v3(100.17,85.12) 100.17,84.84 100.72,84.28 100.72,83.82 101.73,82.81
  IN3 w0.254: 101.73,82.81 102.39,82.81 104.31,80.89 106.84,80.89 109.48,78.25 109.48,74.89 v3(109.68,74.69)
  BOTTOM w0.254: UC1.AU16 v3(100.17,85.12)
PCH_PCI_CLK_R: length 18.9
  TOP w0.114: RC24.1 107.84,70.39 107.56,70.39 v4(107.4,70.55) 106.97,70.98 106.97,75.27 108.17,76.48 v3(108.58,76.48)
  BOTTOM w0.076: 108.16,79.29 105.9,81.55 104.9,81.55 104.35,82.1 104.35,82.48 104.37,82.51 104.4,82.59 104.4,82.71 104.34,82.93 104.34,83.07 104.39,83.23 104.39,83.31 104.61,84.01 104.61,84.01 104.79,84.19 UC1.AW9
  BOTTOM w0.102: v3(108.58,76.48) 108.16,76.9 108.16,79.29
PCH_PWROK: length 100.9
  TOP w0.114: v3(188.17,44.16) 188.11,44.1 UE1.99 ; v3(123.75,62.65) 123.65,62.55 120.43,62.55 118.76,60.89 110.17,60.89 108.27,62.78 v4(108.27,63.11) 108.27,64.9 106.1,67.07 106.1,69.08 RC382.1 104.91,70.27 RC41.1
  IN2 w0.14: v3(162.69,49.84) 159.84,49.84 153.81,55.87 144.92,55.87 140.98,59.81 138.74,59.81 137.29,61.26 134.11,61.26 132.09,63.27 124.38,63.27 v3(123.75,62.65)
  IN3 w0.114: v3(162.69,49.84) 163.59,49.84 166.41,47.02 174.54,47.02 175.16,46.39 182.43,46.39 185.1,43.73 187.74,43.73 v3(188.17,44.16)
PCH_RTCRST#: length 44.7
  TOP w0.084: 118.4,72.4 118.4,72.3 118.13,72.04
  TOP w0.114: v4(117.99,70.4) 117.9,70.49 v3(117.9,71.81) 118.13,72.04 ; 118.4,72.4 CC1.1 118.4,73.17 117.89,73.67 RC12.2
  IN2 w0.076: v3(100.17,88.29) 99.78,87.91 99.78,84.95 101.48,83.25 106.28,83.25
  IN2 w0.14: 106.28,83.25 115.96,73.57 116.59,73.57 117.9,72.26 v3(117.9,71.81)
  BOTTOM w0.076: UC1.AM16 v3(100.17,88.29)
  BOTTOM w0.114: v3(117.9,71.81) 118.04,71.67 120.71,71.67 121.47,70.91 122.99,70.91 124.71,72.62 125.53,72.62 125.98,72.18 125.98,71.67 125.72,71.41 125.72,70.49 JCMOS1.1
PCH_RTCX1: length 21.8
  TOP w0.114: YC1.1 116.99,88.89 CC3.1 115.45,88.89 RC13.1 115.04,88.53 114.44,88.53 114.17,88.26 107.8,88.26 v2(107.5,88.55) 106.41,88.55 106.06,88.91 106.06,89.19 105.77,89.48 105.25,89.48 v3(104.89,89.12)
  IN3 w0.076: v3(99.25,88.29) 99.7,88.74 99.7,89.12 99.88,89.3 101.76,89.3 102.1,89.63 104.38,89.63 v3(104.89,89.12)
  BOTTOM w0.076: UC1.AM18 v3(99.25,88.29)
PCH_RTCX2: length 22.8
  TOP w0.114: v1(105.55,89.07) 106.27,88.35 107.26,88.35 107.61,88 114.25,88 114.55,88.3 115.12,88.3 RC13.2 115.45,88.03 CC4.1 117.3,88.03 YC1.2
  IN3 w0.076: v1(105.55,89.07) 104.18,90.44 102.47,90.44 101.48,89.45 99.75,89.45 99.62,89.32 99.08,89.32 98.86,89.1 98.86,88.82 v3(98.34,88.29)
  BOTTOM w0.076: UC1.AM20 v3(98.34,88.29)
PCH_SLP_LAN#: length 444.3
  TOP w0.114: v3(117.63,67.02) v4(116.57,67.02) 116.31,67.02 116.11,67.22 115.04,67.22 114.84,67.02 113.57,67.02 113.13,66.59 112.68,66.59 112.17,66.08 RPC18.5 ; v3(193.73,48.15) 193.58,48.3 188.02,48.3 187.28,47.56 187.02,47.56 186.52,48.07 UE1.87 ; v3(56.72,119.71) 56.6,119.83 54.08,119.83 RL17.1
  IN2 w0.14: v3(146.26,40.55) 146.26,41.26 145.9,41.62 129.93,41.62 129.42,41.11 129.42,34.05 125.13,29.76 125.13,16.6 122.76,14.24 48.93,14.24 45.78,17.39 45.75,17.39 36.05,27.09 36.05,34.08 31.86,38.27 31.86,55.16 30.99,56.02 30.99,63.08 30.33,63.74 30.33,66.16 29.52,66.97 29.17,66.97 28.61,67.53 28.61,70.68 29.85,71.92 29.85,73.15 31.76,75.06 31.76,76.78 33.33,78.35 33.33,78.84 36.79,82.29 36.79,83.43 39.07,85.72 39.07,97.05 48.8,106.77 48.8,110.61 54.92,116.74 54.92,119.28 55.42,119.78 56.66,119.78 v3(56.72,119.71) ; v3(117.63,67.02) 117.63,67.51 119.47,69.36 121.77,69.36 122.05,69.64 122.51,69.64 123.46,68.68 124.19,68.68 124.6,69.1 129.22,69.1 130.75,67.57 137.43,67.57 142.99,62.02 v3(151.09,62.02)
  IN3 w0.114: v3(148.88,20.11) 149.87,21.1 169.12,21.1 171.35,23.33 175.06,23.33 184.36,32.63 190.05,32.63 192.61,35.19 192.61,37.86 194.72,39.97 194.72,41.39 195.64,42.31 195.64,46.24 v3(193.73,48.15)
  BOTTOM w0.076: 104.44,77.81 104.44,78.19 101.29,81.33 101.29,82.07 101.41,82.18 101.41,83.65 101.25,83.99 101.25,83.98 101.09,84.14 UC1.AW15
  BOTTOM w0.114: v3(151.09,62.02) 151.33,61.77 151.33,52.83 147.15,48.66 147.15,41.72 146.26,40.83 v3(146.26,40.55) 146.26,38.85 147.36,37.75 147.36,22.63 148.88,21.12 v3(148.88,20.11) ; v3(117.63,67.02) 116.36,67.02 114.94,68.44 111.6,68.44 110.98,69.06 109.26,69.06 104.44,73.89 104.44,77.81
PCH_SLP_SUS#: length 3
  TOP w0.076: v3(101.08,87.66) 101.61,88.19 101.61,89.24 101.91,89.55 TC21.1
  BOTTOM w0.076: UC1.AN15 v3(101.08,87.66)
PCH_SLP_WLAN#: length 111.5
  TOP w0.114: v3(117.75,64.21) 117.02,63.49 RC393.2 ; v4(167.7,49.42) v3(167.7,50.05) ; UE1.88 184.01,47.67 v3(183.58,48.1)
  IN2 w0.14: v3(167.7,50.05) 165.78,50.05 161.66,54.18 160.29,54.18 153.44,61.03 142.84,61.03 139.29,64.59 133.95,64.59 131.76,66.77 130.5,66.77 130.07,66.34 129.18,66.34 128.19,67.34 125.55,67.34 125.41,67.48 123.56,67.48 123.21,67.12 121.98,67.12 121.21,67.88 120.35,67.88 119.31,66.84 119.31,65.27 118.25,64.21 v3(117.75,64.21)
  IN3 w0.114: v3(183.58,48.1) 183.02,47.54 176.31,47.54 174.15,49.7 168.05,49.7 v3(167.7,50.05)
  BOTTOM w0.076: UC1.BB17 100.05,82.23 100.05,80.91
  BOTTOM w0.102: 104.67,70.26 102.85,72.07 102.85,78.11 100.05,80.91
  BOTTOM w0.114: 104.67,70.26 107.55,67.38 110.19,67.38 112.7,64.86 116.54,64.86 117.19,64.21 v3(117.75,64.21)
PCH_SMB_CLK: length 202.1
  TOP w0.114: v3(128.86,82.69) 128.61,82.95 RC395.1 ; v3(151.72,103.7) 151.72,104.79 152.23,105.3 152.23,111.85 147.6,116.47 145.45,116.47 143.07,118.85 v3(143.07,119.52)
  IN1 w0.14: v3(128.86,82.69) 128.86,81.32 128.07,80.53 128.07,77.66 129.17,76.57 129.17,74.33 130.61,72.89 130.61,71.92 131.44,71.09 134.85,71.09 135.55,70.39 148.25,70.39 149.38,71.52 149.38,72.33 152.18,75.12 v3(152.84,75.12)
  IN2 w0.14: v3(143.07,119.52) 142.25,118.7 141.69,118.7 139.45,120.94 139.15,120.94 137.8,122.29 137.8,124.37 136.41,125.76 117.81,125.76 116.46,127.12 102.36,127.12 100.63,128.84 93.21,128.84 v3(91.58,127.21) ; v3(152.84,75.12) 152.84,75.38 153.27,75.81 153.27,80.13 150.04,83.35 150.04,94.93 150.73,95.62 150.73,102.38 151.72,103.37 v3(151.72,103.7)
  IN3 w0.114: v3(106.58,96.53) 107,96.1 108.85,96.1 109.61,95.34 115.85,95.34 116.34,94.86 119.69,94.86 120.57,93.98 120.57,93.3 121.6,92.27 123.05,92.27 124.68,90.63 124.68,90.35 125.29,89.74 125.29,88.87 127.5,86.66 127.5,84.52 128.86,83.16 v3(128.86,82.69)
  BOTTOM w0.076: UC1.R7 v3(106.58,96.53)
  BOTTOM w0.114: v3(91.58,127.21) 91.35,127.45 v2(90.25,127.45) 89.95,127.75 89.06,127.75 87.67,126.37 85.6,126.37 83,128.96 83,131.35 82.66,131.69 80.4,131.69 79.99,132.09 79.99,132.81 79.2,133.59 77.96,133.59 77.56,133.2 76.51,133.2 75.66,132.35 QC1.6
PCH_SMB_DATA: length 196.3
  TOP w0.114: RC396.1 128.15,83.83 128.83,83.15 129.09,83.15 v3(129.55,82.69) ; v3(151.06,103.75) 151.06,104.56 151.92,105.42 151.92,111.72 147.48,116.17 145.32,116.17 142.32,119.17 v3(142.32,119.52)
  IN1 w0.14: v3(152.36,75.75) 149.07,72.46 149.07,71.65 148.12,70.7 135.72,70.7 135.01,71.41 131.58,71.41 130.98,72.01 130.98,73.04 129.5,74.53 129.5,76.8 128.4,77.89 128.4,80.28 129.55,81.42 v3(129.55,82.69)
  IN2 w0.14: v3(152.36,75.75) 152.66,75.75 152.94,76.04 152.94,79.99 149.71,83.21 149.71,95.11 150.4,95.8 150.4,102.5 151.06,103.16 v3(151.06,103.75) ; v3(89.34,127.19) 89.5,127.19 91.47,129.16 100.76,129.16 102.49,127.43 116.61,127.43 117.97,126.08 136.6,126.08 138.16,124.53 138.16,122.46 139.35,121.26 140.71,121.26 142.32,119.65 v3(142.32,119.52)
  IN3 w0.114: v3(105.94,96.53) 106.56,95.91 108.77,95.91 109.59,95.09 115.12,95.09 115.65,94.55 118.68,94.55 120.05,93.18 120.05,92.67 121.04,91.67 122.3,91.67 123.97,90 123.97,89.71 127.21,86.48 127.21,84.39 128.3,83.3 128.3,82.62 128.71,82.21 129.19,82.21 129.55,82.56 v3(129.55,82.69)
  BOTTOM w0.076: UC1.R8 v3(105.94,96.53)
  BOTTOM w0.114: v3(89.34,127.19) 89.34,127.01 v2(88.63,126.3) 88.4,126.07 85.48,126.07 82.4,129.15 79.17,129.15 77.96,130.35 QC1.3
PCH_SML0_CLK: length 365.6
  TOP w0.076: RC92.1 115.42,97.86 114.81,98.46 113.49,98.46 112.45,97.42 112.17,97.42 111.89,97.7 111.89,98.34 111.05,99.18 v3(110.98,99.18)
  TOP w0.114: v5(46.63,113.08) 46.71,113.16 UL1.28
  IN1 w0.14: v3(110.98,99.18) 109.94,99.18 107.73,96.97 105.75,96.97 v3(105.31,96.53)
  IN2 w0.14: v1(145.24,94.5) 144.68,94.5 143.39,95.8 132.54,95.8 130.19,98.15 126.17,98.15 125,99.32 121.03,99.32 120.27,98.55 117.2,98.55 116.76,98.99 115.83,98.99 115.12,98.29 114.22,98.29 113.98,98.53 111.63,98.53 v3(110.98,99.18) ; v3(154.72,17.08) 154.23,16.6 150.65,16.6 145.4,11.34 140.26,11.34 138.52,9.6 121.77,9.6 119.15,12.22 49.21,12.22 34.65,26.78 34.65,31.45 33.9,32.19 33.9,34.65 30.61,37.94 30.61,54.17 28.35,56.43 28.35,65.85 27.26,66.94 27.26,68.14 26.4,69 26.4,72.91 27.84,74.36 29.48,74.36 30.63,75.51 30.63,77.36 32.14,78.87 32.14,85.96 33.85,87.67 33.85,90.89 37.57,94.61 37.57,97.32 46.63,106.37 v5(46.63,113.08)
  BOTTOM w0.076: UC1.R9 v3(105.31,96.53)
  BOTTOM w0.114: v1(145.24,94.5) 145.12,94.38 145.12,90.92 146.44,89.6 146.44,88.53 147.73,87.24 147.73,84.9 148.3,84.33 148.3,82.94 147.36,82 147.36,77.79 148.36,76.8 148.36,72.37 148.85,71.88 148.85,67.27 153.77,62.34 153.77,60.23 155.29,58.71 155.29,47.23 154.93,46.87 154.93,46.38 155.29,46.03 155.29,39.83 154.36,38.9 154.36,17.44 v3(154.72,17.08)
PCH_SML0_DAT: length 353.4
  TOP w0.114: UL1.31 v3(47.91,113.6)
  IN2 w0.14: v3(127.34,89.8) 126.19,89.8 123.93,92.06 123.93,94.27 122.64,95.57 118.24,95.57 117.91,95.9 115.26,95.9 114.22,94.86 113.44,94.86 v3(113.26,94.68) ; v3(47.91,113.6) 47.91,112.69 46.94,111.72 46.94,106.23 38.03,97.32 38.03,85.81 35.99,83.77 35.99,82.62 32.45,79.09 32.45,78.74 30.96,77.25 30.96,75.39 29.6,74.03 27.97,74.03 26.73,72.79 26.73,69.18 27.67,68.24 27.67,67.02 28.68,66 28.68,56.76 30.94,54.5 30.94,38.06 34.22,34.78 34.22,32.33 34.96,31.58 34.96,26.91 49.34,12.54 119.28,12.54 121.9,9.92 138.39,9.92 140.13,11.66 145.26,11.66 150.52,16.92 153.84,16.92 v3(154.03,17.11)
  IN3 w0.114: v3(127.34,89.8) 127.51,89.98 130.1,89.98 130.71,90.59 132.09,90.59 132.76,91.26 142.33,91.26 143.95,89.65 145.5,89.65 v1(145.98,89.17)
  BOTTOM w0.076: UC1.W2 109.18,94.82 109.32,94.68 109.33,94.68 109.33,94.68 109.34,94.67 109.58,94.56 109.93,94.56 110.33,94.96 112.99,94.96 v3(113.26,94.68) 113.29,94.65 114.71,94.65 115.27,94.1 RC93.1
  BOTTOM w0.114: v1(145.98,89.17) 145.98,88.51 147.4,87.09 147.4,84.8 148.01,84.19 148.01,83.07 147.07,82.13 147.07,77.59 146.29,76.81 146.29,74.02 148.56,71.76 148.56,67.14 153.43,62.28 153.43,60.13 155,58.56 155,47.35 154.64,46.99 154.64,46.26 155,45.91 155,39.95 154.03,38.98 v3(154.03,17.11)
PCH_SML1CLK: length 37
  TOP w0.114: RC397.1 128.05,84.67 129.04,83.68 v3(129.04,83.61)
  IN3 w0.114: v3(111.49,95.8) 111.89,96.2 114.56,96.2 115.11,96.76 116.62,96.76 118.17,95.21 119.91,95.21 121.68,93.45 122.28,93.45 124.98,90.75 124.98,90.51 124.98,90.47 125.58,89.86 125.58,88.99 127.79,86.78 127.79,84.64 128.82,83.61 v3(129.04,83.61)
  BOTTOM w0.076: UC1.W3 108.58,95.02 108.74,95.02 108.96,95.1 109.09,95.1 109.32,95.03 109.45,95.03 109.58,95.09 109.86,95.09 110.14,95.37 111.05,95.37 v3(111.49,95.8) 111.85,95.43 112.27,95.43 112.49,95.65 113.16,95.65 113.84,94.97 114.52,94.97 115.07,95.52 115.98,95.52 116.36,95.9 116.57,95.9 116.64,95.98
  BOTTOM w0.114: 116.64,95.98 QC2.6
PCH_SML1DATA: length 39.4
  TOP w0.114: RC398.1 128.45,85.61 129.27,84.8 129.27,84.04 v1(129.67,83.63)
  IN3 w0.114: v1(129.67,83.63) 129.29,84.01 129.29,84.77 128.09,85.98 128.09,86.9 125.94,89.05 125.94,89.92 125.27,90.59 125.27,90.87 122.38,93.77 121.77,93.77 119.97,95.57 118.27,95.57 116.77,97.07 115.15,97.07 114.57,96.48 111.49,96.48 v3(110.85,95.85)
  BOTTOM w0.076: UC1.V3 108.33,95.22 108.79,95.22 108.95,95.27 109.09,95.27 109.31,95.21 109.43,95.21 109.54,95.26 109.73,95.26 110.01,95.54 110.55,95.54 v3(110.85,95.85) 111.21,96.2 113.04,96.2 113.96,95.28 114.39,95.28 114.86,95.75 114.86,97.02 115.12,97.28 QC2.3
PCH_SRTCRST#: length 41.9
  TOP w0.114: v4(116.57,71.49) 116.57,71.82 v3(116.3,72.08) 115.7,72.68 CC5.1 116.26,73.29 RC14.2
  IN2 w0.076: v3(99.25,87.66) 99.62,87.29 99.62,85.02 99.62,84.89 101.47,83.05 105.75,83.05
  IN2 w0.14: v3(116.3,72.08) 116.3,72.49 105.75,83.05
  BOTTOM w0.076: UC1.AN18 v3(99.25,87.66)
  BOTTOM w0.114: JME1.1 126.51,72.4 125.79,73.13 124.39,73.13 122.74,71.48 121.72,71.48 121.02,72.18 118.67,72.18 118.1,72.75 116.97,72.75 v3(116.3,72.08)
PCH_SYSPWROK: length 161.7
  TOP w0.076: RC381.1 112.12,109.84 112.12,110.76 v4(111.51,111.37)
  TOP w0.114: v3(193.55,54.47) 193.55,54.14 190.56,51.14 187.89,51.14 186.81,50.07 UE1.82 ; RC381.1 112.58,108.55 v3(111.67,107.64)
  IN1 w0.14: v3(111.67,107.64) 113.24,109.21 119.33,109.21 121.37,111.25 121.37,112.46 121.14,112.69 121.14,115.2 121.84,115.9 130.83,115.9 131.81,116.88 135.44,116.88 138.61,113.71 150.42,113.71 151.82,112.3 151.82,112.3 151.92,112.2 151.92,107.11 156.6,102.43 156.6,97.44 152.46,93.3 152.46,89.5 150.25,87.29 150.25,82.49 156.6,76.14 156.6,73.85 160.27,70.18 160.67,70.18 165.31,65.54 v3(165.31,63.69)
  IN3 w0.114: v3(165.31,63.69) 166.96,63.69 169.35,61.3 177.62,61.3 178.11,60.82 183.56,60.82 186.37,58.02 190.01,58.02 v3(193.55,54.47)
  BOTTOM w0.076: v3(111.67,107.64) 110.64,107.64 109.11,106.11 107.78,106.11 107.1,105.44 107.1,104.26 UC1.B6
PCH_TSOFF#: length 173.1
  TOP w0.114: v3(233.61,143.63) 233.91,143.93 233.91,146.78 234.42,147.28 234.43,147.28 D60.1 ; v3(187.15,110) 184.87,107.72 173.19,107.72 170.24,104.77 165.53,104.77 164.42,103.66 164.42,102.21 165.23,101.4 165.23,98.49 162.77,96.03 159.31,96.03 157.21,93.92 v4(155.35,93.92) 150.4,93.92 RPC9.1 148.58,92.69 148.44,92.55 v3(148.44,92.37)
  IN1 w0.14: v3(148.44,92.37) 148.47,92.34 148.47,91.2 147.82,90.55 147.82,88.72 147.3,88.2 146.89,88.2 146.46,88.64 146.46,89.37 146.16,89.68 143.77,89.68 141.19,92.26 134.43,92.26 134.07,92.62 127.84,92.62 126.69,91.47 126.69,90.79 125.49,89.58 125.49,88.56 125.09,88.16 124.35,88.16 122.83,89.67 122.83,90.68 121.45,92.06 120.05,92.06 119.84,91.86 116.62,91.86 115.04,90.29 v3(114.74,90.29)
  IN3 w0.114: v3(233.61,143.63) 233.18,143.19 232.6,143.19 223.04,133.63 221.98,133.63 216.39,128.04 216.39,121.38 204.4,109.39 190.2,109.39 189.59,110 v3(187.15,110)
  BOTTOM w0.076: UC1.AD4 107.98,92.42 110.66,92.42 111.3,91.78 113.14,91.78 113.47,91.45 113.47,91.05 113.72,90.79 114.23,90.79 v3(114.74,90.29)
PCH_VGA_AUX: length 69.4
  TOP w0.114: v3(35.64,86.5) 35.41,86.73 35.08,86.73 CVG20.1
  IN3 w0.076: v3(81.88,101.83) 81.88,101.94 81.39,102.43 81.39,102.8 81.38,102.8 81.38,103 77.88,106.51 77.88,108.06 77.86,108.08 77.86,108.1
  IN3 w0.114: 77.86,108.1 77.86,109.38 76.81,110.43 71.81,110.43 71.15,109.77 69.07,109.77 68.67,110.16 65.32,110.16 64.76,110.72 63.26,110.72 62.26,111.72 59.37,111.72 58.74,111.09 55.01,111.09 53.8,109.89 53.8,108.55 47.12,101.87 47.12,99.41 44.43,96.71 42.33,96.71 37.12,91.5 37.12,87.73 36.17,86.78 35.93,86.78 v3(35.64,86.5)
  BOTTOM w0.076: UC1.F48 v3(81.88,101.83)
PCH_VGA_AUX#: length 69.4
  TOP w0.114: CVG19.1 35.14,86.96 35.31,86.96 v1(35.64,87.29)
  IN3 w0.076: 78.06,108.1 78.06,108.08 78.04,108.06 78.04,106.58 81.06,103.56 81.17,103.56 81.33,103.4 81.33,103.29 81.55,103.07 81.55,102.54 81.62,102.47 v3(81.88,102.47)
  IN3 w0.114: v1(35.64,87.29) 35.64,87.14 35.8,86.98 36.09,86.98 36.91,87.81 36.91,91.58 42.25,96.92 44.34,96.92 46.92,99.49 46.92,101.95 53.6,108.63 53.6,109.97 54.92,111.29 58.65,111.29 59.29,111.93 62.35,111.93 63.35,110.92 64.85,110.92 65.4,110.36 68.76,110.36 69.15,109.97 71.07,109.97 71.73,110.63 76.89,110.63 78.06,109.46 78.06,108.1
  BOTTOM w0.076: UC1.E48 v3(81.88,102.47)
PCH_VGA_HPD: length 351.3
  TOP w0.114: RC204.1 121.8,99.99 v3(122.51,100.7)
  TOP w0.305: v3(33.31,95.04) v4(32.72,95.04) 29.8,95.04 RVG129.1
  IN1 w0.076: v3(106.58,98.53) 107.7,99.65 108.31,99.65 108.42,99.77
  IN1 w0.14: 122.51,100.7 122.96,100.24 123.37,100.24 123.58,100.45 125.41,100.45 128.11,97.74 144.26,97.74 145.53,99.01 147.59,99.01 v3(148.42,98.19) ; 122.51,100.7 v3(122.51,100.7) ; 122.51,100.7 122.43,100.7 121.98,100.24 120.22,100.24 120.02,100.45 117.74,100.45 117.26,100.93 116.72,100.93 116.47,100.67 114.7,100.67 113.97,101.41 110.06,101.41 108.42,99.77
  IN2 w0.14: v3(33.31,95.04) 33.31,93.31 31.6,91.61 31.6,79.09 30.1,77.59 30.1,75.73 29.31,74.94 27.57,74.94 25.69,73.06 25.69,67.6 27.77,65.52 27.77,56.1 29.93,53.94 29.93,37.87 33.3,34.5 33.3,31.57 33.99,30.88 33.99,26.68 48.88,11.79 48.88,11.79 49,11.67 118.93,11.67 124.46,6.14 136.59,6.14 140.32,9.87 144.74,9.87 150.84,15.97 154.87,15.97 v3(155.35,15.48)
  BOTTOM w0.076: UC1.L7 v3(106.58,98.53)
  BOTTOM w0.114: v3(155.35,15.48) 156.09,16.22 156.09,17.4 155.91,17.58 155.91,38.57 156.32,38.98 156.32,45.56 156.65,45.89 156.65,46.28 156.32,46.61 156.32,59.35 154.96,60.7 154.96,62.57 151.06,66.47 151.06,71.87 150.56,72.37 150.56,76.94 148.65,78.86 148.65,81.35 149.51,82.21 149.51,84.86 149.05,85.32 149.05,88.69 149.43,89.06 149.43,94.2 147.55,96.08 147.55,97.32 v3(148.42,98.19)
PCH_XTAL24_IN: length 23.4
  BOTTOM w0.076: 90.46,104.99 90.46,102.91 90.15,102.61 89.1,102.61 UC1.E37
  BOTTOM w0.114: 90.46,104.99 90.46,106.11 89.59,106.97 89.59,107.93 90.1,108.43 91.56,108.43 92,108.88 92,114.21 v2(90.54,115.67) 89.64,116.58 RC30.2 89.64,118.19 CC7.1 89.46,118.42 89.46,120.03 YC2.3
PCH_XTAL24_OUT: length 21.5
  BOTTOM w0.076: UC1.E35 89.65,102.33 89.72,102.4 90.25,102.4 91.03,103.18 91.03,104.21
  BOTTOM w0.114: YC2.1 90.16,118.58 CC6.1 90.56,118.19 RC30.1 90.56,117.12 92.24,115.43 v2(92.24,114.99) 92.24,108.67 91.75,108.18 90.23,108.18 89.85,107.8 89.85,107.1 90.73,106.21 90.73,104.5 91.03,104.21
PCIE1_PTX_DRX_N0: length 14.6
  BOTTOM w0.076: UC1.B23 95.99,104.57 95.99,106.22 95.65,106.56 95.65,107.04 95.62,107.07 95.62,107.09
  BOTTOM w0.114: 95.62,107.09 95.62,112.15 96.93,113.47 96.93,113.7 97.24,114 97.24,115.77 v3(96.88,116.12) 96.58,116.42 96.58,117.3 CC86.2
PCIE1_PTX_DRX_P0: length 14.5
  BOTTOM w0.076: UC1.A23 96.15,105.07 96.15,106.28 95.82,106.61 95.82,107.05 95.85,107.07 95.85,107.09
  BOTTOM w0.114: CC87.2 97.08,117.57 96.81,117.29 96.81,116.52 97.47,115.86 v3(97.47,114.37) 97.47,113.91 97.16,113.6 97.16,113.37 96.58,112.79 96.58,112.7 96.58,112.61 96.34,112.37 96.16,112.37 95.85,112.05 95.85,111.62 95.9,111.56 95.9,111.56 95.96,111.51 95.96,111.16 95.9,111.11 95.9,111.11 95.85,111.05 95.85,110.7 95.9,110.65 95.9,110.65 95.96,110.59 95.96,110.25 95.9,110.19 95.9,110.19 95.85,110.13 95.85,109.79 95.9,109.73 95.9,109.73 95.96,109.67 95.96,109.33 95.9,109.27 95.9,109.27 95.85,109.22 95.85,108.87 95.9,108.82 95.9,108.82 95.96,108.76 95.96,108.42 95.9,108.36 95.9,108.36 95.85,108.3 95.85,107.96 95.9,107.9 95.9,107.9 95.96,107.84 95.96,107.5 95.9,107.44 95.9,107.44 95.85,107.39 95.85,107.09
PCIE2_PTX_DRX_N1: length 15.9
  BOTTOM w0.076: UC1.D23 96.47,103.34 96.54,103.61 96.54,103.72 96.68,104.2 96.68,104.45 96.65,104.54 96.65,104.73 96.68,104.83 96.68,105.34 96.52,105.5 96.52,106.03 96.87,106.38 96.87,106.69 96.91,106.73 96.91,106.75
  BOTTOM w0.114: 96.91,106.75 96.91,111.72 97.9,112.71 97.9,113.23 98.28,113.61 98.28,114.8 98.91,115.43 v3(98.91,116.6) 98.91,117.24 CC88.2
PCIE2_PTX_DRX_P1: length 15.9
  BOTTOM w0.076: 96.68,106.75 96.68,106.73 96.71,106.69 96.71,106.45 96.36,106.09 96.36,105.43 96.52,105.28 96.52,104.86 96.46,104.74 96.46,104.59 96.52,104.4 96.52,104.23 96.43,103.97 UC1.C23
  BOTTOM w0.114: 96.68,106.75 96.68,107 96.55,107.12 96.55,107.47 96.68,107.59 96.68,107.94 96.55,108.06 96.55,108.41 96.68,108.53 96.68,108.88 96.55,109 96.55,109.35 96.68,109.47 96.68,109.82 96.55,109.94 96.55,110.29 96.68,110.41 96.68,111.82 96.9,112.04 96.9,112.22 97.14,112.47 97.33,112.47 97.67,112.81 97.67,113.32 98.05,113.7 98.05,114.89 v3(98.49,115.33) 98.69,115.53 98.69,117.29 98.41,117.57 CC89.2
PCIE3_CRX_DTX_N: length 216.5
  IN3 w0.076: v3(100.17,100.56) 100.4,100.8 100.51,100.8 100.55,100.76 100.55,100.28 101.16,99.67 102.02,99.67 102.3,99.39 102.3,98.89 102.08,98.66 102.08,98.33 102.43,97.98 107.61,97.98 108.16,98.53 108.18,98.53
  IN3 w0.114: v3(245.68,170.95) 246.05,170.58 246.34,170.58 246.67,170.25 246.67,169.58 246.01,168.92 246.01,159.38 246.46,158.93 246.46,151.35 243.87,148.76 243.32,148.76 236.81,142.25 236.81,141.26 233.95,138.39 230.67,138.39 225.35,133.08 225.35,131.3 218.45,124.39 218.45,109 215.89,106.44 172.98,106.44 170.08,103.54 168.04,103.54 165.8,101.31 164.95,101.31 157.61,93.97 152.82,93.97 151.75,92.9 147.82,92.9 146.67,91.76 130.49,91.76 130.13,91.4 127.1,91.4 125.91,92.6 125.45,92.6 124.97,93.07 124.97,93.86 124.5,94.33 124.5,94.63 123.68,95.46 123.68,95.97 122.83,96.81 120.24,96.81 119.5,97.55 118.11,97.55 117.04,98.62 115.21,98.62 115.13,98.53 108.18,98.53
  BOTTOM w0.076: UC1.H16 100.4,100.29 v3(100.17,100.56)
  BOTTOM w0.114: JWLBT.43 242.49,172.9 242.63,173.04 244.97,173.04 246.44,171.57 246.44,170.92 246.18,170.66 245.96,170.66 v3(245.68,170.95)
PCIE3_CRX_DTX_P: length 216.6
  IN3 w0.076: v3(100.17,101.2) 100.4,100.96 100.58,100.96 100.71,100.83 100.71,100.35 101.23,99.84 102.09,99.84 102.47,99.46 102.47,98.82 102.24,98.59 102.24,98.4 102.5,98.15 107.54,98.15 108.13,98.74
  IN3 w0.114: v3(245.68,170.15) 245.91,170.38 246.25,170.38 246.46,170.17 246.46,169.66 245.8,169 245.8,159.3 246.26,158.84 246.26,151.43 243.79,148.96 243.24,148.96 236.61,142.33 236.61,141.34 233.86,138.6 230.59,138.6 225.15,133.16 225.15,131.38 218.24,124.47 218.24,109.08 215.8,106.64 172.9,106.64 170,103.75 167.95,103.75 165.72,101.51 164.87,101.51 157.53,94.17 152.74,94.17 151.67,93.11 147.73,93.11 146.59,91.96 130.4,91.96 130.05,91.61 127.18,91.61 125.99,92.8 125.53,92.8 125.18,93.16 125.18,93.95 124.71,94.42 124.71,94.72 123.88,95.54 123.88,96.05 122.92,97.02 120.33,97.02 119.59,97.75 118.19,97.75 117.13,98.82 115.13,98.82 115.04,98.74 108.13,98.74
  BOTTOM w0.076: UC1.G16 100.4,100.94 v3(100.17,101.2)
  BOTTOM w0.114: JWLBT.41 242.52,173.4 242.65,173.27 245.07,173.27 246.67,171.67 246.67,170.82 246.28,170.44 245.96,170.44 v3(245.68,170.15)
PCIE3_CTX_C_DRX_N: length 205.7
  IN3 w0.114: v3(243.23,174.26) 243.23,174.44 243.44,174.65 243.67,174.65 243.8,174.53 243.8,174.04 241.2,171.45 241.2,163.49 234.27,156.55 229.87,156.55 218.9,145.59 218.9,142.69 214.43,138.22 212.24,138.22 204.56,130.54 204.56,129.68 204.36,129.48 v3(204.17,129.48)
  BOTTOM w0.114: JWLBT.37 242.47,174.4 242.69,174.62 243.1,174.62 243.23,174.5 v3(243.23,174.26) ; v3(204.17,129.48) 204.34,129.48 204.45,129.36 204.45,118.48 202.37,116.4 188.53,116.4 183.48,111.34 181.21,111.34 178.16,114.39 178.16,116.45 176.16,118.45 154.01,118.45 151.62,120.84 149.78,120.84 145.06,125.57 v3(141.59,125.57) 140.59,125.57 137.74,128.41 111.97,128.41 108.86,125.3 108.86,124.21 104.83,120.18 104.45,120.18 103.71,119.45 103.71,116.34 100.67,113.29 100.67,110.96 CC18.1
PCIE3_CTX_C_DRX_P: length 205.8
  IN3 w0.114: v3(204.96,129.48) 204.77,129.67 204.77,130.46 212.32,138.01 214.52,138.01 219.11,142.6 219.11,145.51 229.95,156.35 234.35,156.35 241.41,163.4 241.41,171.36 244,173.95 244,174.61 243.76,174.85 243.42,174.85 v3(243.23,175.05)
  BOTTOM w0.114: CC19.1 100.89,111.11 100.89,111.39 101.02,111.52 101.02,111.85 100.89,111.98 100.89,112.31 101.02,112.43 101.02,112.76 100.89,112.89 100.89,113.2 101.13,113.43 101.31,113.43 101.54,113.67 101.54,113.84 101.78,114.08 101.95,114.08 102.19,114.31 102.19,114.49 103.94,116.24 103.94,119.36 104.54,119.95 104.93,119.95 109.09,124.11 109.09,125.21 112.06,128.18 137.65,128.18 140.49,125.34 v3(143.69,125.34) 144.96,125.34 149.69,120.61 151.52,120.61 153.91,118.23 176.06,118.23 177.93,116.35 177.93,114.3 181.11,111.11 183.57,111.11 188.63,116.17 202.46,116.17 204.68,118.39 204.68,129.2 v3(204.96,129.48) ; v3(243.23,175.05) 243.03,174.85 242.52,174.85 242.47,174.9 JWLBT.35
PCIE3_CTX_DRX_N: length 7.8
  BOTTOM w0.076: 99.73,106.26 99.73,106.24 99.76,106.21 99.76,105.48 99.65,105.37 99.65,104.86 99.65,104.85 99.65,104.83 99.68,104.73 99.68,104.54 99.65,104.45 99.65,104.2 99.79,103.72 99.79,103.61 99.86,103.34 UC1.D17
  BOTTOM w0.114: 99.73,106.26 99.73,108.03 100.87,109.18 100.87,109.68 100.76,109.79 CC18.2
PCIE3_CTX_DRX_P: length 7.8
  BOTTOM w0.076: 99.96,106.26 99.96,106.24 99.92,106.21 99.92,105.42 99.81,105.31 99.81,104.86 99.87,104.74 99.87,104.59 99.81,104.4 99.81,104.23 99.87,104.04 99.96,103.98 100.23,103.98 100.36,103.85 100.36,103.49 100.29,103.42 100.18,103.42 100.08,103.52 UC1.C17
  BOTTOM w0.114: 99.96,106.26 99.96,107.94 101.1,109.08 101.1,109.59 CC19.2
PCIE3_PTX_DRX_N2: length 15.7
  BOTTOM w0.076: 95.24,107.58 95.24,107.56 95.21,107.53 95.21,106.66 95.81,106.06 95.81,104.5 96.01,104.3 96.01,103.86 95.69,103.53 UC1.D24
  BOTTOM w0.114: CC90.2 95.21,117.34 95.21,116.85 96.28,115.78 v3(96.28,114.92) 96.28,113.81 95.24,112.77 95.24,107.58
PCIE3_PTX_DRX_P2: length 15.7
  BOTTOM w0.076: UC1.C24 95.77,103.99 95.85,104.07 95.85,104.23 95.65,104.43 95.65,105.99 95.05,106.6 95.05,107.53 95.01,107.56 95.01,107.58
  BOTTOM w0.114: CC23.2 94.98,117.13 94.98,116.76 v3(95.17,116.57) 96.06,115.68 96.06,113.9 95.91,113.75 95.74,113.75 95.5,113.51 95.5,113.34 95.01,112.86 95.01,112.12 94.9,112.01 94.9,111.66 95.01,111.55 95.01,111.2 94.9,111.09 94.9,110.74 95.01,110.63 95.01,110.29 94.9,110.17 94.9,109.83 95.01,109.71 95.01,109.37 94.9,109.25 94.9,108.91 95.01,108.79 95.01,108.45 94.9,108.33 94.9,107.99 95.01,107.87 95.01,107.58
PCIE4_CRX_DTX_N: length 67.2
  TOP w0.114: v3(55.05,110.14) 54.8,110.14 54.69,110.24 v3(54.69,112.1) 54.69,113.68 54.39,113.98 54.15,113.98 CL2.1
  IN1 w0.14: v3(55.05,110.14) 55.05,109.99 55.35,109.69 55.55,109.69 57.23,111.37 57.51,111.37 60.86,114.72 64.68,114.72 65.39,114.01 74.5,114.01 74.83,114.34 81.13,114.34 82.05,115.26 98.05,115.26 100.74,112.57 100.74,111.22 101.46,110.5 101.46,102.28 101.5,102.24 101.5,101.62 v3(101.08,101.2)
  BOTTOM w0.076: v3(101.08,101.2) 101.32,100.94 UC1.G15
PCIE4_CRX_DTX_N_C: length 4.3
  TOP w0.114: CL2.2 52.65,113.88 52.52,113.88 52.41,114 v3(52.41,115.43) 52.41,115.65 51.97,116.09 51.31,116.09 51.25,116.15 UL1.39
PCIE4_CRX_DTX_P: length 67.3
  TOP w0.114: v3(54.47,109.56) 54.59,109.67 54.59,110.02 54.46,110.15 v3(54.46,110.73) 54.46,113.58 54.29,113.76 54.06,113.76 53.91,113.61 CL1.1
  IN1 w0.14: v3(54.47,109.56) 54.58,109.67 55.02,109.67 55.25,109.44 55.66,109.44 57.33,111.11 57.61,111.11 60.97,114.47 64.57,114.47 65.28,113.76 74.61,113.76 74.94,114.09 81.24,114.09 82.15,115 97.95,115 100.49,112.46 100.49,111.11 101.21,110.39 101.21,106.57 101.05,106.41 101.05,106.01 101.21,105.85 101.21,105.34 101.13,105.26 101.13,105.26 101.05,105.18 101.05,104.76 101.13,104.68 101.13,104.68 101.21,104.6 101.21,104.18 101.13,104.1 101.13,104.1 101.05,104.02 101.05,103.6 101.13,103.52 101.13,103.52 101.21,103.44 101.21,103.02 101.13,102.94 101.13,102.94 101.05,102.86 101.05,102.45 101.13,102.37 101.13,102.37 101.21,102.29 101.21,101.96 v3(101.08,101.83)
  BOTTOM w0.076: v3(101.08,101.83) 101.32,101.59 UC1.F15
PCIE4_CRX_DTX_P_C: length 4.3
  TOP w0.114: CL1.2 52.68,113.65 52.43,113.65 52.18,113.9 v3(52.18,114.11) 52.18,115.56 51.87,115.86 51.37,115.86 51.26,115.75 UL1.38
PCIE4_CTX_C_DRX_N: length 68.9
  TOP w0.114: v3(54.13,116.85) 54,116.85 53.6,117.25 51.48,117.25 51.38,117.35 UL1.42
  IN1 w0.14: v3(54.13,116.85) 53.9,117.08 53.9,117.21 54.47,117.77 55.84,117.77 57.49,119.42 57.49,120.74 57.84,121.1 58.05,121.1 58.34,121.39 58.34,121.6 58.63,121.89 58.84,121.89 59.13,122.18 59.13,122.39 59.86,123.12 61.92,123.12 62.12,123.32 62.33,123.32 62.62,123.61 62.62,123.82 64.78,125.97 67.55,125.97 68.18,126.6 71.03,126.6 71.38,126.95 76.4,126.95 77.38,127.93 83.39,127.93 84.18,128.72 93.14,128.72 93.29,128.56 93.7,128.56 93.85,128.72 94.26,128.72 94.41,128.56 94.82,128.56 94.97,128.72 95.38,128.72 95.53,128.56 95.94,128.56 96.09,128.72 96.49,128.72 96.65,128.56 97.05,128.56 97.21,128.72 97.61,128.72 97.76,128.56 98.17,128.56 98.32,128.72 98.73,128.72 98.88,128.56 99.29,128.56 99.44,128.72 100.03,128.72 101.44,127.31 101.44,126.31 101.3,126.17 v3(101.17,126.17)
  BOTTOM w0.114: CC92.1 102.29,118.61 102.29,121.32 102.57,121.6 v3(102.57,124.63) 102.57,124.96 102.2,125.34 101.89,125.34 101.56,125.68 101.56,125.97 101.35,126.17 v3(101.17,126.17)
PCIE4_CTX_C_DRX_P: length 68.9
  TOP w0.114: v3(53.62,116.38) 53.62,116.91 53.51,117.02 52.45,117.02 52.34,116.91 51.99,116.91 51.88,117.02 51.44,117.02 51.38,116.95 UL1.41
  IN1 w0.14: v3(53.62,116.38) 53.65,116.41 53.65,117.31 54.36,118.02 55.73,118.02 57.23,119.53 57.23,120.85 59.76,123.37 61.81,123.37 64.67,126.23 67.44,126.23 68.07,126.86 70.93,126.86 71.28,127.2 76.29,127.2 77.27,128.18 83.29,128.18 84.08,128.97 100.14,128.97 101.69,127.41 101.69,126.44 v3(101.96,126.17)
  BOTTOM w0.114: v3(101.96,126.17) 101.78,125.99 101.78,125.77 101.99,125.57 102.29,125.57 102.8,125.06 v3(102.8,122.47) 102.8,121.51 102.52,121.23 102.52,119.01 CC93.1
PCIE4_CTX_DRX_N: length 15.1
  BOTTOM w0.076: UC1.B19 98.73,104.54 98.45,104.82 98.45,106.53 98.9,106.98 98.9,107.17 98.86,107.21 98.86,107.23
  BOTTOM w0.114: CC92.2 102.37,117.36 102.37,116.49 v3(101.62,115.75) 99.68,113.8 99.68,108.69 98.86,107.88 98.86,107.23
PCIE4_CTX_DRX_P: length 15.1
  BOTTOM w0.076: UC1.A19 98.61,105.08 98.61,106.47 99.06,106.91 99.06,107.17 99.09,107.21 99.09,107.23
  BOTTOM w0.114: CC93.2 102.6,117.11 v3(102.6,116.6) 102.6,116.4 102.37,116.17 102.37,115.99 102.12,115.75 102.03,115.75 101.95,115.75 101.7,115.5 101.7,115.33 101.46,115.08 101.37,115.08 101.28,115.08 101.04,114.84 101.04,114.66 100.8,114.42 100.71,114.42 100.62,114.42 99.9,113.7 99.9,113.47 100.03,113.34 100.03,113 99.9,112.87 99.9,112.53 100.03,112.4 100.03,112.06 99.9,111.93 99.9,111.59 100.03,111.46 100.03,111.12 99.9,110.99 99.9,108.6 99.09,107.79 99.09,107.23
PCIE4_PTX_DRX_N3: length 11.2
  BOTTOM w0.076: 94.27,107.4 94.27,107.38 94.3,107.35 94.3,106.78 95.31,105.77 95.31,105.04 95.24,104.96 UC1.A25
  BOTTOM w0.114: 94.27,107.4 94.27,107.7 94.15,107.82 94.15,108.16 94.27,108.28 94.27,108.62 94.15,108.73 94.15,109.08 94.27,109.19 94.27,109.54 94.15,109.65 94.15,109.99 94.27,110.11 94.27,110.45 94.15,110.57 94.15,110.91 94.27,111.03 94.27,111.37 94.15,111.49 94.15,111.83 94.27,111.94 v3(94.27,112.38) 94.27,113.34 94.81,113.89 94.81,114.38 94.62,114.57 CC24.2
PCIE4_PTX_DRX_P3: length 11.2
  BOTTOM w0.076: 94.49,107.4 94.49,107.39 94.46,107.36 94.46,106.85 95.47,105.83 95.47,104.91 95.12,104.56 UC1.B25
  BOTTOM w0.114: CC91.2 95.04,114.3 95.04,113.79 v3(94.88,113.63) 94.49,113.25 94.49,107.4
PCIE6_CRX_C_DTX_N: length 2
  TOP w0.114: UW1.8 48.69,33.82 48.77,33.9 48.77,34.79 CW10.2
PCIE6_CRX_C_DTX_P: length 2
  TOP w0.114: UW1.7 49.09,33.82 49,33.92 49,34.79 CW9.2
PCIE6_CRX_DTX_N: length 161.4
  TOP w0.114: CW10.1 48.7,36.29 48.7,36.81 47.96,37.54 47.96,37.8 v5(47.76,38)
  IN1 w0.14: v3(99.25,101.2) 99.44,101.38 99.74,101.38 100.12,101.76 100.12,110.04 99.96,110.2 99.96,112.24 97.71,114.48 82.68,114.48 81.76,113.55 75.16,113.55 74.74,113.13 73.6,113.13 72.93,112.46 72.14,112.46 71.89,112.71 68.56,112.71 68.32,112.47 59.78,112.47 57.74,110.43 57.43,110.43 46.28,99.28 46.28,98.26 38.84,90.82 38.84,85.34 31.55,78.05 31.55,72.68 34.22,70.02 34.22,57.42 32.95,56.15 32.95,39.5 36.22,36.23 44.63,36.23 47.25,38.85 47.68,38.85 47.89,38.65 47.89,38.13 v5(47.76,38)
  BOTTOM w0.076: v3(99.25,101.2) 99.49,100.94 UC1.G18
PCIE6_CRX_DTX_P: length 161.5
  TOP w0.114: CW9.1 48.93,36.44 48.93,36.9 v3(48.78,37.05) 48.19,37.64 48.19,37.86 48.31,37.98 v3(48.55,37.98)
  IN1 w0.14: v3(48.55,37.98) 48.45,37.98 48.14,38.29 48.14,38.75 47.79,39.11 47.14,39.11 46.85,38.81 46.65,38.81 46.35,38.51 46.35,38.31 46.06,38.02 45.86,38.02 45.56,37.72 45.56,37.52 45.26,37.22 45.07,37.22 44.77,36.93 44.77,36.73 44.53,36.49 44,36.49 43.85,36.64 43.43,36.64 43.28,36.49 42.86,36.49 42.71,36.64 42.29,36.64 42.14,36.49 41.72,36.49 41.56,36.64 41.14,36.64 40.99,36.49 40.57,36.49 40.42,36.64 40,36.64 39.85,36.49 36.33,36.49 33.2,39.61 33.2,56.05 34.47,57.32 34.47,70.12 31.81,72.79 31.81,77.94 39.1,85.23 39.1,90.71 46.54,98.16 46.54,99.18 57.54,110.17 57.84,110.17 59.89,112.22 68.42,112.22 68.66,112.46 71.78,112.46 72.04,112.21 73.03,112.21 73.7,112.88 74.85,112.88 75.27,113.3 81.86,113.3 82.79,114.23 97.6,114.23 99.7,112.13 99.7,110.1 99.86,109.94 99.86,101.86 99.63,101.64 99.45,101.64 v3(99.25,101.83)
  BOTTOM w0.076: v3(99.25,101.83) 99.49,101.59 UC1.F18
PCIE6_CTX_C_DRX_N: length 190.8
  TOP w0.114: v3(17.17,54.78) 17.33,54.62 17.33,54.14 20.25,51.22 23.37,51.22 25.3,49.29 25.3,44.01 32.95,36.36 43.36,36.36 46.16,39.16 49.79,39.16 51.42,37.53 51.42,35.24 v3(50.99,34.81) 50.38,34.2 50.38,33.96 50.29,33.87 UW1.4
  IN1 w0.14: v3(100.32,127.11) 100.13,127.29 100.13,127.62 99.77,127.98 84.26,127.98 83.62,127.34 77.55,127.34 76.64,126.43 71.6,126.43 71.25,126.08 68.39,126.08 67.76,125.45 66.75,125.45 66.08,124.79 65.9,124.79 64.3,123.18 63.63,123.18 62.79,122.34 61.85,122.34 61.24,121.73 60.56,121.73 49.71,110.89 49.71,110.2 36.91,97.4 35.06,97.4 33.99,96.33 32.65,96.33 23.93,87.62 23.93,86.35 20.73,83.15 20.73,66.69 19.54,65.5 19.54,57.24 18.65,56.35 18.29,56.35 17.33,55.39 17.33,54.93 v3(17.17,54.78)
  BOTTOM w0.114: v3(100.32,127.11) 100.11,126.9 100.11,126.63 100.32,126.42 100.32,125.36 100.82,124.86 100.82,118.81 CC20.1
PCIE6_CTX_C_DRX_P: length 190.8
  TOP w0.114: v3(17.99,54.78) 17.79,54.78 17.56,54.55 17.56,54.24 20.34,51.45 23.47,51.45 25.53,49.39 25.53,44.1 33.04,36.59 43.27,36.59 46.06,39.38 49.88,39.38 51.64,37.63 51.64,35.14 50.61,34.11 50.61,33.99 50.69,33.91 UW1.3
  IN1 w0.14: v3(17.99,54.78) 17.79,54.78 17.58,54.98 17.58,55.29 18.4,56.1 18.76,56.1 19.79,57.14 19.79,65.39 20.99,66.58 20.99,83.04 24.19,86.24 24.19,87.51 32.75,96.08 34.1,96.08 35.16,97.14 37.02,97.14 49.97,110.09 49.97,110.78 60.67,121.48 61.35,121.48 61.96,122.09 62.9,122.09 63.73,122.93 64.4,122.93 66.01,124.53 66.19,124.53 66.85,125.2 67.87,125.2 68.5,125.83 71.35,125.83 71.7,126.18 76.74,126.18 77.66,127.09 83.73,127.09 84.36,127.73 99.67,127.73 99.88,127.52 99.88,127.32 99.67,127.11 v3(99.53,127.11)
  BOTTOM w0.114: v3(99.53,127.11) 99.76,127.11 99.88,126.99 99.88,126.53 100.09,126.32 100.09,125.27 100.59,124.77 v3(100.59,120.44) 100.59,118.81 CC21.1
PCIE6_CTX_DRX_N: length 15.6
  BOTTOM w0.076: UC1.D20 98.16,103.46 98.46,103.75 98.46,104.11 98.24,104.32 98.24,106.84 98.28,106.88 98.28,106.9
  BOTTOM w0.114: 98.28,106.9 98.28,107.89 99.04,108.65 99.04,114.09 v3(99.54,114.58) 100.95,115.99 100.95,117.36 CC20.2
PCIE6_CTX_DRX_P: length 15.7
  BOTTOM w0.076: 98.05,106.9 98.05,106.88 98.08,106.84 98.08,104.47 97.87,104.26 97.87,103.82 97.95,103.74 98.08,103.74 98.16,103.82 UC1.C20
  BOTTOM w0.114: 98.05,106.9 98.05,107.98 98.81,108.75 98.81,114.18 v3(100.31,115.68) 100.72,116.09 100.72,117.11 CC21.2
PCIE_CRX_C_GTX_N0: length 13.2
  TOP w0.114: v1(144.51,138.36) 144.73,138.14 144.98,138.14 145.32,137.8 145.32,137.23 144.71,136.62 143.43,136.62 141.53,134.71 140.16,134.71 137.32,131.87 137.32,131.59 CV2.1
  BOTTOM w0.102: v1(144.51,138.36) 144.11,137.96 UV1.Y32
PCIE_CRX_C_GTX_N1: length 11.1
  TOP w0.114: CV4.1 135.19,131.75 135.19,132.17 139.41,136.39 141.03,136.39 141.48,136.84 141.48,137.07 141.73,137.31 142.06,137.31 v1(142.25,137.5)
  BOTTOM w0.084: v1(142.25,137.5) 142.34,137.5 UV1.W32
PCIE_CRX_C_GTX_N2: length 11.9
  TOP w0.114: v1(141.05,137.61) 140.98,137.53 139.27,137.53 137.22,135.47 136.61,135.47 134.75,133.61 134.75,133.14 134.45,132.83 134.15,132.83 133.13,131.81 133.13,131.59 CV6.1
  BOTTOM w0.084: v1(141.05,137.61) 141.41,137.96 UV1.U32
PCIE_CRX_C_GTX_N3: length 17.1
  TOP w0.114: CV8.1 131.04,131.66 131.04,131.92 131.11,131.98 132.03,132.91 132.96,132.91 134.77,134.72 134.77,135.96 135.45,136.64 136.92,136.64 138.54,138.27 141.21,138.27 141.51,138.56 141.51,139.41 141.76,139.66 142,139.66 v1(142.15,139.81)
  BOTTOM w0.084: UV1.U29 v1(142.15,139.81)
PCIE_CRX_C_GTX_P0: length 13.1
  TOP w0.114: CV1.1 136.84,131.33 137.09,131.59 137.09,131.97 140.06,134.94 141.43,134.94 143.34,136.84 144.62,136.84 145.09,137.32 145.09,137.71 144.89,137.91 144.64,137.91 144.5,137.77 v1(144.5,137.53)
  BOTTOM w0.084: UV1.Y33 144.13,137.16 v1(144.5,137.53)
PCIE_CRX_C_GTX_P1: length 11.1
  TOP w0.114: v1(142.25,136.92) 142.08,137.09 141.83,137.09 141.71,136.97 141.71,136.74 141.13,136.16 139.5,136.16 136.65,133.3 136.65,133.12 136.41,132.89 136.23,132.89 136,132.65 136,132.48 135.76,132.24 135.59,132.24 135.42,132.08 135.42,131.58 CV3.1
  BOTTOM w0.084: UV1.W33 142.8,136.92 142.63,136.74 142.42,136.74 v1(142.25,136.92)
PCIE_CRX_C_GTX_P2: length 11.9
  TOP w0.114: CV5.1 133.53,131.33 133.36,131.51 133.36,131.71 134.25,132.6 134.54,132.6 134.98,133.04 134.98,133.52 136.71,135.24 137.31,135.24 139.37,137.3 140.73,137.3 v1(141.04,137)
  BOTTOM w0.084: v1(141.04,137) 141.04,137.06 141.28,137.3 141.46,137.3 UV1.U33
PCIE_CRX_C_GTX_P3: length 17.1
  TOP w0.114: v1(142.16,139.16) 142.16,139.32 142.04,139.44 141.86,139.44 141.74,139.31 141.74,138.47 141.31,138.04 138.64,138.04 137.01,136.41 135.54,136.41 135,135.87 135,134.63 133.08,132.71 132.16,132.71 131.27,131.82 131.27,131.66 CV7.1
  BOTTOM w0.102: UV1.U30 141.6,139.29 141.88,139.01 142.01,139.01 v1(142.16,139.16)
PCIE_CRX_GTX_N0: length 62.9
  TOP w0.114: v3(136.41,124.09) 136.21,124.09 136,124.31 136,126.53 137.27,127.8 137.27,130.24 137.45,130.42 CV2.2
  IN3 w0.114: v3(96.51,102.47) 96.31,102.47 96.2,102.58 96.2,103.01 96.32,103.14 96.32,103.47 96.2,103.59 96.2,103.92 96.32,104.05 96.32,104.38 96.2,104.51 96.2,105.58 96.81,106.19 96.81,111.9 98.89,113.98 99.18,113.98 102.27,117.08 106.9,117.08 108.22,118.4 130.99,118.4 135.97,123.38 135.97,123.84 136.23,124.09 v3(136.41,124.09)
  BOTTOM w0.076: UC1.E22 96.73,102.24 v3(96.51,102.47)
PCIE_CRX_GTX_N1: length 62
  TOP w0.114: CV4.2 135.03,130.16 135.03,128.18 132.98,126.12 132.98,124.12 v3(132.74,123.89)
  IN3 w0.114: v3(95.59,101.83) 95.35,102.08 95.05,102.08 94.72,102.4 94.72,103.07 95.21,103.55 95.21,106.02 95.71,106.52 95.71,112.11 98.5,114.9 98.69,114.9 101.78,118 106.53,118 107.91,119.37 116.06,119.37 116.62,119.93 129.6,119.93 133,123.33 133,123.63 v3(132.74,123.89)
  BOTTOM w0.076: UC1.F25 95.36,101.59 v3(95.59,101.83)
PCIE_CRX_GTX_N2: length 61.4
  TOP w0.114: v3(130.79,123.92) 131.07,124.2 131.07,126.4 133.2,128.53 133.2,130.09 CV6.2
  IN3 w0.114: v3(92.85,102.47) 93.25,102.86 93.25,103.95 93.73,104.43 93.73,105.94 94.8,107.01 94.8,113.23 97.23,115.66 98.46,115.66 101.5,118.71 106.2,118.71 107.6,120.11 111.89,120.11 113.01,121.22 117.68,121.22 118.24,120.66 128.5,120.66 131.04,123.2 131.04,123.66 v3(130.79,123.92)
  BOTTOM w0.076: v3(92.85,102.47) 93.07,102.24 UC1.E28
PCIE_CRX_GTX_N3: length 65.5
  TOP w0.114: v3(129.78,123.66) 129.57,123.46 129.57,123.2 129.34,122.98 128.58,122.98 128.15,123.41 128.15,126.4 130.97,129.22 130.97,130.16 CV8.2
  IN3 w0.114: v3(92.85,101.83) 92.6,101.58 92.49,101.58 92.32,101.76 92.32,102.74 92.64,103.06 92.64,105.48 94.29,107.13 94.29,113.45 97.03,116.19 98.28,116.19 101.73,119.64 105.34,119.64 105.55,119.85 106.38,119.85 107.19,120.66 111.66,120.66 112.88,121.88 114.77,121.88 115.08,122.19 118.24,122.19 119.23,121.2 128.28,121.2 129.62,122.54 129.62,123.51 v3(129.78,123.66)
  BOTTOM w0.076: UC1.E30 v3(92.85,101.83)
