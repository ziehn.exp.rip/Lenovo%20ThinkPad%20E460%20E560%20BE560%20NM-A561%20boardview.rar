# Allegro board Lenovo ThinkPad E460 E560 BE560 NM-A561 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_DQS#1: length 73
  IN3 w0.076: v3(65.93,83.13) 65.69,83.37 65.69,83.58 65.51,83.76 65.01,83.76 64.54,83.29 64.54,82.28 64.49,82.23 64.49,82.2 64.44,82.16 64.44,82.11 64.43,82.09 64.43,82.08
  IN3 w0.114: v5(67.13,35.01) 67.4,34.74 67.59,34.74 67.76,34.9 67.76,36.04 67.39,36.41 67.39,38.54 65.41,40.52 63.92,40.52 62,42.43 61.62,42.43 60.78,43.27 60.78,47.6 60.22,48.16 60.22,49.12 59.34,50 59.34,62.93 59.23,63.04 59,63.04 58.77,63.27 58.77,63.86 59,64.09 59.23,64.09 59.34,64.2 59.34,64.62 59.23,64.73 59,64.73 58.77,64.96 58.77,65.55 59,65.78 59.23,65.78 59.34,65.89 59.34,66.31 59.23,66.43 59,66.43 58.77,66.66 58.77,67.24 59,67.47 59.23,67.47 59.34,67.58 59.34,68 59.23,68.12 59,68.12 58.77,68.35 58.77,68.93 59,69.16 59.23,69.16 59.34,69.28 59.34,69.69 59.23,69.81 59,69.81 58.77,70.04 58.77,70.62 59,70.85 59.23,70.85 59.34,70.97 59.34,71.39 59.23,71.5 59,71.5 58.77,71.73 58.77,72.31 59,72.54 59.23,72.54 59.34,72.66 59.34,72.99 60.51,74.16 60.51,75.94 64.43,79.85 64.43,82.08
  BOTTOM w0.076: v3(65.93,83.13) 65.67,83.38 65.67,83.79 65.75,83.87 65.75,84.11 65.67,84.19 65.67,84.3 65.77,84.4 65.88,84.4 66.06,84.57 66.05,84.63 66.05,84.68 66.1,84.72 66.33,84.72 66.41,84.64 66.65,84.64 66.73,84.72 66.98,84.72 67.05,84.64 67.3,84.64 67.38,84.72 67.49,84.72 68.35,85.58 68.61,85.58 68.77,85.74 69.16,85.74 69.27,85.69 69.49,85.69 69.6,85.74 69.81,85.74 69.89,85.71 70.18,85.71 70.37,85.8 70.37,85.8 70.45,85.88 70.45,86.09 70.5,86.14 UC1.AT69
  BOTTOM w0.127: JDIMM1.27 67.72,36.09 67.89,35.91 67.89,35.02 67.66,34.79 67.34,34.79 v5(67.13,35.01)
DDR_A_DQS#2: length 66.2
  IN3 w0.076: v5(67.61,76.33) 67.86,76.57 68.03,76.57 68.15,76.44 68.15,74.92 67.75,74.51 66.63,74.51 66.51,74.39 66.48,74.39 66.47,74.37
  IN3 w0.114: 66.47,74.37 63.51,71.41 63.51,55.93 68.44,51 68.44,48.07 68.6,47.91 68.6,43.46 69.82,42.24 70.03,42.24 72.71,39.56 72.71,36.43 73.15,35.99 73.15,34.8 73.51,34.44 74.01,34.44 v3(74.29,34.15)
  BOTTOM w0.076: UC1.BA64 73.48,83.52 73.43,83.56 73.28,83.56 73.27,83.55 73.21,83.42 73.21,83.2 73.24,83.12 73.24,82.85 73.19,82.72 73.19,82.61 73.19,82.59 73.24,82.48 73.24,82.11 73.08,81.95 73.08,81.2 72.12,80.23 69.11,80.23 68.76,79.89 68.76,77.17 68.12,76.53 67.81,76.53 v5(67.61,76.33)
  BOTTOM w0.127: JDIMM1.45 73.12,35.92 73.27,35.76 73.27,34.69 73.55,34.41 74.03,34.41 v3(74.29,34.15)
DDR_A_DQS#3: length 66.8
  IN3 w0.076: v3(73.52,77.88) 73.27,78.13 73.17,78.13 72.29,77.25 72.29,75.5 70.6,73.81 70.6,72.4 70.45,72.26 70.45,72.23 70.45,72.22
  IN3 w0.114: 70.45,72.22 67.87,69.65 67.87,58.85 75.7,51.02 75.7,42.61 77.02,41.29 77.02,39.21 79.69,36.54 79.69,33.22 79.23,32.76 79.23,31.89 79.41,31.71 79.57,31.71 v5(79.85,31.99)
  BOTTOM w0.076: UC1.AY60 75.93,83.89 76.17,83.64 76.26,83.46 76.26,83.17 76.23,83.09 76.23,82.88 76.28,82.77 76.28,82.75 76.28,82.58 76.22,82.42 76.22,82.16 76.39,81.99 76.39,81.55 76.16,81.32 76.16,81.19 75.92,80.95 75.92,80.9 75.92,80.85 75.75,80.67 75.69,80.67 75.69,80.67 75.64,80.67 75.47,80.5 75.47,80.45 75.47,80.39 75.29,80.22 75.24,80.22 75.19,80.22 75.01,80.05 75.01,79.99 75.01,79.99 75.01,79.94 74.84,79.76 74.79,79.76 74.73,79.76 74.56,79.59 74.56,79.54 74.56,79.48 74.39,79.31 74.33,79.31 74.33,79.31 74.28,79.31 74.18,79.22 74.18,78.29 73.98,78.09 73.73,78.09 v3(73.52,77.88)
  BOTTOM w0.127: v5(79.85,31.99) 79.72,31.87 78.96,31.87 78.43,31.33 78.43,30.16 78.22,29.95 JDIMM1.62
DDR_A_DQS#4: length 66.1
  IN3 w0.076: v3(88.25,77.79) 88.25,77.66 88.42,77.49 88.8,77.49 89.11,77.18 89.11,76.22 88.88,75.99 88.88,71.64 89.36,71.16 89.36,70.21 89.38,70.19 89.38,70.17
  IN3 w0.114: v3(102.25,34.92) 102.25,34.75 102.06,34.56 101.81,34.56 101.74,34.63 101.74,37.33 103.71,39.3 103.71,40.96 106.25,43.49 106.25,53.08 105.71,53.62 105.49,53.62 105.19,53.91 105.19,54.66 103.1,56.75 100.52,56.75 89.38,67.89 89.38,70.17
  BOTTOM w0.076: v3(88.25,77.79) 88.25,77.65 88.1,77.51 87.94,77.51 87.82,77.63 87.82,79.99 88.01,80.18 88.01,81.32 87.84,81.5 87.84,81.85 87.97,81.98 87.97,82.48 87.92,82.59 87.91,82.61 87.91,82.72 87.97,82.85 87.97,83.12 87.93,83.2 87.93,83.42 87.96,83.48 88.01,83.56 88.07,83.64 88.14,83.64 88.28,83.59 88.28,83.49 UC1.BA38
  BOTTOM w0.127: v3(102.25,34.92) 102.25,34.7 102.35,34.59 102.59,34.59 102.71,34.72 102.71,35.94 102.52,36.13 JDIMM1.135
DDR_A_DQS#5: length 68.6
  IN3 w0.076: 93.24,70.17 93.24,70.19 93.26,70.21 93.26,70.77 91.21,72.82 91.21,75.43 91.45,75.66 91.62,75.66 v3(91.8,75.84)
  IN3 w0.114: 93.24,70.17 93.24,69.5 102.14,60.61 104.71,60.61 111.17,54.15 111.17,51.44 111.67,50.94 111.67,42.39 109.96,40.68 109.96,40.06 107.71,37.8 107.71,31.25 v3(107.59,31.13)
  BOTTOM w0.076: v3(91.8,75.84) 91.8,75.73 91.6,75.53 91.37,75.53 91.08,75.82 91.08,81.28 90.95,81.41 90.95,82.44 91,82.56 91,82.6 91,82.61 91,82.77 90.95,82.88 90.95,83.09 90.99,83.17 90.99,83.45 90.94,83.56 90.86,83.7 90.73,83.75 90.67,83.75 90.65,83.77 UC1.AY34
  BOTTOM w0.127: JDIMM1.152 107.62,28.95 107.62,30 107.83,30.21 107.83,30.89 v3(107.59,31.13)
DDR_A_DQS#6: length 72.5
  IN3 w0.076: 98.57,70.31 98.56,70.32 98.53,70.32 97.66,71.19 96.6,71.19 94.49,73.29 94.49,77.2 94.09,77.61 93.86,77.61 v3(93.68,77.79)
  IN3 w0.114: v3(112.81,34.58) 113.03,34.36 113.03,33.65 113.41,33.27 113.96,33.27 114.37,33.68 114.37,35.54 114,35.91 114,36.15 114.33,36.49 114.33,36.87 116.16,38.7 116.16,40.88 117.96,42.68 117.96,43.63 118.5,44.16 118.5,44.49 117.96,45.02 117.96,45.41 118.42,45.86 118.42,49.57 118.22,49.77 118.22,52.24 115.49,54.96 115.49,55.9 106.51,64.88 104,64.88 103.26,65.62 103.26,66.02 102.95,66.33 102.54,66.33 102.32,66.56 102.32,66.94 101.96,67.3 101.58,67.3 101.4,67.48 101.4,67.86 101.07,68.19 100.69,68.19 100.15,68.73 100.15,69.11 99.68,69.58 99.3,69.58 98.57,70.31
  BOTTOM w0.076: v3(93.68,77.79) 93.53,77.64 93.34,77.64 93.26,77.73 93.26,80.99 92.92,81.32 92.92,81.33 92.92,81.73 92.95,81.76 92.95,82.48 92.9,82.59 92.9,82.61 92.9,82.72 92.95,82.85 92.95,83.12 92.91,83.2 92.91,83.42 92.94,83.48 93.01,83.6 93.06,83.66 93.21,83.64 93.23,83.49 UC1.BA30
  BOTTOM w0.127: JDIMM1.169 112.72,35.45 112.93,35.23 112.93,34.7 v3(112.81,34.58)
DDR_A_DQS#7: length 83.1
  IN3 w0.114: v3(97.26,75.84) 97.4,75.7 98.71,75.7 99.12,75.3 99.12,74.11 99.42,73.81 103.02,73.81 106.64,70.19 107.87,70.19 109.03,69.04 109.19,69.04 109.41,69.26 109.73,69.26 110.15,68.84 110.15,68.52 109.93,68.3 109.93,68.14 110.69,67.37 110.85,67.37 111.02,67.55 111.35,67.55 111.76,67.13 111.76,66.81 111.59,66.64 111.59,66.47 111.89,66.18 112.05,66.18 112.29,66.42 112.62,66.42 113.03,66.01 113.03,65.68 112.79,65.44 112.79,65.28 113.08,64.98 113.25,64.98 113.49,65.22 113.82,65.22 114.23,64.81 114.23,64.49 113.99,64.24 113.99,64.08 115.48,62.59 115.64,62.59 115.88,62.83 116.21,62.83 116.62,62.42 116.62,62.09 116.38,61.85 116.38,61.7 126.02,52.05 126.02,51.5 125.72,51.19 125.34,51.19 125.15,51 125.15,50.73 125.34,50.54 125.72,50.54 126.02,50.24 126.02,41.27 120.93,36.18 120.93,34.83 120.55,34.46 119.82,34.46 118.29,32.93 118.29,32.64 118.38,32.55 118.76,32.55 v5(118.97,32.76)
  BOTTOM w0.076: v3(97.26,75.84) 97.26,75.73 97.05,75.52 96.84,75.52 96.35,76.02 96.35,80.52 96.15,80.73 96.15,81.93 95.93,82.15 95.93,82.44 95.99,82.55 95.99,82.77 95.93,82.88 95.93,83.09 95.97,83.17 95.97,83.45 95.92,83.56 95.84,83.7 95.71,83.75 95.65,83.75 95.63,83.77 UC1.AY26
  BOTTOM w0.127: v5(118.97,32.76) 118.97,32.76 118.77,32.56 118.45,32.56 118.01,32.13 118.01,30.39 118.01,30.3 117.82,30.11 117.82,28.95 JDIMM1.186
DDR_A_MA0: length 63.9
  IN3 w0.076: 80.55,72.38 80.6,72.43 80.6,74.06 80.17,74.49 80.17,77.6 v3(79.5,78.28)
  IN3 w0.165: v5(90.3,31.66) 90.3,32.13 90.48,32.3 90.48,36.31 91.22,37.05 91.22,42.79 90.79,43.22 90.79,49.77 89.77,50.79 89.77,53.41 83.67,59.5 82.96,59.5 82.76,59.3 82.55,59.3 79.91,61.93 79.91,63.08 79.1,63.9 79.1,70.45 78.95,70.6 78.95,70.78 79.2,71.03 79.2,71.36 79.36,71.52 79.69,71.52 80.55,72.38
  BOTTOM w0.076: v3(79.5,78.28) 79.87,78.65 79.87,78.73 80.38,79.24 80.38,79.83 80.78,80.24 80.78,80.94 81.36,81.52 81.36,82 81.18,82.18 81.18,82.44 81.21,82.52 81.22,82.53 81.24,82.56 81.24,82.7 81.17,82.93 81.17,83.06 81.25,83.28 81.45,83.48 UC1.AY50
  BOTTOM w0.178: v5(90.3,31.66) 91.42,30.55 91.42,28.95 JDIMM1.98
DDR_A_MA1: length 62.8
  IN3 w0.076: v3(79.5,77.63) 80.02,77.11 80.02,74.26 80.12,74.16
  IN3 w0.165: 80.12,74.16 80.32,73.95 80.32,73.78 80.12,73.57 80.12,73.37 80.32,73.17 80.32,72.61 80.14,72.43 79.86,72.43 79.71,72.28 79.71,72 79.51,71.79 79.2,71.79 78.9,71.49 78.9,71.19 78.8,71.08 78.54,71.08 78.37,70.91 78.37,70.75 78.64,70.47 78.64,63.72 78.87,63.49 78.87,63.31 78.64,63.08 78.64,62.57 78.72,62.5 78.85,62.5 79.16,62.8 79.36,62.8 79.46,62.7 79.46,62.11 79.36,62.01 79.36,61.86 82.71,58.51 82.94,58.51 83.03,58.6 83.03,58.93 83.14,59.04 83.48,59.04 83.73,58.8 83.73,58.61 83.83,58.51 84.03,58.51 89.31,53.23 89.31,50.26 89.42,50.15 89.77,50.15 90.2,49.72 90.2,49.57 90.09,49.45 89.43,49.45 89.31,49.34 89.31,49.14 89.64,48.81 89.64,48.55 89.43,48.34 89.43,48.06 89.77,47.72 89.77,47.49 89.43,47.14 89.43,46.88 89.54,46.76 90.24,46.76 90.33,46.67 90.33,46.24 90.15,46.07 89.54,46.07 89.43,45.95 89.43,45.72 89.72,45.43 89.72,45.25 89.43,44.96 89.43,44.78 89.64,44.57 89.64,44.39 89.43,44.17 89.43,44.02 89.67,43.78 89.67,43.6 89.44,43.37 89.44,43.19 89.52,43.11 90.26,43.11 90.63,42.74 90.63,42.53 90.51,42.41 89.59,42.41 89.43,42.25 89.43,41.94 89.59,41.77 90.63,41.77 90.76,41.65 90.76,41.23 90.28,40.74 90.28,40.25 90.39,40.13 90.6,40.13 90.73,39.99 v5(90.73,39.11)
  BOTTOM w0.076: UC1.BB50 81.52,82.26 81.52,81.45 81.02,80.94 81.02,80.23 80.56,79.77 80.56,79.18 80.13,78.75 80.13,78.54
  BOTTOM w0.102: 80.13,78.54 80.13,78.16 79.6,77.63 v3(79.5,77.63)
  BOTTOM w0.178: v5(90.73,39.11) 91.12,38.72 JDIMM1.97
DDR_A_MA2: length 63.9
  IN3 w0.076: v3(79.98,79.41) 79.22,79.41 78.7,78.88 78.7,73.4 76.62,71.32 76.62,71.07
  IN3 w0.165: 76.62,71.07 76.62,62.09 87.05,51.66 87.05,49.52 86.49,48.97 86.49,48.08 87.09,47.48 87.09,45.97 87.57,45.5 87.57,39.45 88.8,38.22 88.8,34.05 89.13,33.72 89.13,31.51 v5(90.28,30.37)
  BOTTOM w0.076: UC1.AY51 81.05,83.73 81.05,83.23 81,83.07 81,82.93 81.06,82.71 81.06,82.59 81.02,82.48 81.02,82.11 81.19,81.94 81.19,81.59 80.52,80.91 80.52,80.21 79.98,79.67 v3(79.98,79.41)
  BOTTOM w0.178: v5(90.28,30.37) 90.82,29.83 90.82,28.95 JDIMM1.96
DDR_A_MA3: length 63.5
  IN3 w0.076: 79.86,74.01 79.86,75.96 v3(79.5,76.33)
  IN3 w0.165: 79.86,74.01 79.53,73.67 79.53,73.47 79.89,73.12 79.89,72.91 77.93,70.96 77.93,70.73 78.19,70.47 78.19,62.4 78.55,62.04 78.75,62.04 78.9,61.89 78.9,61.69 82.54,58.05 82.73,58.05 82.86,57.93 82.86,57.73 82.97,57.62 83.2,57.62 83.62,58.05 83.86,58.05 84.18,57.72 84.18,57.62 84.06,57.49 83.67,57.11 83.67,56.92 83.98,56.61 84.16,56.61 84.64,57.09 84.82,57.09 85.15,56.76 85.15,56.6 85,56.45 84.66,56.12 84.66,55.93 84.98,55.62 85.15,55.62 85.63,56.1 85.81,56.1 86.11,55.79 86.11,55.59 85.63,55.11 85.63,54.96 85.97,54.62 86.13,54.62 86.61,55.11 86.8,55.11 87.1,54.8 87.1,54.61 86.62,54.13 86.62,53.97 86.96,53.63 87.12,53.63 87.6,54.12 87.79,54.12 88.09,53.81 88.09,53.62 87.61,53.14 87.61,52.98 87.95,52.64 88.1,52.64 88.53,53.08 88.73,53.08 88.86,52.95 88.86,52.41 88.6,52.15 88.6,51.99 88.87,51.72 88.87,50.07 89.06,49.87 89.06,49.72 88.87,49.53 88.87,48.95 88.98,48.83 88.98,47.87 89.16,47.69 89.16,47.51 88.98,47.33 88.98,46.67 89.19,46.47 89.19,46.34 88.98,46.14 88.98,43.02 89.19,42.81 89.19,42.64 88.98,42.43 88.98,41.54 89.2,41.33 89.59,41.33 89.82,41.1 v5(89.82,40.1)
  BOTTOM w0.076: 80.34,78.54 80.34,78.67 80.74,79.07 80.74,79.71 81.34,80.32 81.34,81.03 81.69,81.38 81.69,82.16 81.72,82.18 81.72,82.57 81.45,82.84 UC1.BA50
  BOTTOM w0.102: v3(79.5,76.33) 80.34,77.17 80.34,78.54
  BOTTOM w0.178: v5(89.82,40.1) 90.18,39.74 90.18,38.83 90.52,38.48 JDIMM1.95
DDR_A_MA4: length 63.9
  IN3 w0.076: 77.15,73.73 76.43,73.01 75.88,73.01 74.39,71.53 74.39,70.17
  IN3 w0.084: 77.15,73.73 77.15,76.5 v3(78.28,77.63)
  IN3 w0.165: v5(88.58,32.02) 87.97,32.02 87.59,31.64 86.93,31.64 86.05,32.52 86.05,37.8 84.33,39.52 84.33,42.34 83.03,43.64 83.03,50.57 82.37,51.23 82.37,52.81 74.39,60.78 74.39,70.17
  BOTTOM w0.076: UC1.BB52 80.02,82.24 80.02,80.48 78.76,79.21 78.76,78.78 78.68,78.71 78.68,78.64
  BOTTOM w0.102: v3(78.28,77.63) 78.68,78.03 78.68,78.64
  BOTTOM w0.178: v5(88.58,32.02) 89.62,30.97 JDIMM1.92
DDR_A_MA5: length 63.6
  IN3 w0.076: 78.95,73.34 78.95,75.13 v3(79.5,75.68)
  IN3 w0.165: 78.95,73.34 78.95,72.91 78.75,72.71 78.44,72.71 78.26,72.53 78.26,72.23 78.11,72.07 77.78,72.07 77.58,71.87 77.58,71.54 77.45,71.41 77.15,71.41 76.97,71.24 76.97,70.75 77.27,70.45 77.27,70.27 77.06,70.06 77.06,69.87 77.27,69.66 77.27,69.48 77.06,69.27 77.06,69.09 77.27,68.87 77.27,68.7 77.06,68.48 77.06,68.3 77.27,68.09 77.27,67.93 77.07,67.73 77.07,67.53 77.27,67.32 77.27,67.12 77.07,66.92 77.07,66.74 77.27,66.54 77.27,66.33 77.06,66.12 77.06,65.94 77.27,65.72 77.27,65.55 77.06,65.33 77.06,65.15 77.27,64.94 77.27,64.71 77.06,64.5 77.06,64.31 77.27,64.1 77.27,63.87 77.06,63.66 77.06,63.47 77.27,63.26 77.27,62.96 77.06,62.74 77.06,62.27 87.97,51.37 87.97,51.02 87.86,50.91 87.6,50.91 87.51,50.81 87.51,50.33 87.63,50.21 87.86,50.21 87.97,50.1 87.97,49.6 87.88,49.51 87.6,49.51 87.51,49.42 87.51,48.93 87.86,48.58 87.86,47.89 88.09,47.66 88.09,45.61 88.01,45.53 88.01,39.87 88.14,39.74 88.47,39.74 88.6,39.61 88.6,39.05 89.28,38.37 90.16,38.37 90.3,38.23 90.3,37.78 90.19,37.67 89.41,37.67 89.29,37.56 89.29,37.3 89.57,37.02 89.57,36.74 89.29,36.46 89.29,36.31 89.57,36.03 89.57,35.78 89.29,35.5 89.29,35.17 v5(89.44,35.02)
  BOTTOM w0.076: UC1.BA51 80.56,83.09 80.56,82.87 80.56,82.85 80.55,82.85 80.55,82.85 80.52,82.76 80.52,82.56 80.55,82.47 80.55,82.11 80.36,81.91 80.36,80.34 79.09,79.08 79.09,78.57
  BOTTOM w0.102: v3(79.5,75.68) 79.09,76.08 79.09,78.57
  BOTTOM w0.178: v5(89.44,35.02) 89.32,35.14 JDIMM1.91
DDR_A_MA6: length 64.2
  IN3 w0.076: 76.94,73.85 76.41,73.32 75.7,73.32 74.15,71.77 74.15,70.37 73.95,70.17
  IN3 w0.084: v3(78.28,78.28) 77.4,77.4 77.4,77.21 76.94,76.75 76.94,73.85
  IN3 w0.165: 73.95,70.17 73.95,60.59 81.92,52.62 81.92,51.05 82.58,50.39 82.58,43.46 83.88,42.16 83.88,39.34 85.61,37.61 85.61,32.26 87.14,30.72 v5(88.7,30.72)
  BOTTOM w0.076: UC1.BA52 80.12,82.76 79.86,82.5 79.86,80.55 78.59,79.28 78.59,78.86 78.48,78.74 78.48,78.48 v3(78.28,78.28)
  BOTTOM w0.178: v5(88.7,30.72) 89.02,30.41 JDIMM1.90
DDR_A_MA7: length 66.2
  IN3 w0.076: 77.36,73.65 74.84,71.13 74.84,70.93
  IN3 w0.084: 77.36,73.65 77.36,75.41 v3(78.28,76.33)
  IN3 w0.165: v5(88.53,33.31) 87.83,32.62 87.02,32.62 86.5,33.14 86.5,37.98 84.77,39.71 84.77,42.52 84.29,43 84.29,45.27 83.57,45.99 83.57,46.75 84.11,47.28 84.11,48.51 83.66,48.96 83.66,51.29 82.94,52.01 82.94,53.25 74.84,61.35 74.84,70.93
  BOTTOM w0.076: UC1.AW52 80.22,84.1 79.9,83.78 79.9,83.23 79.69,83.02 79.69,80.61 78.43,79.35 78.43,79 77.88,78.46 77.88,76.72 v3(78.28,76.33)
  BOTTOM w0.178: JDIMM1.86 87.82,28.95 87.82,30.31 87.82,30.89 87.82,32.61 v5(88.53,33.31)
DDR_A_MA8: length 63.9
  IN3 w0.076: 77.45,70.91 79.23,72.69 79.23,74.11 v3(79.5,74.38)
  IN3 w0.165: v5(89.77,33.77) 89.29,34.25 89.29,34.43 89.39,34.53 89.9,34.53 90.02,34.66 90.02,37.05 90.15,37.17 90.61,37.17 90.76,37.33 90.76,38.42 90.18,39 90,39 89.82,38.83 89.46,38.83 89.06,39.23 89.06,39.64 89.29,39.87 89.29,40.58 89.13,40.73 88.7,40.73 88.54,40.9 88.54,47.85 88.31,48.08 88.31,48.36 88.41,48.46 88.41,48.72 88.22,48.91 88.22,49.21 88.42,49.42 88.42,51.54 77.73,62.23 77.73,70.47 77.45,70.75 77.45,70.91
  BOTTOM w0.076: UC1.AY52 80.32,83.54 80.32,83.27 80.36,83.17 80.36,83.17 80.39,83.09 80.39,82.88 80.35,82.79 80.35,82.54 80.35,82.53 80.39,82.44 80.39,82.18 80.19,81.98 80.19,80.41 78.92,79.14 78.92,78.71 78.89,78.68 78.89,78.53
  BOTTOM w0.102: v3(79.5,74.38) 78.89,74.99 78.89,78.53
  BOTTOM w0.178: v5(89.77,33.77) 89.76,33.76 89.5,33.76 88.83,34.43 88.83,35.93 88.72,36.04 JDIMM1.89
DDR_A_MA9: length 63.4
  IN3 w0.076: 76.17,70.99 76.17,71.23 78.28,73.33 v3(78.28,73.73)
  IN3 w0.165: v5(88.17,35.07) 87.97,35.07 87.83,35.2 87.83,36.03 87.96,36.16 88.21,36.16 88.34,36.29 88.34,36.73 88.22,36.86 87.96,36.86 87.84,36.98 87.84,37.45 87.94,37.55 88.18,37.55 88.31,37.68 88.31,38.08 88.13,38.25 87.96,38.25 87.83,38.38 87.83,38.54 86.65,39.72 86.65,39.93 87.13,40.41 87.13,40.59 86.88,40.84 86.88,41.12 87.13,41.37 87.13,41.61 86.87,41.86 86.87,42.09 87.13,42.34 87.13,42.61 86.87,42.86 86.87,43.14 87.13,43.4 87.13,45.31 86.86,45.57 86.46,45.57 86.32,45.71 86.32,45.91 86.62,46.22 86.62,46.42 86.37,46.68 86.37,47.58 85.89,48.05 85.89,48.27 86.04,48.43 86.04,48.73 85.9,48.87 85.6,48.87 85.44,49.03 85.44,49.28 85.73,49.57 86.46,49.57 86.6,49.71 86.6,50.15 86.49,50.27 85.91,50.27 85.74,50.44 85.74,50.85 85.85,50.96 86.48,50.96 86.6,51.08 86.6,51.47 86.41,51.66 85.93,51.66 85.81,51.79 85.81,52.19 85.68,52.31 85.28,52.31 85.17,52.42 85.17,52.9 76.17,61.9 76.17,70.99
  BOTTOM w0.076: v3(78.28,73.73) 77.75,74.25 77.26,74.74 77.26,78.69 77.93,79.36 77.93,79.56 79.2,80.82 79.2,82.23 UC1.BB54
  BOTTOM w0.178: v5(88.17,35.07) 88.07,35.07 87.52,35.61 JDIMM1.85
DDR_A_MA10: length 65.3
  IN3 w0.076: v3(80.96,85.75) 80.58,85.37 80.58,83.71 82.31,81.98 82.31,81.42 82.31,81.41 82.31,81.31 83.02,80.6 83.02,72.13 82.82,71.93
  IN3 w0.165: 82.82,71.93 82.1,71.21 82.1,64.89 93.38,53.6 93.38,50.99 94.61,49.76 94.61,43.34 94.15,42.88 94.15,41.37 94.43,41.1 94.43,34.14 93.66,33.36 v5(93.58,33.36)
  BOTTOM w0.076: UC1.AT50 v3(80.96,85.75)
  BOTTOM w0.178: JDIMM1.107 94.12,35.56 93.83,35.27 93.4,35.27 93.07,34.94 93.07,33.54 93.25,33.36 v5(93.58,33.36)
DDR_A_MA11: length 64.5
  IN3 w0.076: 75.73,71.16 75.73,70.97
  IN3 w0.084: v3(78.28,75.03) 77.88,74.62 77.88,73.31 75.73,71.16
  IN3 w0.165: 75.73,70.97 75.73,61.72 84.73,52.72 84.73,51.9 84.86,51.76 85.2,51.76 85.36,51.6 85.36,51.23 85.2,51.06 84.88,51.06 84.75,50.93 84.75,50.49 84.88,50.36 85.2,50.36 85.36,50.2 85.36,49.83 85.2,49.67 84.85,49.67 84.72,49.54 84.72,49.18 85.01,48.89 85.01,48.3 85.87,47.44 85.87,47.07 85.87,43.11 86.43,42.55 86.43,40.37 86.03,39.97 86.03,39.71 87.39,38.35 87.39,34.97 88.26,34.1 88.26,33.72 87.68,33.14 v5(87.22,33.14)
  BOTTOM w0.076: v3(78.28,75.03) 77.47,75.84 77.47,78.61 78.1,79.24 78.1,79.49 79.36,80.75 79.36,82.51 79.15,82.72 79.09,82.77 UC1.BA54
  BOTTOM w0.178: v5(87.22,33.14) 87.38,32.97 87.38,30.06 87.22,29.9 JDIMM1.84
DDR_A_MA12: length 64.6
  IN3 w0.076: 75.28,70.94 75.28,71.12 77.61,73.45
  IN3 w0.084: v3(78.28,75.68) 77.61,75.01 77.61,73.45
  IN3 w0.165: v5(87.05,34.46) 86.94,34.56 86.94,38.16 85.22,39.89 85.22,40.29 85.35,40.42 85.82,40.42 85.98,40.59 85.98,40.96 85.82,41.12 85.35,41.12 85.21,41.26 85.21,41.69 85.35,41.82 85.82,41.82 85.98,41.99 85.98,42.35 85.82,42.52 85.33,42.52 85.2,42.65 85.2,43.09 85.43,43.32 85.43,45.75 85.26,45.92 84.36,45.92 84.16,46.12 84.16,46.41 84.36,46.61 85.26,46.61 85.43,46.78 85.43,47.26 84.56,48.12 84.56,48.71 84.28,48.99 84.28,52.54 75.28,61.54 75.28,70.94
  BOTTOM w0.076: UC1.AW54 78.99,84.07 79.3,83.76 79.3,83.21 79.48,83.04 79.53,82.99 79.53,80.68 78.26,79.42 78.26,79.1 77.67,78.51 77.67,76.28 v3(78.28,75.68)
  BOTTOM w0.178: JDIMM1.83 86.92,34.59 v5(87.05,34.46)
DDR_A_MA13: length 67.6
  IN3 w0.076: v3(82.79,85.12) 82.79,84.33 84.75,82.37 84.75,79.01 85.06,78.7 85.06,70.84 84.96,70.74
  IN3 w0.165: v5(97.5,33.4) 97.14,33.77 97.14,34.99 96.65,35.48 96.65,36.56 96.82,36.73 97.3,36.73 97.47,36.89 97.47,37.26 97.3,37.42 96.82,37.42 96.65,37.59 96.65,41.6 97.06,42.01 97.61,42.01 98.39,42.8 98.39,45.72 97.76,46.35 97.76,47.8 97.85,47.89 98.37,47.89 98.53,48.05 98.53,48.42 98.37,48.58 97.78,48.58 96.83,49.53 96.83,49.93 97.57,50.66 97.57,51.27 96.96,51.88 96.96,53.47 84.44,65.99 84.44,70.22 84.96,70.74
  BOTTOM w0.076: UC1.AU46 v3(82.79,85.12)
  BOTTOM w0.178: JDIMM1.119 97.72,33.62 v5(97.5,33.4)
DDR_A_MA14: length 65.5
  IN3 w0.076: v3(76.19,76.58) 74.35,74.75 74.35,73.88 72.14,71.67 72.14,70.6 71.93,70.38
  IN3 w0.165: v5(84.87,31.66) 83.99,31.66 82.98,32.67 82.98,37.09 81.62,38.44 81.62,41.25 79.69,43.18 79.69,51.6 70.57,60.71 70.57,68.52 71.71,69.66 71.71,70.17 71.93,70.38
  BOTTOM w0.076: 77.06,78.54 77.06,78.73 77.77,79.43 77.77,79.63 79.03,80.89 79.03,81.98 78.83,82.18 78.83,82.44 78.88,82.56 78.88,82.7 78.82,82.93 78.82,83.06 78.89,83.28 78.89,83.54 UC1.AY54
  BOTTOM w0.102: 77.06,78.54 77.06,77.02 76.62,76.58 v3(76.19,76.58)
  BOTTOM w0.178: v5(84.87,31.66) 85.45,31.08 85.45,30.39 86.02,29.82 JDIMM1.80
DDR_A_MA15: length 64.6
  IN3 w0.076: 71.65,70.55 71.91,70.82 71.91,71.87 74.13,74.09 74.13,76.48 v3(76.19,78.53)
  IN3 w0.165: v5(84.87,30.37) 84.41,30.37 82.53,32.25 82.53,36.9 81.17,38.26 81.17,41.06 79.24,42.99 79.24,46.13 78.67,46.7 78.67,51.25 78.35,51.57 78.35,52.31 70.13,60.53 70.13,68.71 71.27,69.84 71.27,70.17 71.65,70.55
  BOTTOM w0.076: UC1.BA55 78.2,83.08 78.2,82.85 78.15,82.72 78.15,82.61 78.2,82.47 78.2,82.06 78.06,81.92 78.06,81.6 78.32,81.34 78.32,80.67 v3(76.19,78.53)
  BOTTOM w0.178: JDIMM1.78 85.42,29.82 v5(84.87,30.37)
DDR_A_RAS#: length 64.8
  IN3 w0.076: v3(80.96,85.12) 80.96,83.75 82.71,82.01 82.71,81.62 83.32,81.01 83.32,71.92 83.17,71.77
  IN3 w0.165: v5(94.52,31.82) 94.52,33.44 94.87,33.79 94.87,41.28 94.6,41.56 94.6,42.7 95.05,43.16 95.05,44.01 95.22,44.17 95.57,44.17 95.74,44.34 95.74,44.71 95.57,44.87 95.22,44.87 95.05,45.04 95.05,49.95 93.83,51.18 93.83,53.79 82.56,65.05 82.56,71.16 83.17,71.77
  BOTTOM w0.076: UC1.AU50 v3(80.96,85.12)
  BOTTOM w0.178: JDIMM1.110 95.02,31.32 v5(94.52,31.82)
DDR_A_WE#: length 65
  IN3 w0.076: 84.64,74.13 84.84,74.33 84.84,78.62 84.5,78.97 84.5,82.31 82.36,84.45 82.36,85.32 v3(82.79,85.75)
  IN3 w0.165: v5(96.3,35.04) 96.21,35.13 96.21,41.79 96.88,42.46 97.43,42.46 97.95,42.98 97.95,45.53 97.31,46.17 97.31,48.42 96.39,49.35 96.39,50.11 97.11,50.83 97.11,51.07 96.85,51.33 96.62,51.33 96.21,50.92 95.99,50.92 95.73,51.18 95.73,54.07 83.9,65.9 83.9,70.91 84.29,71.29 84.64,71.29 84.77,71.41 84.77,71.87 84.65,71.99 84.45,71.99 84.33,72.1 84.33,72.56 84.46,72.69 84.64,72.69 84.77,72.81 84.77,73.24 84.62,73.38 84.45,73.38 84.33,73.5 84.33,73.83 84.64,74.13
  BOTTOM w0.076: UC1.AT46 v3(82.79,85.75)
  BOTTOM w0.178: JDIMM1.113 95.92,35.42 v5(96.3,35.04)
DDR_B_BS0: length 51.1
  IN1 w0.076: 82.16,70.19 81.92,70.44 81.92,71.95 82.81,72.84 82.81,78.88 83.14,79.21 83.53,79.21 83.83,78.92 83.83,76.39 84,76.22 v3(84.21,76.22)
  IN1 w0.165: 82.16,70.19 82.16,63.83 91.22,54.77 91.22,54.03 92.25,53 92.25,51.31 92.47,51.08 92.83,51.08 93.15,50.76 93.82,50.76 93.98,50.6 93.98,50.2 93.68,49.9 93.68,49.54 93.98,49.24 93.98,48.17 v5(93.66,47.84)
  BOTTOM w0.076: 84.81,78.54 84.81,78.76 84.74,78.84 84.74,80.43 84.74,80.89 84.83,80.99 84.83,81 84.83,82.23 UC1.BB44
  BOTTOM w0.102: v3(84.21,76.22) 84.81,76.82 84.81,78.54
  BOTTOM w0.178: JDIMM2.109 94.72,48.91 v5(93.66,47.84)
DDR_B_BS1: length 51.9
  IN1 w0.076: 83.13,72.19 84.65,73.71 84.65,76.44 v3(84.21,76.87)
  IN1 w0.165: v5(93.68,44.52) 94.16,44.03 94.16,43.47 93.81,43.12 93.32,43.12 92.97,43.47 92.97,46.47 94.43,47.93 94.43,50.94 94.14,51.22 93.78,51.22 93.57,51.44 93.57,51.8 93.57,51.8 93.57,52.17 93.57,52.17 93.57,53.85 87.18,60.24 87.18,61.3 83.05,65.43 83.05,70.33 82.73,70.65 82.73,71.79 83.13,72.19
  BOTTOM w0.076: UC1.BA44 84.67,82.72 84.67,81.06 84.57,80.97 84.57,80.5 84.57,80.5 84.57,78.71 84.62,78.66 84.62,78.54
  BOTTOM w0.102: 84.62,78.54 84.62,77.28 v3(84.21,76.87)
  BOTTOM w0.178: v5(93.68,44.52) 94.44,43.75 94.44,43.47 94.42,43.45 JDIMM2.108
DDR_B_BS2: length 52.9
  IN1 w0.076: 74.16,71.95 74.16,72.16 74.99,72.99 74.99,79.16 79.2,83.38 79.2,84.24 79.67,84.71 79.67,86.92 79.78,87.02 v3(80.05,87.02)
  IN1 w0.165: 74.16,71.95 74.16,59.36 81.08,52.44 81.08,51.02 82.91,49.19 82.91,48.5 82.71,48.3 82.71,47.03 83.19,46.55 83.37,46.55 83.57,46.75 v5(83.57,47.61)
  BOTTOM w0.076: v3(80.05,87.02) 80.43,87.4 UC1.AP52
  BOTTOM w0.178: v5(83.57,47.61) 84.08,47.61 85.72,49.25 JDIMM2.79
DDR_B_CAS#: length 53.3
  IN1 w0.076: v3(85.79,75.71) 85.38,75.3 85.38,72.76 85.21,72.59
  IN1 w0.165: 85.21,72.59 84.38,71.77 84.38,66.84 86.47,64.76 86.47,63.95 94.04,56.38 94.04,55.27 94.26,55.05 94.89,55.05 95.14,54.8 95.14,54.28 94.93,54.07 94.93,53.13 95.34,52.71 95.34,47.5 94.57,46.73 94.57,45.89 94.27,45.58 94.27,45.07 94.57,44.77 95.25,44.77 95.54,45.05 95.54,46.5 95.79,46.75 v5(96.17,46.75)
  BOTTOM w0.076: 85.19,78.54 85.19,79.04 85.07,79.16 85.07,80.29 85.07,80.29 85.07,80.72 85.18,80.84 85.18,81.92 85.37,82.1 85.37,82.48 85.35,82.51 85.32,82.59 85.32,82.71 85.38,82.93 85.38,83.07 85.33,83.23 85.33,83.41 85.41,83.57 85.41,83.67 UC1.AY43
  BOTTOM w0.102: v3(85.79,75.71) 85.19,76.31 85.19,78.54
  BOTTOM w0.178: v5(96.17,46.75) 96.83,47.41 96.83,48.88 96.52,49.19 JDIMM2.115
DDR_B_D0: length 70.5
  IN1 w0.114: v5(64.53,46.94) 64.31,47.17 64.31,49.53 61.82,52.01 61.35,52.01 56.38,56.99 56.38,75.32 54.51,77.19 54.51,85.01 58.32,88.83 66.59,88.83 67.77,90.01 68.55,90.01 68.75,90.21 68.75,90.38 68.44,90.69 68.44,90.85 68.74,91.15 68.9,91.15 69.21,90.83 69.37,90.83 69.6,91.06 69.6,91.51 69.81,91.71 72.61,91.71 v3(73.27,91.05)
  BOTTOM w0.076: UC1.AF65 v3(73.27,91.05)
  BOTTOM w0.114: JDIMM2.21 65.92,48.88 65.55,48.52 65.09,48.52 64.9,48.33 64.9,47.31 v5(64.53,46.94)
DDR_B_D1: length 69.1
  IN1 w0.076: 71.48,90.66 73.53,90.66 73.91,91.04 v3(73.91,91.05)
  IN1 w0.114: 71.48,90.66 70.59,90.66 68.87,88.94 68.23,88.94 66.58,87.29 63.16,87.29 63.05,87.17 63.05,86.92 62.86,86.73 62.59,86.73 62.4,86.92 62.4,87.17 62.29,87.29 61.87,87.29 61.75,87.17 61.75,86.82 61.56,86.63 61.3,86.63 61.11,86.82 61.11,87.17 60.99,87.29 60.57,87.29 60.46,87.17 60.46,86.51 60.34,86.4 59.92,86.4 59.81,86.51 59.81,87.17 59.7,87.29 59.28,87.29 59.16,87.17 59.16,86.51 59.05,86.4 57.3,86.4 55.5,84.6 55.5,77.67 57.37,75.8 57.37,57.87 65.87,49.36 65.87,48.48 v5(65.41,48.02)
  BOTTOM w0.076: UC1.AF64 v3(73.91,91.05)
  BOTTOM w0.114: v5(65.41,48.02) 65.44,48.02 66.15,48.73 66.15,49.16 66.52,49.54 JDIMM2.23
DDR_B_D2: length 69.3
  IN1 w0.076: v3(73.27,89.24) 72.87,88.84 72.47,88.84 72.3,88.66 71.55,88.66 70.28,87.4 70.28,86.67 67.8,84.19 65.74,84.19 65.64,84.09
  IN1 w0.114: 65.64,84.09 64.62,83.07 64.62,80.77 61.36,77.5 61.36,74.06 61.25,73.94 60.65,73.94 60.53,73.83 60.53,73.41 60.65,73.3 61.25,73.3 61.36,73.18 61.36,72.76 61.25,72.65 60.65,72.65 60.53,72.53 60.53,72.12 60.65,72 61.25,72 61.36,71.89 61.36,71.47 61.25,71.35 60.65,71.35 60.53,71.24 60.53,70.82 60.65,70.71 61.25,70.71 61.36,70.59 61.36,70.17 61.25,70.06 60.65,70.06 60.53,69.94 60.53,69.52 60.65,69.41 61.25,69.41 61.36,69.3 61.36,68.88 61.25,68.76 60.65,68.76 60.53,68.65 60.53,68.23 60.65,68.11 61.25,68.11 61.36,68 61.36,67.58 61.25,67.47 60.65,67.47 60.53,67.35 60.53,66.93 60.65,66.82 61.25,66.82 61.36,66.71 61.36,66.29 61.25,66.17 60.65,66.17 60.53,66.06 60.53,65.64 60.65,65.52 61.25,65.52 61.36,65.41 61.36,64.99 61.25,64.88 60.65,64.88 60.53,64.76 60.53,64.34 60.65,64.23 61.25,64.23 61.36,64.11 61.36,63.7 61.25,63.58 60.65,63.58 60.53,63.47 60.53,63.05 60.65,62.93 61.25,62.93 61.36,62.82 61.36,62.4 61.25,62.29 60.65,62.29 60.53,62.17 60.53,61.75 60.65,61.64 61.25,61.64 61.36,61.52 61.36,61.1 61.25,60.99 60.65,60.99 60.53,60.88 60.53,60.46 60.65,60.34 61.25,60.34 61.36,60.23 61.36,59.81 60.97,59.42 60.97,58.74 61.36,58.35 61.36,57.33 68.66,50.03 68.66,48.81 v5(69.09,48.38)
  BOTTOM w0.076: v3(73.27,89.24) 72.98,89.67 UC1.AK65
  BOTTOM w0.114: v5(69.09,48.38) 69.3,48.38 69.58,48.66 69.58,49.32 69.52,49.37 JDIMM2.33
DDR_B_D3: length 70.5
  IN1 w0.076: 71.46,90.34 71.63,90.51 74.06,90.51 74.28,90.29 74.28,89.59 v3(73.93,89.24)
  IN1 w0.114: 71.46,90.34 70.69,89.57 70.13,89.57 67.51,86.96 64.16,86.96 63.27,86.07 57.44,86.07 55.83,84.46 55.83,77.8 57.7,75.94 57.7,58 66.2,49.5 66.2,47.45 66.57,47.08 v5(67.9,47.08)
  BOTTOM w0.076: UC1.AK64 73.66,89.66 v3(73.93,89.24)
  BOTTOM w0.114: v5(67.9,47.08) 68.59,47.08 69.91,48.4 69.91,49.29 70.12,49.5 JDIMM2.35
DDR_B_D4: length 69.6
  IN1 w0.114: v5(65.72,44.36) 65.06,45.02 65.06,47.11 64.64,47.53 64.64,49.66 61.69,52.61 61.22,52.61 59.47,54.36 59.47,54.83 58.84,55.46 58.68,55.46 58.61,55.38 58.44,55.38 58.22,55.61 58.22,56.08 57.99,56.3 57.53,56.3 56.71,57.12 56.71,75.46 54.84,77.33 54.84,84.87 57.91,87.95 66.32,87.95 67.97,89.6 68.66,89.6 70.49,91.44 72.24,91.44 v3(72.64,91.05)
  BOTTOM w0.076: UC1.AF66 v3(72.64,91.05)
  BOTTOM w0.114: JDIMM2.22 66.22,43.86 v5(65.72,44.36)
DDR_B_D5: length 69.3
  IN1 w0.114: v3(72,91.05) 70.55,91.05 68.72,89.22 68.08,89.22 66.48,87.62 58.05,87.62 55.17,84.74 55.17,77.53 57.04,75.66 57.04,57.73 57.3,57.46 57.3,57.3 57.23,57.23 57.23,57.07 57.53,56.77 57.69,56.77 57.76,56.84 57.92,56.84 60.12,54.64 60.12,54.17 61.04,53.26 61.51,53.26 64.97,49.8 64.97,47.66 65.39,47.24 65.39,47 65.5,46.89 65.98,46.89 66.1,46.77 66.1,46.35 65.98,46.24 65.5,46.24 65.39,46.12 65.39,45.99 v5(65.74,45.63)
  BOTTOM w0.076: UC1.AF67 v3(72,91.05)
  BOTTOM w0.114: JDIMM2.24 66.82,44.05 66.27,44.59 66.27,45.1 v5(65.74,45.63)
DDR_B_D6: length 67.7
  IN1 w0.076: v3(71.95,89.22) 71.52,89.22 69.73,87.43 69.73,86.91 67.49,84.67 65.54,84.67 65.44,84.57
  IN1 w0.114: 65.44,84.57 63.95,83.09 63.95,81.03 60.7,77.78 60.7,75.2 60.16,74.67 59.39,74.67 59.14,74.41 59.14,73.37 59.25,73.26 59.76,73.26 59.87,73.14 59.87,72.72 59.76,72.61 59.25,72.61 59.14,72.5 59.14,72.08 59.25,71.96 59.76,71.96 59.87,71.85 59.87,71.43 59.76,71.32 59.25,71.32 59.14,71.2 59.14,58.62 68,49.76 68,48.25 68.41,47.84 68.41,46.73 68.18,46.5 66.57,46.5 66.45,46.38 66.45,45.89 66.77,45.57 66.77,45.29 66.96,45.1 67.23,45.1 67.42,45.29 67.42,45.81 67.53,45.92 v5(69.33,45.92)
  BOTTOM w0.076: v3(71.95,89.22) 71.65,89.62 UC1.AK67
  BOTTOM w0.114: v5(69.33,45.92) 68.87,45.46 68.87,44.39 69.11,44.14 69.53,44.14 69.82,43.85 JDIMM2.34
DDR_B_D7: length 68.5
  IN1 w0.076: v3(72.63,89.24) 72.54,89.24 72.13,88.82 71.43,88.82 70.01,87.4 70.01,86.75 67.7,84.44 65.64,84.44 65.49,84.29
  IN1 w0.114: 65.49,84.29 64.29,83.1 64.29,80.9 61.03,77.64 61.03,75.06 60.2,74.24 60.2,71 60.09,70.88 59.66,70.88 59.54,70.77 59.54,70.35 59.66,70.23 60.09,70.23 60.2,70.12 60.2,69.7 60.09,69.59 59.61,69.59 59.49,69.47 59.49,69.05 59.61,68.94 60.09,68.94 60.2,68.82 60.2,68.4 60.09,68.29 59.61,68.29 59.49,68.18 59.49,67.76 59.61,67.64 60.09,67.64 60.2,67.53 60.2,67.11 60.09,66.99 59.61,66.99 59.49,66.88 59.49,66.46 59.61,66.35 60.09,66.35 60.2,66.23 60.2,65.81 60.09,65.7 59.61,65.7 59.49,65.59 59.49,65.17 59.61,65.05 60.09,65.05 60.2,64.94 60.2,64.52 60.09,64.4 59.61,64.4 59.49,64.29 59.49,63.87 59.61,63.76 60.09,63.76 60.2,63.64 60.2,63.22 60.09,63.11 59.61,63.11 59.49,62.99 59.49,62.58 59.61,62.46 59.86,62.46 60.05,62.27 60.05,62 59.86,61.81 59.61,61.81 59.49,61.7 59.49,61.28 59.61,61.17 59.86,61.17 60.05,60.98 60.05,60.71 59.86,60.52 59.61,60.52 59.49,60.4 59.49,58.73 68.33,49.89 68.33,48.4 68.94,47.79 68.94,46.95 69.87,46.03 69.87,45.14 v5(69.31,44.58)
  BOTTOM w0.076: UC1.AK66 72.31,89.56 v3(72.63,89.24)
  BOTTOM w0.114: JDIMM2.36 70.42,43.6 69.43,44.58 v5(69.31,44.58)
DDR_B_D8: length 73.1
  IN1 w0.114: v3(64.63,91.71) 63.96,92.39 57.1,92.39 51.12,86.41 51.12,70.98 52.99,69.11 52.99,52.16 53.5,51.66 54.44,51.66 54.73,51.36 54.73,50.29 55.33,49.69 55.49,49.69 55.87,50.07 56.03,50.07 56.32,49.77 56.32,49.61 55.95,49.24 55.95,49.07 56.25,48.78 56.41,48.78 56.78,49.15 56.94,49.15 57.24,48.86 57.24,48.69 56.98,48.44 56.98,48.17 57.17,47.98 57.44,47.98 57.7,48.24 57.86,48.24 58.61,47.49 59.7,47.49 v3(60.1,47.08)
  BOTTOM w0.076: UC1.AF70 69.49,91.81 69.02,92.28 65.2,92.28 v3(64.63,91.71)
  BOTTOM w0.114: JDIMM2.5 61.12,47.65 60.55,47.08 v3(60.1,47.08)
DDR_B_D9: length 75
  IN1 w0.114: v3(63.33,91.71) 63.08,91.97 57.14,91.97 51.45,86.28 51.45,71.11 53.32,69.25 53.32,53.77 53.84,53.25 53.84,53.09 53.55,52.81 53.55,52.64 53.85,52.35 54.01,52.35 54.29,52.63 54.46,52.63 55.52,51.56 55.52,51.4 55.31,51.19 55.31,51.03 55.61,50.73 55.77,50.73 55.98,50.94 56.14,50.94 57.61,49.48 57.61,48.96 58.04,48.52 58.2,48.52 58.58,48.9 58.74,48.9 59.04,48.6 59.04,48.44 58.93,48.33 58.93,48.13 59.21,47.84 60.1,47.84 60.56,47.39 60.56,46.67 v5(60.13,46.24)
  BOTTOM w0.076: UC1.AF68 70.65,92.06 70.11,92.06 70.05,92.13 69.41,92.13 69.09,92.45 65,92.45 64.65,92.09 63.71,92.09 v3(63.33,91.71)
  BOTTOM w0.114: v5(60.13,46.24) 60.56,46.24 61.72,47.4 JDIMM2.7
DDR_B_D10: length 72.2
  IN1 w0.114: v5(63.07,48.05) 63.25,48.22 63.25,49.04 63.07,49.22 62.69,49.22 62.4,49.52 62.4,49.68 62.52,49.8 62.52,49.96 62.22,50.26 62.06,50.26 61.66,49.85 61.5,49.85 61.2,50.15 61.2,50.31 61.36,50.47 61.36,50.75 61.12,50.99 60.35,50.99 60.22,51.13 58.98,51.13 58.45,51.65 58.45,51.81 58.8,52.15 58.8,52.31 58.5,52.61 58.34,52.61 58,52.27 57.83,52.27 57.54,52.57 57.54,52.73 57.88,53.07 57.88,53.23 57.58,53.53 57.42,53.53 57.08,53.19 56.92,53.19 56.62,53.48 56.62,53.65 56.96,53.99 56.96,54.15 56.67,54.44 56.5,54.44 56.16,54.1 56,54.1 55.7,54.4 55.7,54.56 56.05,54.9 56.05,55.06 55.42,55.69 55.42,72.23 55.31,72.35 54.58,72.35 54.46,72.46 54.46,72.88 54.58,72.99 55.31,72.99 55.42,73.11 55.42,73.43 54.72,74.14 54.55,74.14 54.1,73.69 53.94,73.69 53.65,73.98 53.65,74.15 54.1,74.59 54.1,74.76 53.56,75.3 53.56,85.41 57.93,89.78 62.52,89.78 v3(63.37,90.62)
  BOTTOM w0.076: UC1.AH71 68.8,90.48 68.7,90.59 68.56,90.59 67.89,90.59 67.07,89.77 64.22,89.77 v3(63.37,90.62)
  BOTTOM w0.114: v5(63.07,48.05) 63.35,48.05 64.12,48.81 JDIMM2.15
DDR_B_D11: length 74.7
  IN1 w0.114: v5(63.1,46.73) 63.68,47.31 63.68,49.27 61.56,51.39 61.09,51.39 60.39,52.1 60.22,52.1 59.93,51.81 59.77,51.81 59.48,52.1 59.48,52.26 59.77,52.55 59.77,52.72 59.47,53.01 59.31,53.01 59.02,52.72 58.86,52.72 58.56,53.02 58.56,53.18 58.85,53.47 58.85,53.63 58.55,53.93 58.39,53.93 58.1,53.64 57.94,53.64 57.64,53.93 57.64,54.1 57.93,54.39 57.93,54.55 57.64,54.84 57.47,54.84 57.18,54.55 57.02,54.55 56.73,54.85 56.73,55.01 57.02,55.3 57.02,55.46 56.72,55.76 56.56,55.76 56.27,55.47 56.11,55.47 55.81,55.77 55.81,55.93 56.04,56.16 56.04,56.44 55.75,56.73 55.75,73.57 55.04,74.28 55.04,74.45 55.5,74.91 55.5,75.07 55.2,75.37 55.04,75.37 54.58,74.9 54.42,74.9 53.89,75.43 53.89,85.27 58.07,89.45 62.84,89.45 v3(64.02,90.62)
  BOTTOM w0.076: v3(64.02,90.62) 64.72,91.32 67.61,91.32 68.08,91.78 68.43,91.78 68.83,91.38 69.19,91.38 69.19,91.38 69.28,91.41 69.48,91.41 69.57,91.38 69.57,91.38 69.57,91.38 69.58,91.37 69.81,91.37 69.94,91.41 70.25,91.41 70.35,91.34 70.8,91.34 71.01,91.14 UC1.AH68
  BOTTOM w0.114: JDIMM2.17 64.72,48.55 64.01,47.84 64.01,47.64 v5(63.1,46.73)
DDR_B_D12: length 72.3
  IN1 w0.114: v3(66.66,91.89) 65.49,93.05 56.82,93.05 50.46,86.69 50.46,70.7 52.33,68.84 52.33,51.76 56.34,47.75 56.34,45.92 58.36,43.91 59.09,43.91 59.43,44.25 v5(60.09,44.25)
  BOTTOM w0.076: UC1.AF71 68.75,92.12 66.88,92.12 v3(66.66,91.89)
  BOTTOM w0.114: JDIMM2.4 60.82,43.21 60.61,43.42 60.61,43.74 v5(60.09,44.25)
DDR_B_D13: length 74
  IN1 w0.114: v1(65.96,91.71) 64.96,92.72 56.96,92.72 50.79,86.55 50.79,70.84 52.66,68.97 52.66,51.9 56.67,47.88 56.67,46.06 57.81,44.92 58.32,44.92 58.44,44.81 58.44,44.48 58.55,44.36 58.97,44.36 59.08,44.48 59.08,44.81 59.2,44.92 v3(60.09,44.92)
  BOTTOM w0.076: UC1.AF69 70.25,91.61 69.99,91.61 69.89,91.57 69.89,91.57 69.81,91.54 69.6,91.54 69.51,91.58 69.25,91.58 69.16,91.54 68.9,91.54 68.49,91.95 68.03,91.95 67.59,91.51 66.16,91.51 v1(65.96,91.71)
  BOTTOM w0.114: JDIMM2.6 61.42,43.02 60.84,43.6 60.84,44.18 v3(60.09,44.92)
DDR_B_D14: length 73.1
  IN1 w0.114: v5(63.71,44.13) 64.24,43.6 64.24,43.02 64.47,42.79 64.92,42.79 65.26,43.13 65.26,43.73 64.43,44.55 64.43,45.52 63.89,46.06 62.87,46.06 62.35,46.59 62.35,48.12 61.41,49.06 61.41,49.47 60.08,50.8 58.8,50.8 55.09,54.5 55.09,71.36 53.23,73.23 53.23,85.54 57.79,90.11 60.71,90.11 v3(61.2,90.6)
  BOTTOM w0.076: UC1.AH70 69.56,90.48 69.42,90.34 69.41,90.34 69.41,90.34 69.16,90.22 68.83,90.22 68.63,90.42 68.49,90.42 68.49,90.42 67.96,90.42 67.14,89.6 63.89,89.6 63.53,89.96 61.84,89.96 v3(61.2,90.6)
  BOTTOM w0.114: v5(63.71,44.13) 64.42,43.42 JDIMM2.16
DDR_B_D15: length 74.1
  IN1 w0.114: v3(60.57,90.6) 60.45,90.48 57.7,90.48 52.9,85.68 52.9,73.06 53.42,72.53 53.42,72.27 52.97,71.82 52.97,71.66 53.27,71.36 53.43,71.36 53.76,71.69 53.92,71.69 54.14,71.47 54.14,71.15 54.25,71.03 54.58,71.03 54.74,70.87 54.74,70.71 54.41,70.38 54.41,70.19 54.76,69.84 54.76,54.37 58.66,50.47 59.94,50.47 61.08,49.34 61.08,48.92 62.02,47.98 62.02,46.46 62.98,45.49 62.98,44.82 63.19,44.62 63.95,44.62 64.1,44.77 64.1,45.25 63.93,45.43 v5(63.68,45.43)
  BOTTOM w0.076: UC1.AH69 70.15,90.48 69.76,90.09 69.27,90.09 69.2,90.05 68.73,90.05 68.52,90.26 68.43,90.26 68.03,90.26 67.21,89.44 61.73,89.44 v3(60.57,90.6)
  BOTTOM w0.114: JDIMM2.18 65.02,44.09 v5(63.68,45.43)
DDR_B_D16: length 53.4
  IN1 w0.076: v3(71.82,85.75) 70.89,85.75 69.78,84.65 69.42,84.65 69.22,84.44 69.22,83.73 68.26,82.77
  IN1 w0.114: 68.26,82.77 67.82,82.34 67.82,82.15 64.29,78.62 64.29,75.94 64.15,75.79 62.76,75.79 62.64,75.67 62.64,75.25 62.76,75.14 63.19,75.14 63.3,75.03 63.3,74.61 63.19,74.49 62.76,74.49 62.64,74.38 62.64,73.96 62.76,73.84 63.19,73.84 63.3,73.73 63.3,73.31 63.19,73.2 62.76,73.2 62.64,73.08 62.64,72.66 62.76,72.55 63.09,72.55 63.28,72.36 63.28,72.09 63.09,71.9 62.76,71.9 62.64,71.79 62.64,57.87 70.92,49.59 70.92,48.24 70.62,47.94 v5(70.39,47.94)
  BOTTOM w0.076: v3(71.82,85.75) 72.17,86.1 UC1.AT66
  BOTTOM w0.114: v5(70.39,47.94) 70.92,48.48 70.92,49.09 71.32,49.48 JDIMM2.39
DDR_B_D17: length 52.8
  IN1 w0.076: 67.81,81.67 68.1,81.96 68.1,82.34 68.51,82.75 68.78,82.75 70.26,84.23 70.26,84.76 70.62,85.12 v3(71.82,85.12)
  IN1 w0.114: v5(71.41,48.86) 71.25,49.02 71.25,49.73 63.65,57.32 63.65,62.96 63.35,63.26 63.35,63.54 63.65,63.84 63.65,64.26 63.54,64.37 63.09,64.37 62.97,64.48 62.97,64.9 63.09,65.02 63.54,65.02 63.65,65.13 63.65,65.55 63.54,65.67 63.09,65.67 62.97,65.78 62.97,66.2 63.09,66.31 63.54,66.31 63.65,66.43 63.65,66.85 63.54,66.96 63.09,66.96 62.97,67.08 62.97,67.49 63.09,67.61 63.54,67.61 63.65,67.72 63.65,68.14 63.54,68.26 63.09,68.26 62.97,68.37 62.97,68.79 63.09,68.9 63.54,68.9 63.65,69.02 63.65,69.44 63.54,69.55 63.09,69.55 62.97,69.67 62.97,70.08 63.09,70.2 63.54,70.2 63.65,70.31 63.65,70.73 63.54,70.85 63.09,70.85 62.97,70.96 62.97,71.38 63.09,71.49 63.54,71.49 63.65,71.61 63.65,74.6 64.64,75.59 64.64,78.5 67.81,81.67
  BOTTOM w0.076: UC1.AU66 v3(71.82,85.12)
  BOTTOM w0.114: JDIMM2.41 71.92,49.37 v5(71.41,48.86)
DDR_B_D18: length 56.1
  IN1 w0.076: 71.67,81.97 71.81,82.11 71.81,82.62 73.29,84.09 73.29,85.56 73.12,85.73 73.12,86.93 73.02,87.02 v3(72.73,87.02)
  IN1 w0.114: v5(73.82,48.25) 73.51,48.25 73.36,48.4 73.36,49.24 73.87,49.75 73.87,50.14 66.1,57.9 66.1,58.79 66.58,59.27 66.58,59.92 65.75,60.75 65.75,71.22 65.87,71.34 66.72,71.34 66.83,71.45 66.83,71.87 66.72,71.98 65.87,71.98 65.75,72.1 65.75,72.52 65.87,72.63 66.72,72.63 66.83,72.75 66.83,73.16 66.72,73.28 65.87,73.28 65.75,73.39 65.75,73.71 65.94,73.9 67.95,73.9 68.63,74.59 68.63,79.97 69.41,80.75 69.57,80.75 69.91,80.42 70.07,80.42 70.37,80.71 70.37,80.87 70.31,80.93 70.31,81.09 70.42,81.21 70.91,81.21 71.23,81.52 71.23,81.75 71.44,81.97 71.67,81.97
  BOTTOM w0.076: v3(72.73,87.02) 73.11,87.4 UC1.AP65
  BOTTOM w0.114: v5(73.82,48.25) 73.89,48.25 74.92,49.27 JDIMM2.51
DDR_B_D19: length 56.7
  IN1 w0.076: v5(72.73,87.68) 73.27,87.14 73.27,86.09 73.49,85.87 73.49,83.91 72.07,82.49 72.07,81.98
  IN1 w0.114: 72.07,81.98 70.14,80.05 69.38,80.05 68.94,79.62 68.94,74.43 68.03,73.52 67.78,73.52 67.18,72.92 67.18,70.87 67.05,70.75 66.24,70.75 66.12,70.63 66.12,70.21 66.24,70.1 67.05,70.1 67.16,69.99 67.16,69.57 67.05,69.45 66.2,69.45 66.08,69.34 66.08,68.92 66.2,68.8 66.88,68.8 66.99,68.69 66.99,68.27 66.88,68.16 66.2,68.16 66.08,68.04 66.08,61.15 67.19,60.05 67.19,58.84 67.07,58.73 66.67,58.73 66.55,58.61 66.55,58.19 66.67,58.08 67.07,58.08 67.19,57.97 67.19,57.29 74.26,50.21 74.26,48.01 v3(73.82,47.56)
  BOTTOM w0.076: v5(72.73,87.68) 73.11,88.05 UC1.AN65
  BOTTOM w0.114: JDIMM2.53 75.52,49.19 73.89,47.56 v3(73.82,47.56)
DDR_B_D20: length 55.7
  IN1 w0.076: v3(71.82,87.66) 68.74,84.58 68.74,84 68.4,83.66
  IN1 w0.114: 68.4,83.66 68.4,83.66 61.98,77.24 61.98,57.59 69.58,50 69.58,47.22 71.32,45.48 v5(72.55,45.48)
  BOTTOM w0.076: UC1.AN66 72.21,88.05 v3(71.82,87.66)
  BOTTOM w0.114: v5(72.55,45.48) 71.62,44.55 JDIMM2.40
DDR_B_D21: length 55.2
  IN1 w0.076: 68.91,83.71 68.99,83.79 68.99,84.47 71.55,87.02 v3(71.82,87.02)
  IN1 w0.114: v5(72.57,44.16) 73.03,44.62 73.03,45.63 72.62,46.04 71.23,46.04 69.91,47.36 69.91,50.13 62.31,57.73 62.31,77.11 68.33,83.12 68.91,83.71
  BOTTOM w0.076: UC1.AP66 v3(71.82,87.02)
  BOTTOM w0.114: v5(72.57,44.16) 72.14,43.73 72.14,43.27 72.22,43.19 JDIMM2.42
DDR_B_D22: length 54.7
  IN1 w0.076: 70.05,81.76 70.31,82.03 70.9,82.03 73.12,84.25 73.12,85.28 72.73,85.66 v3(72.73,85.75)
  IN1 w0.114: 70.05,81.76 68.32,80.04 68.32,74.74 67.81,74.23 65.79,74.23 65.42,73.86 65.42,59.99 65.54,59.87 65.75,59.87 65.87,59.76 65.87,59.34 65.75,59.22 65.54,59.22 65.42,59.11 65.42,58.11 73.03,50.51 73.03,47.66 75.05,45.65 75.05,44.98 74.53,44.46 v5(73.97,44.46)
  BOTTOM w0.076: UC1.AT65 73.08,86.1 v3(72.73,85.75)
  BOTTOM w0.114: v5(73.97,44.46) 74.62,43.82 JDIMM2.50
DDR_B_D23: length 54.1
  IN1 w0.076: v3(72.73,85.12) 72.73,84.12 70.85,82.23 70.08,82.23 69.56,81.71
  IN1 w0.114: 69.56,81.71 68.03,80.18 68.03,74.87 67.72,74.56 67.24,74.56 66.86,74.94 66.04,74.94 65.09,74 65.09,57.98 72.7,50.37 72.7,47.53 72.91,47.32 72.91,47.16 72.57,46.82 72.57,46.66 72.86,46.36 73.03,46.36 73.37,46.7 73.53,46.7 74,46.23 v5(74,45.81)
  BOTTOM w0.076: UC1.AU65 73.07,85.45 v3(72.73,85.12)
  BOTTOM w0.114: v5(74,45.81) 75.22,44.59 JDIMM2.52
DDR_B_D24: length 51.5
  IN1 w0.076: 69.67,73.85 69.73,73.92 69.73,75.17 70.34,75.78 70.34,79.26 72.81,81.73 72.81,82.17 74.05,83.41 74.05,85.25 v3(74.56,85.75)
  IN1 w0.114: v5(76.18,48) 75.55,48.63 75.55,50.74 68.47,57.82 68.47,60.58 67.37,61.69 67.37,63.84 67.55,64.02 68.34,64.02 68.46,64.14 68.46,64.56 68.34,64.67 67.48,64.67 67.37,64.79 67.37,65.21 67.48,65.32 68.34,65.32 68.46,65.43 68.46,65.85 68.34,65.97 67.68,65.97 67.57,66.08 67.57,66.5 67.68,66.62 68.34,66.62 68.46,66.73 68.46,72.65 69.67,73.85
  BOTTOM w0.076: UC1.AT61 74.91,86.1 v3(74.56,85.75)
  BOTTOM w0.114: v5(76.18,48) 76.72,48.53 JDIMM2.57
DDR_B_D25: length 51
  IN1 w0.076: v3(74.56,85.12) 74.24,84.79 74.24,83.29 72.97,82.02 72.97,81.57 70.62,79.21 70.62,75.71 70.24,75.33
  IN1 w0.114: 70.24,75.33 70.01,75.1 70.01,73.7 68.8,72.49 68.8,63.58 68.68,63.46 68.27,63.46 68.15,63.35 68.15,62.93 68.27,62.81 68.68,62.81 68.8,62.7 68.8,62.28 68.68,62.17 68.27,62.17 68.15,62.05 68.15,61.63 68.27,61.52 68.68,61.52 68.8,61.4 68.8,58 75.88,50.92 75.88,49.58 76.63,48.82 76.63,47.1 v5(76.21,46.67)
  BOTTOM w0.076: v3(74.56,85.12) 74.9,85.45 UC1.AU61
  BOTTOM w0.114: v5(76.21,46.67) 77.32,47.79 JDIMM2.59
DDR_B_D26: length 54
  IN1 w0.076: v3(75.48,87.02) 75.86,86.64 75.86,85.76 76.07,85.54 76.07,83.17 74.96,82.05 74.96,81.05 72.82,78.9 72.82,78.78
  IN1 w0.114: 72.82,78.78 72.82,73.52 71.61,72.32 71.61,68.01 71.49,67.9 71.09,67.9 70.97,67.78 70.97,67.36 71.09,67.25 71.49,67.25 71.61,67.13 71.61,66.72 71.49,66.6 71.09,66.6 70.97,66.49 70.97,66.07 71.09,65.95 71.49,65.95 71.61,65.84 71.61,65.42 71.49,65.31 71.09,65.31 70.92,65.14 70.92,64.82 71.09,64.66 71.49,64.66 71.61,64.54 71.61,64.12 71.49,64.01 71.09,64.01 70.92,63.85 70.92,63.53 71.09,63.36 71.49,63.36 71.61,63.25 71.61,62.83 71.49,62.71 71.09,62.71 70.92,62.55 70.92,62.23 71.09,62.07 71.49,62.07 71.61,61.95 71.61,61.53 71.49,61.42 71.09,61.42 70.92,61.25 70.92,60.94 71.09,60.77 71.49,60.77 71.61,60.66 71.61,60.24 71.49,60.12 71.02,60.12 70.9,60.01 70.9,58.93 78.03,51.8 78.03,50.48 78.75,49.77 78.75,48.63 v5(79.15,48.22)
  BOTTOM w0.076: UC1.AP60 75.86,87.4 v3(75.48,87.02)
  BOTTOM w0.114: v5(79.15,48.22) 79.72,48.79 JDIMM2.67
DDR_B_D27: length 54.5
  IN1 w0.076: 73.11,78.73 73.11,78.81 75.19,80.89 75.19,81.76 76.3,82.87 76.3,85.67 76.01,85.96 76.01,87.13 v3(75.48,87.66)
  IN1 w0.114: 73.11,78.73 73.11,73.35 71.95,72.19 71.95,59.72 71.84,59.6 71.35,59.6 71.23,59.49 71.23,59.07 71.35,58.95 71.84,58.95 71.95,58.84 71.95,58.38 78.39,51.95 78.39,50.59 79.8,49.18 79.8,47.96 80.65,47.11 80.65,46.62 80.3,46.27 79.81,46.27 v5(79.15,46.93)
  BOTTOM w0.076: v3(75.48,87.66) 75.87,88.05 UC1.AN60
  BOTTOM w0.114: JDIMM2.69 80.32,47.89 79.36,46.93 v5(79.15,46.93)
DDR_B_D28: length 53.7
  IN1 w0.076: v3(74.56,87.66) 74.02,87.11 74.02,86.14 73.69,85.81 73.69,83.78 72.46,82.54 72.46,82 69.87,79.42 69.87,76.13 69.23,75.49 69.23,74.29 68.98,74.04
  IN1 w0.114: v5(76.45,43.62) 76.03,44.04 76.03,45.56 74.89,46.7 74.89,50.47 67.81,57.54 67.81,60.31 66.71,61.41 66.71,67.11 67.17,67.57 67.64,67.57 67.8,67.73 67.8,72.86 68.98,74.04
  BOTTOM w0.076: v3(74.56,87.66) 74.96,88.05 UC1.AN61
  BOTTOM w0.114: JDIMM2.56 76.42,42.15 76.42,43.6 v5(76.45,43.62)
DDR_B_D29: length 53.2
  IN1 w0.076: 69.38,74.04 69.5,74.16 69.5,75.33 70.08,75.91 70.08,79.29 72.64,81.85 72.64,82.4 73.86,83.62 73.86,85.5 74.17,85.81 74.17,86.63 v3(74.56,87.02)
  IN1 w0.114: 69.38,74.04 68.13,72.78 68.13,67.2 68.01,67.08 67.15,67.08 67.04,66.97 67.04,61.55 68.14,60.45 68.14,57.68 75.22,50.6 75.22,46.85 76.51,45.56 v5(76.51,44.91)
  BOTTOM w0.076: v3(74.56,87.02) 74.94,87.4 UC1.AP61
  BOTTOM w0.114: JDIMM2.58 77.02,44.4 v5(76.51,44.91)
DDR_B_D30: length 53.4
  IN1 w0.076: 72.5,78.58 72.5,78.89 74.77,81.16 74.77,82.25 75.87,83.36 75.87,85.36 v3(75.48,85.75)
  IN1 w0.114: v5(80.52,44.9) 80.37,44.9 78.42,46.85 78.42,49.6 77.7,50.31 77.7,51.66 70.57,58.8 70.57,68.18 70.69,68.29 71.16,68.29 71.28,68.41 71.28,68.83 71.16,68.94 70.69,68.94 70.57,69.06 70.57,69.48 70.69,69.59 71.16,69.59 71.28,69.7 71.28,70.12 71.16,70.24 70.76,70.24 70.64,70.35 70.64,70.77 70.76,70.88 71.16,70.88 71.28,71 71.28,72.45 72.5,73.67 72.5,78.58
  BOTTOM w0.076: v3(75.48,85.75) 75.83,86.1 UC1.AT60
  BOTTOM w0.114: v5(80.52,44.9) 80.02,44.39 JDIMM2.68
DDR_B_D31: length 52.8
  IN1 w0.076: v3(75.48,85.12) 75.48,83.36 74.44,82.33 74.44,81.2 74.14,80.9
  IN1 w0.114: v5(80.5,43.6) 79.99,44.11 79.99,44.79 78.09,46.7 78.09,49.42 77.37,50.13 77.37,51.53 70.24,58.66 70.24,71.88 71.97,73.61 71.97,73.9 71.77,74.1 71.49,74.1 71.35,73.95 71.1,73.95 70.97,74.08 70.97,74.77 71.09,74.89 72.05,74.89 72.17,75 72.17,78.93 72.36,79.12 72.36,79.28 72.16,79.48 72.16,79.64 72.46,79.93 72.62,79.93 72.82,79.74 72.98,79.74 74.14,80.9
  BOTTOM w0.076: v3(75.48,85.12) 75.81,85.45 UC1.AU60
  BOTTOM w0.114: JDIMM2.70 80.62,43.48 v5(80.5,43.6)
DDR_B_D32: length 50.7
  IN1 w0.076: v3(86.45,85.12) 86.45,84.67 86.53,84.6 87.2,84.6 87.28,84.52 87.28,81.98 89.08,80.18 89.08,70.96 89.52,70.52
  IN1 w0.114: v5(100.11,48.24) 100.68,48.24 100.95,48.51 100.95,49.04 100.52,49.47 100.52,52.64 100.4,52.76 100.02,52.76 99.9,52.87 99.9,53.26 100.02,53.38 100.4,53.38 100.52,53.49 100.52,53.89 100.4,54 100.02,54 99.9,54.12 99.9,54.51 100.02,54.62 100.4,54.62 100.52,54.74 100.52,55.13 100.4,55.25 100.02,55.25 99.9,55.36 99.9,55.75 100.02,55.87 100.4,55.87 100.52,55.98 100.52,56.38 100.4,56.49 100.02,56.49 99.9,56.6 99.9,57 100.02,57.11 100.4,57.11 100.52,57.23 100.52,58.59 89.52,69.59 89.52,70.52
  BOTTOM w0.076: UC1.AU40 v3(86.45,85.12)
  BOTTOM w0.114: v5(100.11,48.24) 100.11,48.24 100.72,48.85 JDIMM2.129
DDR_B_D33: length 51.3
  IN1 w0.076: v3(86.45,85.75) 86.45,85.66 86.06,85.27 86.06,83.73 86.19,83.61 86.9,83.61 87.05,83.45 87.05,81.93 88.86,80.13 88.86,70.88
  IN1 w0.114: 88.86,70.88 89.19,70.55 89.19,69.45 99.57,59.06 99.57,51.54 99.69,51.43 100.07,51.43 100.19,51.31 100.19,50.92 100.07,50.8 99.69,50.8 99.57,50.69 99.57,50.3 99.69,50.18 99.85,50.18 100.03,50 100.03,49.74 99.85,49.56 99.69,49.56 99.57,49.45 99.57,47.47 v5(100.16,46.89)
  BOTTOM w0.076: UC1.AT40 v3(86.45,85.75)
  BOTTOM w0.114: JDIMM2.131 101.32,48.05 v5(100.16,46.89)
DDR_B_D34: length 52.2
  IN1 w0.076: v3(88.28,85.75) 88.28,85.63 88.67,85.24 88.67,84.94 88.43,84.7 88.43,82.96 89.87,81.52 89.87,80.9 90.68,80.09 90.68,78.4 90.73,78.35 90.73,78.14
  IN1 w0.114: 90.73,78.14 90.73,71.39 91.12,71.01 91.45,71.01 96.79,65.67 96.79,65.5 96.53,65.25 96.53,65.08 96.81,64.81 96.97,64.81 97.23,65.06 97.39,65.06 97.67,64.78 97.67,64.62 97.41,64.37 97.41,64.2 97.69,63.93 97.85,63.93 98.11,64.18 98.27,64.18 98.55,63.9 98.55,63.74 98.29,63.49 98.29,63.32 98.57,63.05 98.73,63.05 98.99,63.3 99.15,63.3 99.43,63.02 99.43,62.86 99.17,62.61 99.17,62.44 99.45,62.16 99.61,62.16 99.87,62.42 100.03,62.42 100.31,62.14 100.31,61.98 100.05,61.72 100.05,61.56 100.33,61.28 100.49,61.28 100.75,61.54 100.91,61.54 101.19,61.26 101.19,61.1 100.93,60.84 100.93,60.68 101.21,60.4 101.37,60.4 101.63,60.66 101.79,60.66 102.09,60.36 102.09,60.19 101.91,60.01 101.91,59.7 102.85,58.76 102.85,54.23 102.74,54.12 102.46,54.12 102.34,54 102.34,53.61 102.46,53.49 102.74,53.49 102.85,53.38 102.85,53.1 102.74,52.99 102.51,52.99 102.4,52.87 102.4,52.48 102.51,52.36 102.74,52.36 102.85,52.25 102.85,52.01 102.7,51.86 v5(101.94,51.86)
  BOTTOM w0.076: UC1.AT37 v3(88.28,85.75)
  BOTTOM w0.114: v5(101.94,51.86) 103.61,51.86 104.32,51.15 JDIMM2.141
DDR_B_D35: length 51.7
  IN1 w0.076: v3(88.28,85.1) 88.28,82.84 89.62,81.5 89.62,80.94 90.43,80.13 90.43,79.91
  IN1 w0.114: 90.43,79.91 90.43,70.72 90.98,70.17 91.14,70.17 91.39,70.42 91.55,70.42 91.83,70.14 91.83,69.98 91.58,69.73 91.58,69.57 91.86,69.29 92.02,69.29 92.27,69.54 92.43,69.54 92.71,69.26 92.71,69.1 92.46,68.85 92.46,68.69 92.74,68.41 92.9,68.41 93.15,68.66 93.31,68.66 93.59,68.38 93.59,68.22 93.34,67.97 93.34,67.81 93.62,67.53 93.78,67.53 94.03,67.78 94.19,67.78 94.47,67.5 94.47,67.34 94.22,67.09 94.22,66.93 94.5,66.65 94.66,66.65 94.91,66.9 95.07,66.9 95.35,66.62 95.35,66.46 95.1,66.21 95.1,66.05 95.38,65.77 95.54,65.77 95.79,66.02 95.95,66.02 96.23,65.74 96.23,65.58 95.98,65.33 95.98,65.17 102.44,58.7 102.44,58.48 102.26,58.3 102.08,58.3 101.96,58.18 101.96,57.79 102.08,57.67 102.41,57.67 102.52,57.56 102.52,57.16 102.41,57.05 102.08,57.05 101.96,56.94 101.96,56.54 102.08,56.43 102.41,56.43 102.52,56.31 102.52,55.92 102.41,55.81 102.08,55.81 101.96,55.69 101.96,55.3 102.08,55.18 102.41,55.18 102.52,55.07 102.52,54.68 102.41,54.56 102.08,54.56 101.96,54.45 v5(101.96,53.15)
  BOTTOM w0.076: UC1.AU37 v3(88.28,85.1)
  BOTTOM w0.114: JDIMM2.143 104.92,51.13 104.65,51.4 104.65,51.7 103.21,53.15 102.97,53.15 102.62,52.8 102.32,52.8 v5(101.96,53.15)
