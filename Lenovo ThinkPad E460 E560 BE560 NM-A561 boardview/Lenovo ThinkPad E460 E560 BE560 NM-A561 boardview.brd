# Allegro board Lenovo ThinkPad E460 E560 BE560 NM-A561 boardview.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
SYX198CQNC_QFN10_3X3
  oval 0.711x0.356 smd: 1(0,0) 2(0,0.45) 3(0,0.9) 4(0,1.35) 5(0,1.8) 6(0,2.25)
  rect 0.33x1.219 smd: 7(0.662,2.215)
  rect 2.007x0.864 smd: 8(2,2.09)
  custom 0.47x0.47 smd: 9(1.775,1.075)
  rect 1.143x0.787 smd: 10(1.6,0.113)
TAI-T_TLPC4012C-4R7M_2P
  rect 1.6x4.293 smd: 1(0,0) 2(2.6,0)
TAIMA_IH-189-A_24P
  oval 0.762x2.057 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(5.08,0) 6(6.35,0) 7(7.62,0) 8(8.89,0) 9(10.16,0) 10(11.43,0) 11(12.7,0) 12(13.97,0) 13(13.97,9.365) 14(12.7,9.365) 15(11.43,9.365) 16(10.16,9.365) 17(8.89,9.365) 18(7.62,9.365) 19(6.35,9.365) 20(5.08,9.365) 21(3.81,9.365) 22(2.54,9.365) 23(1.27,9.365) 24(0,9.365)
TAITW_PUBAU1-09FNLSCNN4H0_9P-T
  round 1.295 hole 0.711: 1(0,0) 2(2.5,0) 3(4.5,0) 4(7,0) 5(7.5,1.5) 6(5.5,1.5) 7(3.5,1.5) 8(1.5,1.5) 9(-0.5,1.5)
  oval 1.397x3.2 hole 0.787x2.591: 10(-4.35,2.38) 13(11.35,2.38)
  oval 1.397x2.489 hole 0.787x1.905: 11(-4.35,9.48) 12(11.35,9.48)
TC7SG17FE_SON5
  oval 0.305x0.457 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1,1.35) 5(0,1.35)
TDK_FLF3215T-4R7M_2P
  rect 1.194x2.007 smd: 1(0,0) 2(3.2,0)
TDK_MPZ1608S300AT_2P
  rect 0.61x0.787 smd: 1(0,0) 2(1.4,0)
TE_2041180-2_2P-T
  oval 0.787x1.6 smd: 1(0,0) 2(-1.25,0)
  rect 2.108x2.997 smd: 3(2.55,2.9) 4(-3.8,2.9)
TPC12
  round 0.305 smd: 1(0,0)
TPC20
  round 0.508 smd: 1(0,0)
TPC32
  round 0.813 smd: 1(0,0)
TPC40
  round 1.016 smd: 1(0,0)
TPCA8059-H_PPAK56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
TPCA8065-H_PPAK56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
TPS2546RTER_QFN16_4X4
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 9(1.5,3.1) 10(1,3.1) 11(0.5,3.1) 12(0,3.1)
  oval 0.889x0.254 smd: 5(2.3,0.8) 6(2.3,1.3) 7(2.3,1.8) 8(2.3,2.3) 13(-0.8,2.3) 14(-0.8,1.8) 15(-0.8,1.3) 16(-0.8,0.8)
  rect 1.702x1.702 smd: 17(0.75,1.55)
TPS22965DSGR_WSON8_2X2
  oval 0.61x0.381 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.9,-1.5) 6(1.9,-1) 7(1.9,-0.5) 8(1.9,0)
  rect 0.889x1.6 smd: 9(0.95,-0.75)
TPS22966DPUR_WSON14_2X3
  oval 0.203x0.762 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2.05) 9(2,2.05) 10(1.6,2.05) 11(1.2,2.05) 12(0.8,2.05) 13(0.4,2.05) 14(0,2.05)
  rect 2.489x0.889 smd: 15(1.2,1.025)
TPS51367RVER_QFN28_3P5X4P5
  oval 0.305x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 15(3.2,3.17) 16(2.8,3.17) 17(2.4,3.17) 18(2,3.17) 19(1.6,3.17) 20(1.2,3.17) 21(0.8,3.17) 22(0.4,3.17) 23(0,3.17)
  oval 0.889x0.305 smd: 10(3.685,0.785) 11(3.685,1.185) 12(3.685,1.585) 13(3.685,1.985) 14(3.685,2.385) 24(-0.485,2.385) 25(-0.485,1.985) 26(-0.485,1.585) 27(-0.485,1.185) 28(-0.485,0.785)
  rect 3.099x2.108 smd: 29(1.6,1.585)
TYCO_2041180-4_4P-T
  oval 0.787x1.6 smd: 1(0,0) 2(-1.25,0) 3(-2.5,0) 4(-3.75,0)
  rect 2.108x2.997 smd: 5(2.55,2.9) 6(-6.3,2.9)
TYCO_2199230-8_75P-T
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(5.75,-7.55) 25(6,0) 26(6.25,-7.55) 27(6.5,0) 28(6.75,-7.55) 29(7,0) 30(7.25,-7.55) 31(7.5,0) 32(7.75,-7.55) 33(8,0) 34(8.25,-7.55) 35(8.5,0) 36(8.75,-7.55) 37(9,0) 38(9.25,-7.55) 39(9.5,0) 40(9.75,-7.55) 41(10,0) 42(10.25,-7.55) 43(10.5,0) 44(10.75,-7.55) 45(11,0) 46(11.25,-7.55) 47(11.5,0) 48(11.75,-7.55) 49(12,0) 50(12.25,-7.55) 51(12.5,0) 52(12.75,-7.55) 53(13,0) 54(13.25,-7.55) 55(13.5,0) 56(13.75,-7.55) 57(14,0) 58(14.25,-7.55) 59(14.5,0) 60(14.75,-7.55) 61(15,0) 62(15.25,-7.55) 63(15.5,0) 64(15.75,-7.55) 65(16,0) 66(16.25,-7.55) 67(16.5,0) 68(16.75,-7.55) 69(17,0) 70(17.25,-7.55) 71(17.5,0) 72(17.75,-7.55) 73(18,0) 74(18.25,-7.55) 75(18.5,0)
  rect 1.194x2.743 smd: 76(-1.1,-0.775) 77(19.6,-0.775)
W25Q32FVSSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
WGI219LM-QREF-A0_QFN48_6X6
  oval 0.305x1.092 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 25(4.4,6) 26(4,6) 27(3.6,6) 28(3.2,6) 29(2.8,6) 30(2.4,6) 31(2,6) 32(1.6,6) 33(1.2,6) 34(0.8,6) 35(0.4,6) 36(0,6)
  oval 1.092x0.305 smd: 13(5.2,0.8) 14(5.2,1.2) 15(5.2,1.6) 16(5.2,2) 17(5.2,2.4) 18(5.2,2.8) 19(5.2,3.2) 20(5.2,3.6) 21(5.2,4) 22(5.2,4.4) 23(5.2,4.8) 24(5.2,5.2) 37(-0.8,5.2) 38(-0.8,4.8) 39(-0.8,4.4) 40(-0.8,4) 41(-0.8,3.6) 42(-0.8,3.2) 43(-0.8,2.8) 44(-0.8,2.4) 45(-0.8,2) 46(-0.8,1.6) 47(-0.8,1.2) 48(-0.8,0.8)
  rect 2.997x2.997 smd: 49(2.2,3)
Y_7V25000014_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_8Y24000011_4P
  rect 0.889x0.787 smd: 1(0,0) 2(1.4,0) 3(1.4,1.1) 4(0,1.1)
Y_8Y25000010_4P
  rect 0.889x0.787 smd: 1(0,0) 2(1.4,0) 3(1.4,1.1) 4(0,1.1)
Y_9H03200042_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_X3G027000FG1H-HX_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)

## Nets
1.8VSP_LX: PL801.1 PR803.2 PU801.1(LX1) PU801.2(LX2) PU801.3(LX3)
3V5V_ON: PC213.2 PQ201.6(D1) PR206.2 PR208.1 PU201.1(EN1) PU202.1(EN)
+0.95VS_VGA: CV32.1 CV33.1 CV34.1 CV35.1 CV36.1 CV37.1 CV38.1 CV227.1 JV1.2 LV5.1 RV6.2 RV8.2 UV1.AK33(DP_VDDC_7) UV1.AK34(DP_VDDC_8) UV1.AL33(DP_VDDC_5) UV1.AM33(DP_VDDC_6) UV1.AN31(DP_VDDC_9) UV1.AN33(DP_VDDC_3) UV1.AP31(DP_VDDC_1) UV1.AP32(DP_VDDC_2) UV1.AP33(DP_VDDC_4) UV1.G30(PCIE_VDDC_1) UV1.G31(PCIE_VDDC_2) UV1.H29(PCIE_VDDC_3) UV1.H30(PCIE_VDDC_4) UV1.J29(PCIE_VDDC_5) UV1.J30(PCIE_VDDC_6) UV1.L28(PCIE_VDDC_7) UV1.M28(PCIE_VDDC_8) UV1.N27(BIF_VDDC_1) UV1.N28(PCIE_VDDC_9) UV1.R28(PCIE_VDDC_10) UV1.T27(BIF_VDDC_2) UV1.T28(PCIE_VDDC_11) UV1.U28(PCIE_VDDC_12)
+0.95VS_VGA_EN#: QV18.5(G2) QV18.6(D1) RV150.1 RV151.2
+0.95VS_VGA_GATE: QV18.3(D2) RV152.2 RV185.1
+0.675VS: CD23.1 CD24.1 CD25.1 CD26.1 CD51.1 CD52.1 CD53.1 CD54.1 CD55.1 CD56.1 JDIMM1.203(VTT1) JDIMM1.204(VTT2) JDIMM2.203(VTT_1) JDIMM2.204(VTT_2) PJ303.1 R159.1
+0.675VSP: PC308.1 PC309.1 PJ303.2 PU301.2(VTTSNS) PU301.20(VTT)
+1.8V_LDO: CA6.2 CA7.1 UA1.3(FILT_1.8V)
+1.8VALW: CV237.1 PJ802.1 RC173.1 UV12.1(VIN1) UV12.2(VIN2)
+1.8VALW_PCH: CC61.1 RC173.2 UC1.AA1(VCCATS_1P8) UC1.AF16(VCCPGPPF)
+1.8VS_VGA: CV21.1 CV24.1 CV25.1 CV53.1 CV63.1 CV71.1 CV72.1 CV207.1 CV238.1 LV3.1 LV4.1 LV6.1 RV106.1 RV108.1 RV112.1 RV114.1 RV128.2 TPV1.1 UV1.AB37(PCIE_PVDD) UV1.AC33(VDD1DI) UV1.AD12(VDDR4_1) UV1.AD34(AVDD) UV1.AF11(VDDR4_2) UV1.AF12(VDDR4_3) UV1.AF13(VDDR4_4) UV1.AF15(VDDR4_5) UV1.AF26(VDD_CT_1) UV1.AF27(VDD_CT_2) UV1.AF34(DP_VDDR_15) UV1.AG11(VDDR4_6) UV1.AG13(VDDR4_7) UV1.AG15(VDDR4_8) UV1.AG26(VDD_CT_3) UV1.AG27(VDD_CT_4) UV1.AG34(DP_VDDR_16) UV1.AH34(DP_VDDR_13) UV1.AJ34(DP_VDDR_14) UV1.AL38(DP_VDDR_18) UV1.AM32(DP_VDDR_19) UV1.AM37(DP_VDDR_17) UV12.7(VOUT1) UV12.8(VOUT2) UV14.8(VCC(B))
+1.8VSP: PC805.1 PC806.1 PC807.1 PC808.1 PJ802.2 PL801.2 PR804.1
+1.35V: CC94.1 CC226.1 CC227.1 CC228.1 CC229.1 CC230.1 CC231.1 CC232.1 CC233.1 CC234.1 CC235.1 CC256.1 CD8.1 CD9.1 CD10.1 CD11.1 CD13.1 CD14.1 CD15.1 CD16.1 CD19.1 CD20.1 CD21.1 CD22.1 CD38.1 CD39.1 CD40.1 CD41.1 CD42.1 CD43.1 CD44.1 CD45.1 CD46.1 CD47.1 CD48.1 CRF1.1 CRF2.1 CRF3.1 CRF4.1 CV232.1 JDIMM1.75(VDD1) JDIMM1.76(VDD2) JDIMM1.81(VDD3) JDIMM1.82(VDD4) JDIMM1.87(VDD5) JDIMM1.88(VDD6) JDIMM1.93(VDD7) JDIMM1.94(VDD8) JDIMM1.99(VDD9) JDIMM1.100(VDD10) JDIMM1.105(VDD11) JDIMM1.106(VDD12) JDIMM1.111(VDD13) JDIMM1.112(VDD14) JDIMM1.117(VDD15) JDIMM1.118(VDD16) JDIMM1.123(VDD17) JDIMM1.124(VDD18) JDIMM2.75(VDD_1) JDIMM2.76(VDD_2) JDIMM2.81(VDD_3) JDIMM2.82(VDD_4) JDIMM2.87(VDD_5) JDIMM2.88(VDD_6) JDIMM2.93(VDD_7) JDIMM2.94(VDD_8) JDIMM2.99(VDD_9) JDIMM2.100(VDD_10) JDIMM2.105(VDD_11) JDIMM2.106(VDD_12) JDIMM2.111(VDD_13) JDIMM2.112(VDD_14) JDIMM2.117(VDD_15) JDIMM2.118(VDD_16) JDIMM2.123(VDD_17) JDIMM2.124(VDD_18) PJ301.1 PJ302.1 QD1.2(BASE) QV24.5(D) RC293.1 RD1.1 RD9.1 RD15.1 RD21.1 UC1.AM40(VDDQC) UC1.AU23(VDDQ_AU23) UC1.AU28(VDDQ_AU28) UC1.AU35(VDDQ_AU35) UC1.AU42(VDDQ_AU42) UC1.BB23(VDDQ_BB23) UC1.BB32(VDDQ_BB32) UC1.BB41(VDDQ_BB41) UC1.BB47(VDDQ_BB47) UC1.BB51(VDDQ_BB51)
+1.35VP: PC301.1 PC311.1(P) PC312.1 PC313.1 PC314.1 PJ301.2 PJ302.2 PL301.1 PR305.1 PU301.5(VDDQ) PU301.19(VLDOIN)
+1.35VS_VGA: CV22.1 CV23.1 CV26.1 CV27.1 CV28.1 CV29.1 CV30.1 CV31.1 CV83.1 CV84.1 CV85.1 CV86.1 CV87.1 CV88.1 CV96.1 CV97.1 CV98.1 CV99.1 CV100.1 CV111.1 CV112.1 CV113.1 CV114.1 CV115.1 CV116.1 CV117.1 CV118.1 CV119.1 CV120.1 CV121.1 CV122.1 CV123.1 CV124.1 CV125.1 CV126.1 CV127.1 CV128.1 CV129.1 CV130.1 CV131.1 CV132.1 CV137.1 CV138.1 CV139.1 CV140.1 CV141.1 CV142.1 CV150.1 CV151.1 CV152.1 CV153.1 CV154.1 CV165.1 CV166.1 CV167.1 CV168.1 CV169.1 CV170.1 CV177.1 CV178.1 CV179.1 CV180.1 CV181.1 CV233.1 QV24.1(S1) QV24.2(S2) QV24.3(S3) RV18.1 RV19.1 RV22.1 RV23.1 RV30.1 RV31.1 RV41.2 RV42.1 RV43.1 RV44.1 RV53.2 RV54.1 RV55.1 RV56.1 RV66.2 RV67.1 RV68.1 RV69.1 RV78.2 RV79.1 RV199.2 RV206.2 UV1.AC7(VDDR1_1) UV1.AD11(VDDR1_2) UV1.AF7(VDDR1_3) UV1.AG10(VDDR1_4) UV1.AJ7(VDDR1_5) UV1.AK8(VDDR1_6) UV1.AL9(VDDR1_7) UV1.G11(VDDR1_8) UV1.G14(VDDR1_9) UV1.G17(VDDR1_10) UV1.G20(VDDR1_11) UV1.G23(VDDR1_12) UV1.G26(VDDR1_13) UV1.G29(VDDR1_14) UV1.H10(VDDR1_15) UV1.J7(VDDR1_16) UV1.J9(VDDR1_17) UV1.K8(VDDR1_20) UV1.K11(VDDR1_18) UV1.K13(VDDR1_19) UV1.L7(VDDR1_26) UV1.L12(VDDR1_21) UV1.L16(VDDR1_22) UV1.L21(VDDR1_23) UV1.L23(VDDR1_24) UV1.L26(VDDR1_25) UV1.M11(VDDR1_27) UV1.N11(VDDR1_28) UV1.P7(VDDR1_29) UV1.R11(VDDR1_30) UV1.U7(VDDR1_32) UV1.U11(VDDR1_31) UV1.Y7(VDDR1_34) UV1.Y11(VDDR1_33) UV5.B1(VDDQ1) UV5.B3(VDDQ9) UV5.B12(VDDQ21) UV5.B14(VDDQ31) UV5.C5(VDD5) UV5.C10(VDD7) UV5.D1(VDDQ2) UV5.D3(VDDQ10) UV5.D11(VDD9) UV5.D12(VDDQ22) UV5.D14(VDDQ32) UV5.E5(VDDQ17) UV5.E10(VDDQ19) UV5.F1(VDDQ3) UV5.F3(VDDQ11) UV5.F12(VDDQ23) UV5.F14(VDDQ33) UV5.G1(VDD1) UV5.G2(VDDQ7) UV5.G4(VDD3) UV5.G11(VDD10) UV5.G13(VDDQ29) UV5.G14(VDD13) UV5.H3(VDDQ12) UV5.H12(VDDQ24) UV5.K3(VDDQ13) UV5.K12(VDDQ25) UV5.L1(VDD2) UV5.L2(VDDQ8) UV5.L4(VDD4) UV5.L11(VDD11) UV5.L13(VDDQ30) UV5.L14(VDD14) UV5.M1(VDDQ4) UV5.M3(VDDQ14) UV5.M12(VDDQ26) UV5.M14(VDDQ34) UV5.N5(VDDQ18) UV5.N10(VDDQ20) UV5.P1(VDDQ5) UV5.P3(VDDQ15) UV5.P11(VDD12) UV5.P12(VDDQ27) UV5.P14(VDDQ35) UV5.R5(VDD6) UV5.R10(VDD8) UV5.T1(VDDQ6) UV5.T3(VDDQ16) UV5.T12(VDDQ28) UV5.T14(VDDQ36) UV6.B1(VDDQ1) UV6.B3(VDDQ9) UV6.B12(VDDQ21) UV6.B14(VDDQ31) UV6.C5(VDD5) UV6.C10(VDD7) UV6.D1(VDDQ2) UV6.D3(VDDQ10) UV6.D11(VDD9) UV6.D12(VDDQ22) UV6.D14(VDDQ32) UV6.E5(VDDQ17) UV6.E10(VDDQ19) UV6.F1(VDDQ3) UV6.F3(VDDQ11) UV6.F12(VDDQ23) UV6.F14(VDDQ33) UV6.G1(VDD1) UV6.G2(VDDQ7) UV6.G4(VDD3) UV6.G11(VDD10) UV6.G13(VDDQ29) UV6.G14(VDD13) UV6.H3(VDDQ12) UV6.H12(VDDQ24) UV6.K3(VDDQ13) UV6.K12(VDDQ25) UV6.L1(VDD2) UV6.L2(VDDQ8) UV6.L4(VDD4) UV6.L11(VDD11) UV6.L13(VDDQ30) UV6.L14(VDD14) UV6.M1(VDDQ4) UV6.M3(VDDQ14) UV6.M12(VDDQ26) UV6.M14(VDDQ34) UV6.N5(VDDQ18) UV6.N10(VDDQ20) UV6.P1(VDDQ5) UV6.P3(VDDQ15) UV6.P11(VDD12) UV6.P12(VDDQ27) UV6.P14(VDDQ35) UV6.R5(VDD6) UV6.R10(VDD8) UV6.T1(VDDQ6) UV6.T3(VDDQ16) UV6.T12(VDDQ28) UV6.T14(VDDQ36) UV7.B1(VDDQ1) UV7.B3(VDDQ9) UV7.B12(VDDQ21) UV7.B14(VDDQ31) UV7.C5(VDD5) UV7.C10(VDD7) UV7.D1(VDDQ2) UV7.D3(VDDQ10) UV7.D11(VDD9) UV7.D12(VDDQ22) UV7.D14(VDDQ32) UV7.E5(VDDQ17) UV7.E10(VDDQ19) UV7.F1(VDDQ3) UV7.F3(VDDQ11) UV7.F12(VDDQ23) UV7.F14(VDDQ33) UV7.G1(VDD1) UV7.G2(VDDQ7) UV7.G4(VDD3) UV7.G11(VDD10) UV7.G13(VDDQ29) UV7.G14(VDD13) UV7.H3(VDDQ12) UV7.H12(VDDQ24) UV7.K3(VDDQ13) UV7.K12(VDDQ25) UV7.L1(VDD2) UV7.L2(VDDQ8) UV7.L4(VDD4) UV7.L11(VDD11) UV7.L13(VDDQ30) UV7.L14(VDD14) UV7.M1(VDDQ4) UV7.M3(VDDQ14) UV7.M12(VDDQ26) UV7.M14(VDDQ34) UV7.N5(VDDQ18) UV7.N10(VDDQ20) UV7.P1(VDDQ5) UV7.P3(VDDQ15) UV7.P11(VDD12) UV7.P12(VDDQ27) UV7.P14(VDDQ35) UV7.R5(VDD6) UV7.R10(VDD8) UV7.T1(VDDQ6) UV7.T3(VDDQ16) UV7.T12(VDDQ28) UV7.T14(VDDQ36) UV8.B1(VDDQ1) UV8.B3(VDDQ9) UV8.B12(VDDQ21) UV8.B14(VDDQ31) UV8.C5(VDD5) UV8.C10(VDD7) UV8.D1(VDDQ2) UV8.D3(VDDQ10) UV8.D11(VDD9) UV8.D12(VDDQ22) UV8.D14(VDDQ32) UV8.E5(VDDQ17) UV8.E10(VDDQ19) UV8.F1(VDDQ3) UV8.F3(VDDQ11) UV8.F12(VDDQ23) UV8.F14(VDDQ33) UV8.G1(VDD1) UV8.G2(VDDQ7) UV8.G4(VDD3) UV8.G11(VDD10) UV8.G13(VDDQ29) UV8.G14(VDD13) UV8.H3(VDDQ12) UV8.H12(VDDQ24) UV8.K3(VDDQ13) UV8.K12(VDDQ25) UV8.L1(VDD2) UV8.L2(VDDQ8) UV8.L4(VDD4) UV8.L11(VDD11) UV8.L13(VDDQ30) UV8.L14(VDD14) UV8.M1(VDDQ4) UV8.M3(VDDQ14) UV8.M12(VDDQ26) UV8.M14(VDDQ34) UV8.N5(VDDQ18) UV8.N10(VDDQ20) UV8.P1(VDDQ5) UV8.P3(VDDQ15) UV8.P11(VDD12) UV8.P12(VDDQ27) UV8.P14(VDDQ35) UV8.R5(VDD6) UV8.R10(VDD8) UV8.T1(VDDQ6) UV8.T3(VDDQ16) UV8.T12(VDDQ28) UV8.T14(VDDQ36)
+1.35VS_VGA_EN: QV23.3(D2) QV24.4(G) RV208.2
+1.35VS_VGA_EN#: QV23.5(G2) QV23.6(D1) RV209.2
+1.65V_LDO: CA8.1 CA9.1 UA1.29(VREF_1.65V)
+1VALW: C749.2 C8543.1 JC5.1 PJ702.1 PJ703.1 Q23.5(D1) Q23.6(D2) Q23.7(D3) Q23.8(D4) QV9.5(D1) QV9.6(D2) QV9.7(D3) QV9.8(D4) RC176.1 RC304.1 RC379.2 U148.A1(IN) U149.3(D)
+1VALW_CLK2: LC3.1 UC1.K19(VCCCLK2)
+1VALW_CLK4: LC4.1 UC1.N20(VCCCLK4)
+1VALW_CLK5: LC5.1 UC1.L19(VCCCLK5)
+1VALW_PCH: CC49.1 CC95.1 CC272.1 LC2.1 LC3.2 LC4.2 LC5.2 RC176.2 RC353.2 RC354.2 RC390.2 UC1.A10(VCCCLK6) UC1.A14(VCCCLK1) UC1.AB17(VCCPRIM_1P0_AB17) UC1.AB19(VCCPRIM_1P0_AB19) UC1.AB20(VCCPRIM_1P0_AB20) UC1.AK20(VCCPRIM_1P0_AK20) UC1.K17(VCCMPHYAON_1P0_K17) UC1.L1(VCCMPHYAON_1P0_L1) UC1.L21(VCCCLK3) UC1.P18(VCCPRIM_1P0_P18) UC1.T1(VCCPRIM_1P0_T1) UC1.Y18(VCCPRIM_1P0_Y18)
+1VALW_PLL: CC273.1 LC2.2 UC1.V15(VCCAPLL_1P0)
+1VS_VGA: CV163.1 CV187.1 JV1.1 QV9.1(S1) QV9.2(S2) QV9.3(S3) RV143.2
+3V3_AUX: CW7.1 CW8.1 RW18.1 UW1.27(3V3AUX)
+3V_AVDD_HP: CA13.1 RA2.1 RA3.2 RA30.1 UA1.24(AVDD_HP)
+3V_DDR: C751.1 RD23.1 U7.1(OUT)
+3V_LDO: CA10.1 CA11.1 UA1.27(AVDD_3.3)
+3V_PWRGD: PR210.1 PU201.2(PG)
+3V_SPI: C8496.1 C8497.1 C8498.1 C8499.1 CC25.1 CC26.1 Q27.3(S) R9477.2 RC117.1 RC118.1 RC310.2 UC1.AJ16(VCCSPI) UC4M1.8(VCC) UC8M2.8(VCC) UTPM1.1(VSB) UTPM1.14(VDD2) UTPM1.22(VDD3)
+3V_VIN: PC201.1 PC202.1 PC230.1 PJ201.1 PR201.1 PU201.7(EN2) PU201.8(IN)
+3V_WLAN: CRF21.1 CRF22.1 JWLBT.2(3.3VAUX1) JWLBT.4(3.3VAUX2) JWLBT.72(3.3VAUX4) JWLBT.74(3.3VAUX5) Q26.1(D) R236.2 R237.2
+3VALW: C73.1 C750.1 C8541.1 CG1.1 PD4.1 PJ202.1 PR4.2 PR11.1 PR16.1 PR130.1 PR209.1 Q26.3(S) QG1.3(S) QL2.3(S) R25.1 R233.1 R236.1 R238.1 R9488.2 RA2.2 RC310.1 RC341.1 RC351.1 RC392.1 RC393.1 RC399.1 RC400.2 RE15.1 RE40.1 RE52.2 RE53.2 RG1.1 RL19.1 RPC18.1(R1) RPC18.2(R2) RPC18.3(R3) RPC18.4(R4) RPE1.1(R1) RPE1.2(R2) RPE1.3(R3) RPE1.4(R4) RPE2.1(R1) RPE2.2(R2) RPE2.3(R3) RPE2.4(R4) U7.5(IN) U11.6(VIN2_1) U11.7(VIN2_2) U149.1(VDD) UC3.5(VCC)
+3VALW_FB: PC212.1 PU201.3(FB)
+3VALW_GS: CG2.1 CG3.1 CG5.1 CG6.1 QG1.1(D) QG2.2(G1) QG2.5(G2) RG1.2 RG6.2 RG7.1 UGSEN1.1(VDD_IO) UGSEN1.14(VDD)
+3VALW_LAN: CL3.1 CRF15.1 CRF16.1 QL2.1(D) RL4.2 RL5.1 RL6.1 RL9.1 RL15.1 RL16.1 RL19.2 UL1.4(VDD3P3_4) UL1.5(VDD3P3_IN) UL1.15(VDD3P3_15) UL1.19(VDD3P3_19) UL1.29(VDD3P3_29)
+3VALW_LOGO: CRF13.1 CRF14.1 D1.3 JLCD.9 R25.2
+3VALW_OUT: PR203.1 PU201.4(OUT)
+3VALW_P: PC204.1 PC205.1 PC206.1 PC207.1 PC210.1 PC211.1 PJ202.2 PL201.2 PR203.2 PR207.2
+3VALW_PCH: CC262.1 CC263.1 CC264.1 RA27.1 RC83.1 RC92.2 RC93.2 RC95.2 RC98.1 RC99.1 RC101.1 RC132.1 RC298.2 RC306.2 RC308.2 RC326.1 RC330.1 RC333.1 RC341.2 RC356.2 RC372.2 RC376.1 RC395.2 RC396.2 RC397.2 RC398.2 RPC15.1(R1) RPC15.2(R2) RPC15.3(R3) RPC15.4(R4) UC1.AD15(VCCPGPPG) UC1.AG15(VCCPGPPB) UC1.AK15(VCCPGPPA) UC1.T16(VCCPGPPE) UC1.Y15(VCCPGPPD) UC1.Y16(VCCPGPPC)
+3VALW_PRIM: CC97.1 RC326.2 UC1.AJ21(VCCPRIM_3P3_AJ21) UC1.V19(VCCPRIM_3P3_V19)
+3VALW_RTCPRIM: CC58.1 CC260.1 CC261.1 RC333.2 UC1.AK17(VCCRTCPRIM_3P3)
+3VBS: PR202.1 PU201.6(BS)
+3VDMIC: JLCD.5 R9475.2
+3VL: CE4.1 CE5.1 CE6.1 CE8.1 CE9.1 CE10.1 JU3LF.20 LE1.1 PR10.1 PR18.2 PR205.2 PR216.1 PR217.1 R71.1 RA30.2 RC127.1 RE3.2 RE4.1 RE31.2 RE33.2 RE39.2 RPE3.4(R4) RPE5.1(R1) RPE5.2(R2) UE1.26(VSTBY1) UE1.50(VSTBY2) UE1.92(VSTBY3) UE1.112(VSTBY0) UE1.114(VSTBY4) UE1.121(VSTBY5) UE1.127(VSTBY(PLL))
+3VL_AVCC: CE2.1 CE3.1 LE1.2 UE1.74(AVCC)
+3VLX: PC203.2 PL201.1 PR204.2 PU201.10(LX)
+3VS: C1.1 C8.1 C50.1 C51.1 C52.1 C74.1 C115.1 C116.1 C204.1 C205.1 CA1.1 CA12.1 CC22.1 CD29.1 CD30.1 CD57.1 CD58.1 CW5.1 CW6.1 J6.2 JDIMM1.199(VDDSPD) JDIMM2.199(VDDSPD) JHDD.8(VCC_3V3_1) JHDD.9(VCC_3V3_2) JTOUCH.1 JU3LF.19 PR308.2 PR406.2 PR704.2 QC1.2(G1) QC1.5(G2) QC2.2(G1) QC2.5(G2) QT1.2(G1) QT1.5(G2) QV6.3(S) R3.2 R17.1 R60.1 R70.2 R106.1 R111.1 R217.1 R237.1 R9475.1 R9480.2 RA3.1 RA4.2 RA18.1 RA25.1 RA28.1 RC1.1 RC2.1 RC29.1 RC52.2 RC67.1 RC70.1 RC86.1 RC88.1 RC106.2 RC107.2 RC108.1 RC165.1 RC277.1 RC287.1 RC409.1 RC413.2 RC433.1 RC434.1 RD19.1 RD25.2 RE8.2 RE9.2 RE41.2 RE51.2 RG5.2 RPC9.5(R5) RPC9.6(R6) RPC9.7(R7) RPC9.8(R8) RPC22.5(R5) RPC22.6(R6) RPC22.7(R7) RPC22.8(R8) RPC200.1(R1) RPC200.2(R2) RPC200.4(R4) RPE3.1(R1) RPE3.2(R2) RPE5.3(R3) RPE5.4(R4) RT36.1 RT37.1 RVG130.1 RVG132.1 RVG133.1 RW11.1 RW12.1 RW13.1 RW18.2 RW20.1 RX1.1 U1.1(VCC) U3.5(IN) UE1.11(VCC) USROM1.8(VCC) UTPM1.8(VDD1) UV15.5(VCC) UW1.11(3V3_IN)
+3VS_CMOS: JLCD.6 R17.2
+3VS_DDIMUX: CX11.1 CX12.1 CX13.1 CX14.1 RX1.2 RX3.1 RX6.1 RX8.1 RX9.1 RX11.1 RX14.1 RX16.1 RX17.1 RX19.1 UX1.14(VDD33_1) UX1.28(VDD33_2) UX1.41(VDD33_3) UX1.56(VDD33_4)
+3VS_DP: CVG34.1 CVG35.1 CVG36.1 CVG37.1 CVG38.1 CVG42.1 RVG130.2 UVG2.1(VDDA33_DNW) UVG2.9(VDDE33_IO1) UVG2.17(VDDE33_IO2) UVG2.30(PVDD33)
+3VS_DVDD: CA14.1 RA4.1 UA1.18(DVDD_3.3)
+3VS_FP: JFPB.1 R70.1
+3VS_LS: J6.1 U11.8(VOUT2_1) U11.9(VOUT2_2)
+3VS_VDDIO: CA42.1 RA25.2 RA27.2 UA1.7(VDD_IO)
+3VS_VDDO: RA28.2 RA29.1 UA1.2(VDDO_3.3)
+3VS_VGA: CV62.1 CV205.1 JV4.2 PR604.2 PR612.1 QV5.2(G1) QV5.5(G2) RV9.1 RV11.1 RV14.1 RV91.1 RV92.1 RV93.1 RV98.1 RV99.1 RV117.1 RV131.1 RV132.1 RV134.2 RV135.1 RV136.1 RV138.1 RV139.1 RV140.1 RV162.2 UV1.AF23(VDDR3_1) UV1.AF24(VDDR3_2) UV1.AG23(VDDR3_3) UV1.AG24(VDDR3_4) UV14.1(VCC(A))
+5V_PWRGD: PR211.1 PU202.2(PG)
+5V_VCC: PC218.2 PU202.5(VCC)
+5V_VIN: PC214.1 PC215.1 PC216.1 PC231.1 PJ203.1 PU202.8(IN)
+5VALW: AOU1.1(IN) AOU1.4(ILIM_SEL) AOU1.7(CLT2) C69.1 C119.1 C171.1 C172.1 C8532.1 CV236.1 JU3LF.13 JU3LF.14 JU3LF.15 JU3LF.16 JU3LF.17 PC444.1 PC455.1 PC463.1 PC705.2 PJ204.1 PJ801.2 PR306.1 PR402.1 PR601.2 PR602.2 PR706.1 PU401.9(CSP2_2PH) PU402.4(VCC) PU403.4(VCC) PU404.4(VCC) PU701.18(V5) R28.1 R156.1 R234.1 R9486.1 RE2.2 RL22.1 RV151.1 RV161.1 RV208.1 RV209.1 U11.1(VIN1_1) U11.2(VIN1_2) U11.4(VBIAS) U15.5(IN) UV12.4(VBIAS)
+5VALW_CHGUSB: AOU1.12(OUT) C8528.1 C8531.1 D17.5(VP) JUSB2.1(VBUS)
+5VALW_OUT: PR213.1 PU202.4(OUT)
+5VALW_P: PC219.1 PC220.1 PC221.1 PC222.1 PC223.1 PC224.1 PC227.1 PC228.1 PJ204.2 PL202.2 PR213.2 PR215.2
+5VBS: PR212.1 PU202.6(BS)
+5VFB: PC229.1 PU202.3(FB)
+5VLP: PC8.1 PC225.1 PR9.2 PU1.1(VCC) PU202.7(LDO) R157.1
+5VLX: PC217.2 PL202.1 PR214.2 PU202.10(LX)
+5VS: C10.1 C19.1 C20.1 C21.1 C22.1 C23.1 C70.1 C132.1 C202.1 C203.1 D5.2 J5.2 JHDD.14(VCC5_1) JHDD.15(VCC5_2) JHDD.16(VCC5_3) JTP.8 JU3LF.18 Q22.1(D) R59.1 R63.1 R65.1 R68.2 R154.1 R9485.1 RA1.1 RA32.2 RE5.2 RE6.2 RL20.2 RV152.1 U4.4(IN1) U4.5(IN2) U150.4(IN1) U150.5(IN2)
+5VS_AVDD: CA15.1 RA32.1 UA1.28(AVDD_5V)
+5VS_CLASSD: CA2.1 CA3.1 CA4.1 CA5.1 CA16.1 RA1.2 UA1.13(LPWR_5.0) UA1.16(RPWR_5.0)
+5VS_CMOS: C11.1 CRF9.1 CRF10.1 JLCD.39 JLCD.40 U4.1(OUT)
+5VS_HDMI: CT31.2 D12.1(IN1) D12.9(OUT4) DT1.5(VP) DT2.5(VP) F2.2 JCRT.9 JHDMI.18(+5V) R224.1 R225.1 RT13.1 RT14.1 UT3.5(P) UT4.5(P)
+5VS_HDMI_F: D5.1 F2.1 Q22.3(S)
+5VS_LS: J5.1 U11.13(VOUT1_1) U11.14(VOUT1_2)
+5VS_ODD: C131.1 CRF5.1 CRF6.1 JODD.9 JODD.10 R154.2 U150.1(OUT)
+AVEE: CA18.1 UA1.21(AVEE)
+DV33_18: CW3.1 UW1.18(DV33_18)
+V1.00AP: PC711.1 PC712.1 PC713.1 PC715.1 PC716.1 PC717.1 PJ702.2 PJ703.2 PL701.2 PU701.22(VSNS)
+VCC_AMPHYPLL: CC46.1 LC1.2 UC1.K15(VCCAMPHYPLL_1P0_K15) UC1.L15(VCCAMPHYPLL_1P0_L15)
+VCC_CORE: CC123.1 CC136.1 CC137.1 CC138.1 CC139.1 CC140.1 CC141.1 CC142.1 CC143.1 CC144.1 CC145.1 CC170.1 CC171.1 CC172.1 CC173.1 CC174.1 CC175.1 CC176.1 CC177.1 CC178.1 CC179.1 CC190.1 CC191.1 CC192.1 CC193.1 CC194.1 CC195.1 CC196.1 CC197.1 CC198.1 CC199.1 CC200.1 CC201.1 CC202.1 CC203.1 CC204.1 CC205.1 CC206.1 CC207.1 CC208.1 CC209.1 CC218.1 CC221.1 CC222.1 CC223.1 CC224.1 CC225.1 PC443.1(P) PC465.2 PC466.2 PC467.2 PC468.2 PC469.2 PC470.2 PC471.2 PC472.2 PC473.2 PC474.2 PC475.2 PC476.2 PC477.2 PC478.2 PC479.2 PC480.2 PC481.2 PC482.2 PC483.2 PC484.2 PC485.2 PC486.2 PC487.2 PL403.2 PR452.1 RC120.1 UC1.A30(VCC_A30) UC1.A34(VCC_A34) UC1.A39(VCC_A39) UC1.A44(VCC_A44) UC1.AK33(VCC_AK33) UC1.AK35(VCC_AK35) UC1.AK37(VCC_AK37) UC1.AK38(VCC_AK38) UC1.AK40(VCC_AK40) UC1.AL33(VCC_AL33) UC1.AL37(VCC_AL37) UC1.AL40(VCC_AL40) UC1.AM32(VCC_AM32) UC1.AM33(VCC_AM33) UC1.AM35(VCC_AM35) UC1.AM37(VCC_AM37) UC1.AM38(VCC_AM38) UC1.G30(VCC_G30) UC1.G32(VCC_G32) UC1.G33(VCC_G33) UC1.G35(VCC_G35) UC1.G37(VCC_G37) UC1.G38(VCC_G38) UC1.G40(VCC_G40) UC1.G42(VCC_G42) UC1.J30(VCC_J30) UC1.J33(VCC_J33) UC1.J37(VCC_J37) UC1.J40(VCC_J40) UC1.K33(VCC_K33) UC1.K35(VCC_K35) UC1.K37(VCC_K37) UC1.K38(VCC_K38) UC1.K40(VCC_K40) UC1.K42(VCC_K42) UC1.K43(VCC_K43)
+VCC_DSW3P3: RC127.2 RC132.2 UC1.AD17(VCCDSW_3P3_AD17) UC1.AD18(VCCDSW_3P3_AD18) UC1.AJ17(VCCDSW_3P3_AJ17)
+VCC_FAN1: CRF17.1 CRF18.1 JFAN.4 R68.1
+VCC_GT: CC129.1 CC130.1 CC131.1 CC133.1 CC146.1 CC147.1 CC148.1 CC149.1 CC150.1 CC151.1 CC152.1 CC153.1 CC154.1 CC155.1 CC156.1 CC157.1 CC158.1 CC159.1 CC160.1 CC161.1 PC454.1(P) PC488.2 PC489.2 PC490.2 PC491.2 PC492.2 PC493.2 PC494.2 PC495.2 PC496.2 PC497.2 PC498.2 PC499.2 PC500.2 PC501.2 PC502.2 PC503.2 PC504.2 PC505.2 PC506.2 PC507.2 PC508.2 PC509.2 PC510.2 PC511.2 PC512.2 PL406.2 PR456.1 RC125.1 UC1.A48(VCCGT_A48) UC1.A53(VCCGT_A53) UC1.A58(VCCGT_A58) UC1.A62(VCCGT_A62) UC1.A66(VCCGT_A66) UC1.AA63(VCCGT_AA63) UC1.AA64(VCCGT_AA64) UC1.AA66(VCCGT_AA66) UC1.AA67(VCCGT_AA67) UC1.AA69(VCCGT_AA69) UC1.AA70(VCCGT_AA70) UC1.AA71(VCCGT_AA71) UC1.AC64(VCCGT_AC64) UC1.AC65(VCCGT_AC65) UC1.AC66(VCCGT_AC66) UC1.AC67(VCCGT_AC67) UC1.AC68(VCCGT_AC68) UC1.AC69(VCCGT_AC69) UC1.AC70(VCCGT_AC70) UC1.AC71(VCCGT_AC71) UC1.J43(VCCGT_J43) UC1.J45(VCCGT_J45) UC1.J46(VCCGT_J46) UC1.J48(VCCGT_J48) UC1.J50(VCCGT_J50) UC1.J52(VCCGT_J52) UC1.J53(VCCGT_J53) UC1.J55(VCCGT_J55) UC1.J56(VCCGT_J56) UC1.J58(VCCGT_J58) UC1.J60(VCCGT_J60) UC1.K48(VCCGT_K48) UC1.K50(VCCGT_K50) UC1.K52(VCCGT_K52) UC1.K53(VCCGT_K53) UC1.K55(VCCGT_K55) UC1.K56(VCCGT_K56) UC1.K58(VCCGT_K58) UC1.K60(VCCGT_K60) UC1.L62(VCCGT_L62) UC1.L63(VCCGT_L63) UC1.L64(VCCGT_L64) UC1.L65(VCCGT_L65) UC1.L66(VCCGT_L66) UC1.L67(VCCGT_L67) UC1.L68(VCCGT_L68) UC1.L69(VCCGT_L69) UC1.L70(VCCGT_L70) UC1.L71(VCCGT_L71) UC1.M62(VCCGT_M62) UC1.N63(VCCGT_N63) UC1.N64(VCCGT_N64) UC1.N66(VCCGT_N66) UC1.N67(VCCGT_N67) UC1.N69(VCCGT_N69) UC1.N70(VCCGT_N70) UC1.N71(VCCGT_N71) UC1.R63(VCCGT_R63) UC1.R64(VCCGT_R64) UC1.R65(VCCGT_R65) UC1.R66(VCCGT_R66) UC1.R67(VCCGT_R67) UC1.R68(VCCGT_R68) UC1.R69(VCCGT_R69) UC1.R70(VCCGT_R70) UC1.R71(VCCGT_R71) UC1.T62(VCCGT_T62) UC1.U65(VCCGT_U65) UC1.U68(VCCGT_U68) UC1.U71(VCCGT_U71) UC1.W63(VCCGT_W63) UC1.W64(VCCGT_W64) UC1.W65(VCCGT_W65) UC1.W66(VCCGT_W66) UC1.W67(VCCGT_W67) UC1.W68(VCCGT_W68) UC1.W69(VCCGT_W69) UC1.W70(VCCGT_W70) UC1.W71(VCCGT_W71) UC1.Y62(VCCGT_Y62)
+VCC_HDA: CC99.1 CC274.1 RC299.2 RC330.2 UC1.AJ19(VCCHDA)
+VCC_IO: CC104.1 CC105.1 CC106.1 CC107.1 CC108.1 CC109.1 JC1.2 R9490.1 RC104.1 RC105.1 RC192.2 RC297.2 RC344.1 UC1.AK28(VCCIO_AK28) UC1.AK30(VCCIO_AK30) UC1.AL30(VCCIO_AL30) UC1.AL42(VCCIO_AL42) UC1.AM28(VCCIO_AM28) UC1.AM30(VCCIO_AM30) UC1.AM42(VCCIO_AM42)
+VCC_IO_AP: C8536.1 C8537.1 JC1.1 Q23.1(S1) Q23.2(S2) Q23.3(S3)
+VCC_IO_AP_GATE: Q24.3(D2) R9485.2 R9487.1
+VCC_MPHYGT: CC47.1 CC50.1 CC52.1 CC258.1 JC5.2 LC1.1 UC1.AF20(VCCSRAM_1P0_AF20) UC1.AF21(VCCSRAM_1P0_AF21) UC1.N15(VCCMPHYGT_1P0_N15) UC1.N16(VCCMPHYGT_1P0_N16) UC1.N17(VCCMPHYGT_1P0_N17) UC1.N18(VCCAPLLEBB) UC1.P15(VCCMPHYGT_1P0_P15) UC1.P16(VCCMPHYGT_1P0_P16) UC1.T19(VCCSRAM_1P0_T19) UC1.T20(VCCSRAM_1P0_T20)
+VCC_SA: CC236.1 CC237.1 CC239.1 CC241.1 CC244.1 CC245.1 CC247.1 CC249.1 CC250.1 CC251.1 CC252.1 CC253.1 CC254.1 CC255.1 PC513.2 PC514.2 PC515.2 PC516.2 PC517.2 PC518.2 PC519.2 PC520.2 PC521.2 PC522.2 PC523.2 PC524.2 PL408.2 PR460.1 RC375.1 UC1.AK23(VCCSA_AK23) UC1.AK25(VCCSA_AK25) UC1.G23(VCCSA_G23) UC1.G25(VCCSA_G25) UC1.G27(VCCSA_G27) UC1.G28(VCCSA_G28) UC1.J22(VCCSA_J22) UC1.J23(VCCSA_J23) UC1.J27(VCCSA_J27) UC1.K23(VCCSA_K23) UC1.K25(VCCSA_K25) UC1.K27(VCCSA_K27) UC1.K28(VCCSA_K28) UC1.K30(VCCSA_K30)
+VCC_SFR: CC70.1 RC197.2 UC1.K20(VCCPLL_K20) UC1.K21(VCCPLL_K21)
+VCC_SFROC: CC257.1 RC293.2 UC1.AL23(VCCPLL_OC)
+VCC_ST: C8544.1 CC69.1 PC403.1 PR403.1 PR404.1 RC3.2 RC20.1 RC31.2 RC34.2 RC53.1 RC197.1 RC387.1 RC388.1 RC391.1 U148.A2(OUT) UC1.A18(VCCST)
+VCC_STG: CC68.1 R9490.2 RC123.1 RC294.1 RC401.1 RC426.2 U149.4(S) UC1.A22(VCCSTG_A22) UC1.G20(VCCSTG_G20)
AV12: CW4.1 RW3.1 UW1.10(AV12)
DV12: CW1.1 CW2.1 RW3.2 UW1.14(DV12S)
