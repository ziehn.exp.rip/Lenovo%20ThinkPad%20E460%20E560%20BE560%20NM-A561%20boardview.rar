# Allegro board Lenovo ThinkPad E460 E560 BE560 NM-A561 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_MAA1_6: length 39.5
  IN1 w0.084: 127.01,149.05 128.98,149.05 129.19,149.26 131.86,149.26 132.09,149.04 134.47,149.04 v1(135.01,149.57)
  IN1 w0.14: v1(107.3,159.48) 107.3,159.42 107.16,159.29 107.16,158.15 108.87,156.44 108.87,155.11 108.1,154.34 108.1,152.53 109.88,150.76 116.78,150.76 118.48,149.05 118.99,149.05 119.18,149.24 119.18,149.79 119.37,149.98 119.64,149.98 119.83,149.79 119.83,149.24 120.02,149.05 127.01,149.05
  BOTTOM w0.084: UV1.J17 135,149.58 v1(135.01,149.57)
  BOTTOM w0.14: v1(107.3,159.48) 107.24,159.42 106.95,159.42 UV5.H5
FBA_MAA1_7: length 38.9
  IN1 w0.084: 127.01,150.28 127.03,150.28 127.13,150.38 130.94,150.38 131.31,150.01 134,150.01 v1(134.4,149.62)
  IN1 w0.14: v3(108.46,159.59) 108.26,159.39 108.26,158.27 109.7,156.83 109.7,153.22 111.35,151.58 119.16,151.58 121,149.74 121.61,149.74 121.8,149.93 121.8,150.5 121.99,150.69 122.26,150.69 122.45,150.5 122.45,149.93 122.64,149.74 126.01,149.74 126.55,150.28 127.01,150.28
  BOTTOM w0.084: UV1.H17 134.2,149.82 v1(134.4,149.62)
  BOTTOM w0.14: UV5.H4 106.08,159.18 106.45,158.81 106.96,158.81 107.11,158.96 107.49,158.96 108.13,159.59 v3(108.46,159.59)
FBA_MAA1_8: length 39.5
  IN1 w0.084: v1(134.63,148.35) 134.19,147.92 133.87,147.92 133.59,148.2 133.59,148.5 133.6,148.51 133.47,148.65 132.08,148.65 131.51,148.08 127.92,148.08 127.63,148.37 127.01,148.37
  IN1 w0.14: 127.01,148.37 118.02,148.37 116.32,150.07 108.71,150.07 106.83,151.95 106.83,157.44 106.27,157.99 v1(106.27,159.59)
  BOTTOM w0.084: v1(134.63,148.35) 134.63,148.59 UV1.J19
  BOTTOM w0.14: v1(106.27,159.59) 106.66,159.98 UV5.J5
FBA_RASA0#: length 42.6
  IN1 w0.084: 127.01,143.42 131.04,143.42 131.53,143.91 135.21,143.91 v1(136,144.69)
  IN1 w0.14: 127.01,143.42 126.57,143.42 124.8,141.64 117.23,141.64 117.09,141.78 114.93,143.94 114.93,145.34 114.64,145.62 110.9,145.62 110.33,145.05 110.33,140.79 109.5,139.96 109.5,138.67 107.93,137.09 107.01,137.09 106.68,136.76 105.97,136.76 v1(105.56,137.17)
  BOTTOM w0.102: UV1.K23 135.8,144.89 v1(136,144.69)
  BOTTOM w0.14: v1(105.56,137.17) 105.52,137.17 UV6.G3
FBA_RASA1#: length 42.9
  IN1 w0.084: 127.15,147.68 134.67,147.68 v1(135.31,148.33)
  IN1 w0.14: 127.15,147.68 117.69,147.68 116.05,149.33 107.94,149.33 105.44,151.84 105.44,153.38 105.11,153.7 105.11,160.73 v1(104.72,161.12)
  BOTTOM w0.084: UV1.K19 135.31,148.47 v1(135.31,148.33)
  BOTTOM w0.14: v1(104.72,161.12) 104.72,161.19 UV5.L3
FBA_RST#: length 149.5
  IN3 w0.14: v3(167.34,167.93) 168.92,169.52 168.92,179.59 161.78,186.73 155.76,186.73 154.6,185.57 ; 102.27,159.58 101.96,159.27 101.96,138.75 102.75,137.96 v1(103.91,137.96) ; 102.27,159.58 101.35,160.49 101.35,167.27 105.09,171.01 116.62,171.01 123.65,178.04 123.65,184.65 125.61,186.6 131.66,186.6 132.6,185.66 ; 102.27,159.58 v1(103.91,159.58) ; v1(154.6,184.29) 154.6,185.57 ; 154.6,185.57 153.01,187.16 134.1,187.16 132.6,185.66 ; 132.6,185.66 v1(132.6,184.29)
  BOTTOM w0.14: v1(103.91,159.58) 104.31,159.98 UV5.J2 ; v1(103.91,137.96) 104.31,138.36 UV6.J2 ; UV7.J2 133,183.89 v1(132.6,184.29) ; v1(154.6,184.29) 155,183.89 UV8.J2 ; v3(167.34,167.93) v4(167.34,166.31) 167.34,163.49 167.93,162.9 167.93,162.02 167.44,161.53 167.44,158.87 168.23,158.08 168.23,154.98 167.87,154.62 RV27.1
FBA_WCKA0_0: length 34.1
  TOP w0.127: v1(129.29,137.45) 129.18,137.34 129.18,137.01 128.98,136.81 126.39,136.81 125.47,137.72 124.7,138.5 v3(123.37,138.5) 120.15,138.5 116.21,134.56 116.21,131.76 115.17,130.72 110.31,130.72 108.48,132.55 108.48,133.68 108.24,133.93 108.06,133.93 v1(107.93,133.79)
  BOTTOM w0.084: v1(129.29,137.45) 129.29,137.68 129.35,137.74 129.56,137.74 129.63,137.8 130.58,137.8 130.68,137.9 130.68,138.08 130.6,138.16 UV1.A32
  BOTTOM w0.127: v1(107.93,133.79) 107.76,133.96 106.31,133.96 UV6.D4
FBA_WCKA0_1: length 33.8
  IN3 w0.14: v1(128.99,145.28) 129.05,145.35 129.05,146.05 126.43,148.67 112.58,148.67 109.38,145.47 109.38,143.07 108.45,142.14 108.04,142.14 107.83,142.35 107.83,142.67 v1(107.91,142.76)
  BOTTOM w0.084: v1(128.99,145.28) 128.99,145.55 129.04,145.6 130.38,145.6 130.46,145.69 130.74,145.69 130.78,145.64 131.22,145.64 131.36,145.79 131.5,145.79 131.56,145.73 131.56,145.52 UV1.D23
  BOTTOM w0.102: v1(107.91,142.76) 107.87,142.76 107.74,142.63 107.74,142.44 107.44,142.14 107.23,142.14 107.09,142 106.46,142 106.1,142.36 UV6.P4
FBA_WCKA0B_0: length 34.4
  TOP w0.127: v1(107.99,134.65) 107.89,134.55 107.89,134.3 107.98,134.21 108.28,134.21 108.71,133.78 108.71,132.65 110.41,130.95 115.07,130.95 115.98,131.86 115.98,134.65 120.05,138.72 v3(121.14,138.72) 124.8,138.72 126.48,137.04 128.88,137.04 128.95,137.1 128.95,137.25 v1(128.71,137.49)
  BOTTOM w0.084: v1(128.71,137.49) 129.16,137.94 129.5,137.94 130.08,138.52 130.31,138.52 130.48,138.35 130.81,138.35 UV1.C32
  BOTTOM w0.127: UV6.D5 106.71,134.28 106.81,134.19 108.01,134.19 108.09,134.26 108.09,134.55 v1(107.99,134.65)
FBA_WCKA0B_1: length 33.5
  IN3 w0.14: v1(128.41,145.3) 128.81,145.71 128.81,145.95 126.33,148.43 112.68,148.43 109.62,145.37 109.62,142.97 108.55,141.9 107.94,141.9 107.52,142.32 107.52,142.57 107.33,142.77 v1(107.17,142.77)
  BOTTOM w0.084: UV1.E22 131.47,146.16 131.14,145.83 130.86,145.83 130.81,145.87 130.39,145.87 130.3,145.79 128.89,145.79 v1(128.41,145.3)
  BOTTOM w0.102: v1(107.17,142.77) 107.45,142.77 107.54,142.69 107.54,142.52 107.38,142.36 107.17,142.36 107.03,142.23 106.84,142.23 UV6.P5
FBA_WCKA1_0: length 31.2
  TOP w0.127: v1(128.56,152.79) 128.79,153.02 128.79,153.16 128.71,153.23 127.14,153.23 126.63,153.74 v3(123.73,153.74) 117,153.74 115.5,152.24 111.36,152.24 110.7,152.9 108.82,152.9 108.01,153.71 108.01,154.37 108.63,155 108.63,155.75 108.49,155.89 108.25,155.89 108.13,155.77 v1(108.13,155.56)
  BOTTOM w0.084: UV1.C14 130.78,152.34 130.48,152.34 130.4,152.27 130.39,152.26 130.31,152.21 129.98,152.21 129.73,152.46 128.92,152.46 128.58,152.8 128.58,152.79 v1(128.56,152.79)
  BOTTOM w0.127: UV5.D4 106.38,155.51 107.62,155.51 107.84,155.73 107.95,155.73 v1(108.13,155.56)
FBA_WCKA1_1: length 34.9
  IN3 w0.14: v1(128.71,156.66) 128.93,156.88 128.93,157.24 128.67,157.49 127.68,157.49 122.47,162.7 118.09,162.7 115.02,159.63 110.3,159.63 108.93,161 108.93,163.87 108.73,164.07 108.18,164.07 v3(107.82,163.71)
  BOTTOM w0.084: v1(128.71,156.66) 128.85,156.66 128.93,156.57 128.93,156.32 129.15,156.09 130.34,156.09 130.43,156 130.77,156 130.86,156.09 131.15,156.09 131.32,155.92 131.72,155.92 131.8,155.84 UV1.E10
  BOTTOM w0.127: v3(107.82,163.71) 107.61,163.93 107.43,163.93 107.11,163.61 106.6,163.61 UV5.P4
FBA_WCKA1B_0: length 30.9
  TOP w0.127: v1(129.14,152.82) 129.02,152.94 129.02,153.25 128.81,153.46 127.23,153.46 126.73,153.96 v3(121.85,153.96) 116.9,153.96 115.4,152.47 111.45,152.47 110.79,153.13 108.91,153.13 108.24,153.8 108.24,154.28 108.86,154.9 108.86,155.85 108.59,156.12 108.33,156.12 108.18,156.27 v1(108.18,156.43)
  BOTTOM w0.084: UV1.A14 130.23,152.53 130.54,152.53 130.68,152.67 130.68,152.78 130.64,152.82 130.41,152.82 130.34,152.89 129.96,152.89 129.7,152.64 129.22,152.64 129.14,152.72 v1(129.14,152.82)
  BOTTOM w0.127: UV5.D5 106.95,155.74 107.53,155.74 107.74,155.96 108.29,155.96 108.4,156.08 108.4,156.21 v1(108.18,156.43)
FBA_WCKA1B_1: length 34.8
  IN3 w0.14: v1(129.39,156.66) 129.17,156.88 129.17,157.06 129.17,157.34 128.77,157.74 127.78,157.74 122.57,162.94 117.99,162.94 117.6,162.55 117.56,162.55 114.88,159.87 110.4,159.87 109.18,161.1 109.18,163.97 108.83,164.31 108.52,164.31 v5(108.19,164.64)
  BOTTOM w0.084: v1(129.39,156.66) 129.23,156.66 129.11,156.54 129.11,156.39 129.23,156.28 130.41,156.28 130.51,156.18 130.69,156.18 130.79,156.27 131.23,156.27 131.4,156.11 131.55,156.11 131.62,156.18 131.62,156.34 UV1.D9
  BOTTOM w0.127: UV5.P5 106.86,163.84 107.02,163.84 107.33,164.15 108.11,164.15 108.2,164.24 108.2,164.63 v5(108.19,164.64)
FBA_WEA0#: length 38.6
  IN1 w0.084: v1(134.88,143.47) 134.36,142.95 133.64,142.95 132.31,141.62 130.77,141.62 130.46,141.31 130.05,141.31
  IN1 w0.14: v1(112.71,140.36) 112.75,140.4 115.71,140.4 116.06,140.05 116.06,138.69 116.2,138.55 116.46,138.55 116.83,138.92 117.1,138.92 117.29,138.73 117.29,138.47 116.92,138.09 116.92,137.83 117.08,137.67 118.18,137.67 118.89,136.96 118.89,136.65 119.08,136.46 119.35,136.46 119.54,136.65 119.54,136.96 119.73,137.15 120,137.15 120.19,136.96 120.19,135.92 120.38,135.73 120.65,135.73 120.84,135.92 120.84,136.98 121.03,137.17 121.29,137.17 121.48,136.98 121.48,135.66 121.67,135.47 121.94,135.47 122.13,135.66 122.13,137.33 122.36,137.56 122.73,137.56 123.42,136.86 123.69,136.86 123.88,137.05 123.88,137.32 123.26,137.93 123.26,138.2 126.38,141.31 130.05,141.31
  BOTTOM w0.084: UV1.K26 135.5,142.96 134.99,143.47 v1(134.88,143.47)
  BOTTOM w0.14: UV6.L12 v1(112.71,140.36)
FBA_WEA1#: length 40.5
  IN1 w0.084: 127.01,153.28 129.9,153.28 131.81,151.37 135.18,151.37 v1(135.79,150.76)
  IN1 w0.14: 127.01,153.28 126.17,153.28 124.43,155.02 124.43,155.68 124.24,155.87 123.97,155.87 123.78,155.68 123.78,154.86 123.59,154.68 123.32,154.68 123.13,154.86 123.13,155.68 122.94,155.87 122.67,155.87 122.49,155.68 122.49,154.86 122.3,154.68 122.03,154.68 121.84,154.86 121.84,155.68 121.65,155.87 121.38,155.87 121.19,155.68 121.19,154.86 121,154.68 120.73,154.68 120.54,154.86 120.54,155.68 120.35,155.87 120.08,155.87 119.89,155.68 119.89,154.86 119.7,154.68 119.44,154.68 119.25,154.86 119.25,155.68 119.06,155.87 118.79,155.87 118.6,155.68 118.6,154.86 118.41,154.68 118.14,154.68 117.95,154.86 117.95,155.68 117.76,155.87 117.49,155.87 117.3,155.68 117.3,154.86 117.11,154.68 116.47,154.68 115.09,156.05 115.09,157.09 114.63,157.55 113.14,157.55 v1(112.71,157.98)
  BOTTOM w0.084: v1(135.79,150.76) 136.2,151.17 136.2,151.65 136.6,152.05 UV1.L15
  BOTTOM w0.14: UV5.G12 v1(112.71,157.98)
FBB0_DBI0#: length 36
  TOP w0.14: v1(129.79,164.11) 129.65,164.25 128.65,164.25 127.29,165.62 127.29,166.77 122.78,171.27 v4(122.78,172.48) 122.78,180.71 125.76,183.68 126.27,183.68 126.63,183.33 127.29,183.33 127.89,183.93 128.41,183.93 128.56,183.78 v1(128.56,183.45)
  BOTTOM w0.084: UV1.G7 132.98,158.78 132.98,159.32 132.47,159.82 132.47,160.04 132.26,160.25 132.26,162.04 130.19,164.11 v1(129.79,164.11)
  BOTTOM w0.14: v1(128.56,183.45) UV7.D2
FBB0_DBI1#: length 16.8
  IN3 w0.14: v1(133.29,165.86) 133.29,166.98 128.55,171.72 128.55,174.64 v1(128.6,174.69)
  BOTTOM w0.084: UV1.K1 136,161.79 135.97,161.82 135.97,162.76 134.88,163.84 134.88,164.28
  BOTTOM w0.127: v1(133.29,165.86) 134.88,164.28
  BOTTOM w0.14: UV7.D13 v1(128.6,174.69)
FBB0_DBI2#: length 15
  IN3 w0.14: v1(138.89,164.2) 139.36,164.66 139.36,165.49 138.93,165.91 138.93,172.09 138.41,172.61 138.41,173.83 137.55,174.69 v1(137.4,174.69)
  BOTTOM w0.084: v1(138.89,164.2) 139.25,163.84 139.25,162.62 139.1,162.47 139.1,161.85 139.2,161.75 UV1.P1
  BOTTOM w0.14: UV7.P13 v1(137.4,174.69)
FBB0_DBI3#: length 28.9
  BOTTOM w0.084: 142.1,165.65 142.1,164.96 142.68,164.38 142.68,162.01 142.91,161.77 142.91,161.42 142.84,161.27 142.85,161.25 142.85,161.05 142.9,160.97 142.93,160.94 142.93,160.63 UV1.W4
  BOTTOM w0.14: UV7.P2 137.35,184.24 138,184.24 138.2,184.05 138.2,183.68 138.4,183.48 140.2,183.48 142.83,180.84 v4(142.83,173.8) 142.83,168.27 142.1,167.53 142.1,165.65
FBB0_EDC0: length 38.3
  TOP w0.14: v1(129.34,162.83) 128.02,162.83 121.2,169.65 v4(121.2,174.72) 121.2,181.3 125.61,185.71 127.29,185.71 v1(127.8,185.2)
  BOTTOM w0.084: v1(129.34,162.83) 129.75,162.42 130.77,162.42 131.41,161.78 131.41,160.82 132.26,159.96 132.26,159.5 UV1.F6
  BOTTOM w0.14: v1(127.8,185.2) 127.8,184.29 UV7.C2
FBB0_EDC1: length 23.3
  IN3 w0.14: v1(135.4,164) 135.28,164.11 134.64,164.11 133.56,165.19 133.08,165.19 130.89,167.38 130.89,167.61 131.18,167.9 131.18,168.13 131.01,168.3 130.78,168.3 130.49,168.01 130.26,168.01 130.1,168.17 130.1,168.4 130.39,168.69 130.39,168.92 130.22,169.09 129.99,169.09 129.7,168.8 129.47,168.8 129.31,168.96 129.31,169.19 129.6,169.48 129.6,169.71 129.43,169.88 129.2,169.88 128.91,169.59 128.68,169.59 128.52,169.75 128.52,169.98 128.81,170.27 128.81,170.5 128.64,170.67 128.41,170.67 128.12,170.38 127.89,170.38 127.7,170.57 127.7,174.59 v1(127.8,174.69)
  BOTTOM w0.084: UV1.K3 136,160.76 136.12,160.88 136.12,161.22 136.33,161.42 136.33,161.7 136.13,161.89 136.13,162.89 135.74,163.28 135.74,163.66 v1(135.4,164)
  BOTTOM w0.14: UV7.C13 v1(127.8,174.69)
FBB0_EDC2: length 22.8
  IN3 w0.14: v1(138.2,174.69) 138.56,174.69 139.27,173.98 139.27,173.79 140.19,172.86 140.19,172.36 140.03,172.2 139.62,172.2 139.45,172.04 139.45,171.8 139.62,171.64 140.03,171.64 140.19,171.48 140.19,171.25 140.03,171.08 139.62,171.08 139.45,170.92 139.45,170.69 139.62,170.52 140.03,170.52 140.19,170.36 140.19,170.13 140.03,169.96 139.62,169.96 139.45,169.8 139.45,169.57 139.62,169.41 140.03,169.41 140.19,169.24 140.19,169.01 140.03,168.85 139.62,168.85 139.45,168.68 139.45,168.45 139.62,168.29 140.03,168.29 140.19,168.12 140.19,167.89 140.03,167.73 139.62,167.73 139.45,167.57 139.45,167.33 139.62,167.17 140.03,167.17 140.19,167.01 140.19,166.77 140.03,166.61 139.62,166.61 139.45,166.45 139.45,166.22 139.62,166.05 140.03,166.05 140.19,165.89 140.19,164.85 v1(138.85,163.51)
  BOTTOM w0.084: UV1.P3 138.93,161.03 138.93,161.34 138.85,161.42 v1(138.85,163.51)
  BOTTOM w0.14: UV7.R13 v1(138.2,174.69)
FBB0_EDC3: length 28.2
  BOTTOM w0.084: UV1.V5 142.13,160.23 142.13,160.54 142.05,160.62 142.05,160.9 142.13,160.98 142.13,161.34 142.05,161.42 142.05,161.7 142.17,161.83 142.17,162.77 141.84,163.11 141.84,164.1 140.65,165.29 140.65,165.85
  BOTTOM w0.14: UV7.R2 137.45,183.54 137.45,182.06 137.65,181.85 137.95,181.85 138.26,181.55 138.26,181.35 138.26,180.96 138.84,180.37 138.84,180.14 138.55,179.84 138.55,179.61 138.71,179.45 138.94,179.45 139.24,179.74 139.47,179.74 141.38,177.83 141.38,173.22 140.65,172.48 v4(140.65,171.74) 140.65,165.85
FBB1_D0: length 31.4
  TOP w0.14: v3(147.68,184.6) 147.28,185 146.82,185 v4(142.52,180.71) 142.09,180.28 142.09,169.84 143.11,168.83 143.11,165.88 144.41,164.58 v1(144.64,164.58)
  BOTTOM w0.084: UV1.AA4 144.5,160.66 144.5,160.97 144.47,160.99 144.47,161.02 144.47,161.3 144.47,161.33 144.5,161.35 144.5,161.86 144.18,162.18 144.18,164.25 144.51,164.58 v1(144.64,164.58)
  BOTTOM w0.14: UV8.B2 149.02,184.27 148.37,184.27 148.04,184.6 v3(147.68,184.6)
FBB1_D1: length 39.4
  TOP w0.14: v1(144.66,162.8) 144.51,162.8 142.14,165.17 142.14,168.43 141.11,169.46 141.11,180.66 v4(145.2,184.76) 147.12,186.68 151.04,186.68 152.2,185.52 v1(152.2,184.32)
  BOTTOM w0.084: UV1.AB6 145.15,159.81 145.15,161.27 145.13,161.28 145.13,161.3 145.01,161.41 145.01,162.44 v1(144.66,162.8)
  BOTTOM w0.14: UV8.F2 152.2,184.29 v1(152.2,184.32)
FBB1_D2: length 30.8
  TOP w0.14: v1(147.07,184.32) 146.82,184.32 142.58,180.08 v4(142.58,178.45) 142.58,173.03 143.59,172.02 143.59,171.79 143.43,171.62 142.79,171.62 142.63,171.46 142.63,171.23 142.79,171.06 143.43,171.06 143.59,170.9 143.59,170.67 143.43,170.51 142.79,170.51 142.63,170.34 142.63,170.11 142.79,169.95 143.43,169.95 143.59,169.78 143.59,166.26 v1(144.66,165.19)
  BOTTOM w0.084: UV1.AB1 145.35,161.81 145.35,162.44 145.35,162.44 145.35,164.5 v1(144.66,165.19)
  BOTTOM w0.14: v1(147.07,184.32) 147.33,184.06 148.23,184.06 148.41,183.89 UV8.A2
FBB1_D3: length 35.3
  TOP w0.14: v1(151.37,184.32) 151.34,184.35 151.34,185.03 150.18,186.2 147.32,186.2 v4(143.86,182.73) 141.61,180.48 141.61,169.64 142.62,168.63 142.62,165.41 144.63,163.41 v1(144.65,163.41)
  BOTTOM w0.084: v1(144.65,163.41) 145.18,162.87 145.18,162.51 145.18,162.51 145.18,161.49 145.6,161.07 UV1.AB3
  BOTTOM w0.14: UV8.E2 v1(151.37,184.32)
FBB1_D4: length 32.2
  TOP w0.14: v1(152.21,181.85) 151.93,181.57 151.79,181.57 151.58,181.36 150.57,181.36 150.15,180.95 149.84,180.95 149.26,180.37 149.03,180.37 148.59,180.81 148.36,180.81 148.2,180.64 148.2,180.41 148.63,179.97 148.63,179.74 148.47,179.58 148.24,179.58 147.8,180.02 147.57,180.02 147.41,179.85 147.41,179.62 147.84,179.18 147.84,178.95 147.68,178.79 147.45,178.79 147.01,179.23 146.78,179.23 146.62,179.06 146.62,178.83 147.05,178.39 147.05,178.16 146.61,177.72 v4(146.61,176.54) 146.61,173.11 148.29,171.43 148.29,164.38 v1(147.78,163.87)
  BOTTOM w0.084: v1(147.78,163.87) 147.38,163.47 147.38,161.86 147.55,161.69 147.55,159.76 147.4,159.6 UV1.AD6
  BOTTOM w0.14: UV8.F4 152.6,182.24 v1(152.21,181.85)
FBB1_D5: length 30.6
  TOP w0.14: v1(151.39,181.85) 150.38,181.85 149.95,181.43 148.28,181.43 145.94,179.1 145.94,177.87 145.78,177.7 145.31,177.7 145.14,177.54 145.14,177.31 145.31,177.14 145.78,177.14 145.94,176.98 145.94,176.75 145.78,176.59 145.31,176.59 145.14,176.42 145.14,176.19 145.31,176.03 145.78,176.03 145.94,175.86 145.94,175.63 145.78,175.47 145.31,175.47 145.14,175.3 145.14,175.07 145.31,174.91 145.78,174.91 145.94,174.75 145.94,174.51 145.78,174.35 145.31,174.35 145.14,174.19 145.14,173.95 145.31,173.79 145.78,173.79 145.94,173.63 145.94,173.09 147.78,171.25 v4(147.78,169.66) 147.78,164.64 v1(147.78,164.63)
  BOTTOM w0.084: v1(147.78,164.63) 147.21,164.07 147.21,161.57 UV1.AD1
  BOTTOM w0.14: UV8.E4 151.8,182.26 v1(151.39,181.85)
FBB1_D6: length 31.7
  TOP w0.14: v1(146.2,163.59) 146.36,163.59 146.74,163.97 146.74,165.24 145.85,166.13 145.85,167.24 145.69,167.4 145.23,167.4 145.07,167.56 145.07,167.8 145.23,167.96 145.69,167.96 145.85,168.12 145.85,168.36 145.69,168.52 145.23,168.52 145.07,168.68 145.07,168.91 145.23,169.08 145.69,169.08 145.85,169.24 145.85,169.47 145.69,169.64 145.23,169.64 145.07,169.8 145.07,170.03 145.23,170.19 145.69,170.19 145.85,170.36 145.85,170.59 145.69,170.75 145.23,170.75 145.07,170.92 145.07,171.15 145.23,171.31 145.69,171.31 145.85,171.48 145.85,171.81 v4(145.15,172.51) 144.15,173.51 144.15,178.37 144.15,178.38 144.15,178.68 147.81,182.34 148.69,182.34 149.03,182.67 v1(149.03,182.67)
  BOTTOM w0.084: v1(146.2,163.59) 146.2,163.58 147.05,162.74 147.05,161.87 146.87,161.7 146.87,161.42 146.97,161.32 146.97,160.99 UV1.AD3
  BOTTOM w0.14: v1(149.03,182.67) 149.03,182.66 UV8.B4
FBB1_D7: length 31.7
  TOP w0.14: v1(148.02,181.85) 144.63,178.47 144.63,173.72 v4(146.95,171.4) 147.23,171.12 147.23,170.79 147.06,170.63 146.52,170.63 146.36,170.46 146.36,170.23 146.52,170.07 147.06,170.07 147.23,169.91 147.23,169.67 147.06,169.51 146.52,169.51 146.36,169.35 146.36,169.11 146.52,168.95 147.06,168.95 147.23,168.79 147.23,168.56 147.06,168.39 146.52,168.39 146.36,168.23 146.36,168 146.52,167.83 147.06,167.83 147.23,167.67 147.23,167.44 147.06,167.28 146.52,167.28 146.36,167.11 146.36,166.88 146.52,166.72 147.06,166.72 147.23,166.55 147.23,163.77 146.41,162.96 146.21,162.96 146.18,162.98 v1(146.2,162.98)
  BOTTOM w0.084: UV1.AD5 146.8,160.36 146.8,161.25 146.7,161.35 146.7,161.77 146.86,161.93 146.86,161.94 146.87,161.95 146.87,162.32 v1(146.2,162.98)
  BOTTOM w0.14: UV8.A4 148.45,182.29 v1(148.02,181.85)
FBB1_D8: length 14.6
  IN3 w0.14: v1(148.2,174.69) 148.41,174.48 148.41,165.61 149.56,164.45 v1(149.61,164.45)
  BOTTOM w0.084: UV1.AF1 148.8,163.51 149.61,164.33 v1(149.61,164.45)
  BOTTOM w0.14: UV8.A13 v1(148.2,174.69)
FBB1_D9: length 18.3
  IN3 w0.14: v1(149.6,163.74) 147.43,165.91 147.43,174.66 147.9,175.14 148.29,175.14 148.57,175.43 148.57,175.73 149,176.16 v1(149,176.29)
  BOTTOM w0.084: UV1.AF3 148.8,161.06 149.14,161.41 149.14,162.2 149.06,162.28 149.06,163.21 v1(149.6,163.74)
  BOTTOM w0.14: UV8.B11 v1(149,176.29)
FBB1_D10: length 20.3
  IN3 w0.084: 147.45,164.25 148.01,164.25 149.13,163.13 v1(149.61,163.13)
  IN3 w0.14: 147.45,164.25 146.84,164.86 146.84,174.93 v1(148.2,176.29)
  BOTTOM w0.084: v1(149.61,163.13) 149.23,162.75 149.23,162.35 149.31,162.27 149.31,161.34 149.27,161.3 149.27,161.02 149.15,160.9 149.15,159.84 149,159.69 UV1.AF6
  BOTTOM w0.14: UV8.A11 v1(148.2,176.29)
FBB1_D11: length 15.9
  IN3 w0.14: v1(149,174.69) 149.26,174.43 149.26,173.5 148.75,172.99 148.75,165.9 v1(149.61,165.04)
  BOTTOM w0.084: v1(149.61,165.04) 149.99,164.66 149.99,161.91 arc(149.92,161.82) 149.88,161.72 arc(149.87,161.59) 149.88,161.46 arc(149.91,161.39) 149.94,161.33 arc(149.98,161.24) 150,161.15 arc(150,161.12) 149.99,161.08 arc(149.96,161.03) 149.93,160.97 149.6,160.64 UV1.AG4
  BOTTOM w0.14: UV8.B13 v1(149,174.69)
FBB1_D12: length 16.2
  IN3 w0.084: v1(150.88,165.04) 150.91,165.06 150.91,165.11
  IN3 w0.14: 150.91,165.11 150.91,166.41 151.19,166.69 151.19,172.87 151.4,173.08 v1(151.4,174.69)
  BOTTOM w0.084: UV1.AH5 150.4,160.26 150.12,160.54 arc(150.09,160.6) 150.05,160.66 arc(150.02,160.75) 150.05,160.84 arc(150.07,160.87) 150.08,160.91 arc(150.11,160.95) 150.13,160.99 arc(150.17,161.08) 150.17,161.19 arc(150.14,161.3) 150.08,161.41 arc(150.06,161.46) 150.04,161.51 arc(150.03,161.59) 150.04,161.67 arc(150.07,161.74) 150.11,161.8 150.15,161.84 150.15,164.59 150.6,165.04 v1(150.88,165.04)
  BOTTOM w0.14: UV8.E13 v1(151.4,174.69)
FBB1_D13: length 20.2
  IN3 w0.14: v1(152.2,176.29) 152.6,175.89 153.17,175.89 153.4,175.66 153.4,172.53 152.33,171.46 152.33,165.82 152.13,165.62 152.13,163.21 151.68,162.76 v1(151.34,162.76)
  BOTTOM w0.084: v1(151.34,162.76) 151.33,162.76 151.33,162.72 151.63,162.43 151.63,161.89 151.5,161.77 151.5,161.35 151.62,161.24 151.62,161.12 151.55,161.04 151.55,160.11 UV1.AH6
  BOTTOM w0.14: UV8.F11 v1(152.2,176.29)
FBB1_D14: length 18.6
  IN3 w0.14: v1(151.43,163.34) 151.43,163.34 151.43,163.32 151.71,163.32 151.85,163.46 151.85,164.23 151.76,164.31 151.76,165.73 151.99,165.96 151.99,172.24 152.6,172.85 152.6,174.89 152.4,175.09 152.03,175.09 151.8,175.32 151.8,175.71 151.4,176.11 v1(151.4,176.29)
  BOTTOM w0.084: UV1.AJ4 150.85,160.71 150.85,161.18 arc(150.85,161.23) 150.86,161.27 arc(150.87,161.3) 150.89,161.32 arc(150.92,161.37) 150.96,161.42 150.97,161.43 150.97,161.87 150.72,162.12 150.72,162.69 151.37,163.34 v1(151.43,163.34)
  BOTTOM w0.14: UV8.E11 v1(151.4,176.29)
FBB1_D15: length 15.2
  IN3 w0.14: v1(151.44,163.97) 151.42,164 151.42,165.88 151.64,166.11 151.64,172.69 152.2,173.24 152.2,174.62 v1(152.17,174.66)
  BOTTOM w0.084: UV1.AK3 151.8,160.96 151.8,161.3 151.67,161.42 151.67,161.7 151.8,161.82 151.8,163.62 v1(151.44,163.97)
  BOTTOM w0.14: UV8.F13 v1(152.17,174.66)
FBB1_D16: length 21.1
  IN3 w0.084: 149.79,159.2 149.79,158.46 149.45,158.12 v1(149.41,158.12)
  IN3 w0.14: 149.79,159.2 149.79,159.68 151.95,161.84 151.95,162.47 156.24,166.77 v5(156.24,173.22)
  BOTTOM w0.084: UV1.AF8 148.85,157.56 v1(149.41,158.12)
  BOTTOM w0.14: UV8.M13 157,174.69 157,173.98 v5(156.24,173.22)
FBB1_D17: length 22.5
  IN3 w0.084: v1(149.36,156.78) 149.87,157.28 149.87,157.55 150.06,157.74 150.06,158.92
  IN3 w0.14: v3(157.8,174.69) 157.54,174.43 157.54,167.43 152.28,162.17 152.28,161.66 150.06,159.44 150.06,158.92
  BOTTOM w0.084: UV1.AF9 149.34,156.76 v1(149.36,156.78)
  BOTTOM w0.14: UV8.N13 v3(157.8,174.69)
FBB1_D18: length 24.6
  IN3 w0.084: 150.27,158.79 150.27,157.47 v1(150.6,157.14)
  IN3 w0.14: 150.27,158.79 150.76,159.27 151.06,159.27 153.5,161.71 153.5,162.52 158.57,167.6 158.57,175.52 v1(157.8,176.29)
  BOTTOM w0.084: UV1.AG8 150.42,157.14 v1(150.6,157.14)
  BOTTOM w0.14: UV8.M11 v1(157.8,176.29)
FBB1_D19: length 26.4
  IN3 w0.14: v1(150.65,157.9) 151.21,158.46 151.21,158.97 153.9,161.66 153.9,162.17 159.16,167.43 159.16,169.55 159.33,169.71 159.79,169.71 159.95,169.87 159.95,170.1 159.79,170.27 159.33,170.27 159.16,170.43 159.16,170.66 159.33,170.83 159.79,170.83 159.95,170.99 159.95,171.22 159.79,171.39 159.33,171.39 159.16,171.55 159.16,172.75 v5(159.4,172.99)
  BOTTOM w0.084: v1(150.65,157.9) 150.46,157.9 UV1.AG7
  BOTTOM w0.14: UV8.N11 158.57,176.32 158.57,173.4 158.99,172.99 v5(159.4,172.99)
FBB1_D20: length 28.2
  IN3 w0.14: v1(161.01,176.28) 161.42,176.69 162.09,176.69 163,175.78 163,166.84 157.16,161 157.16,159.6 155.15,157.6 154.64,157.6 153.38,156.34 v1(152.62,156.34)
  BOTTOM w0.089: UV1.AK9 v1(152.62,156.34)
  BOTTOM w0.14: v1(161.01,176.28) UV8.T11
FBB1_D21: length 20.6
  IN3 w0.14: v1(153.41,158.74) 153.83,159.17 153.83,159.3 161.8,167.27 v1(161.8,174.69)
  BOTTOM w0.084: v1(153.41,158.74) 153.02,158.36 UV1.AL7
  BOTTOM w0.14: UV8.U13 v1(161.8,174.69)
FBB1_D22: length 24.5
  IN3 w0.14: v1(161.8,176.29) 162.64,175.45 162.64,167.02 155.66,160.03 155.66,158.71 154.92,157.98 v1(153.4,157.98)
  BOTTOM w0.089: UV1.AM8 153.8,157.57 153.4,157.98 v1(153.4,157.98)
  BOTTOM w0.14: v1(161.8,176.29) UV8.U11
FBB1_D23: length 22.1
  IN3 w0.14: v1(154.2,158.76) 154.73,159.3 154.73,159.64 162.21,167.12 162.21,174.94 162.06,175.09 161.4,175.09 v1(161,175.49)
  BOTTOM w0.089: UV1.AM7 154.2,158.76 v1(154.2,158.76)
  BOTTOM w0.14: v1(161,175.49) UV8.T13
FBB1_D24: length 32.5
  BOTTOM w0.084: UV1.AK1 152,164.25
  BOTTOM w0.14: UV8.M4 157.4,182.05 157,181.65 157,180.18 158.79,178.39 161.18,178.39 162.33,177.23 162.33,173.62 161.83,173.12 160.38,173.12 159.01,171.75 158.78,171.75 158.38,172.15 158.15,172.15 157.98,171.99 157.98,171.76 158.39,171.35 158.39,171.12 158.22,170.96 157.99,170.96 157.59,171.36 157.36,171.36 157.19,171.2 157.19,170.97 157.6,170.56 157.6,170.33 v4(153.97,166.7) 152,164.73 152,164.25
FBB1_D25: length 33.8
  BOTTOM w0.084: 154.39,166.05 154.39,164.99 153.22,163.82 153.22,161.88 153.1,161.77 153.1,161.35 153.23,161.23 153.23,160.79 UV1.AL4
  BOTTOM w0.14: UV8.N4 157.82,181.91 157.82,180.04 159.06,178.8 161.5,178.8 162.9,177.41 162.9,173.5 162.03,172.63 160.58,172.63 156.32,168.37 156.32,168.14 v4(156.51,167.95) 156.76,167.7 156.76,167.47 156.6,167.3 156.37,167.3 155.93,167.75 155.7,167.75 155.53,167.58 155.53,167.35 155.97,166.91 155.97,166.68 155.81,166.51 155.58,166.51 155.14,166.95 154.91,166.95 154.39,166.44 154.39,166.05
FBB1_D26: length 32.9
  BOTTOM w0.084: 155.75,163.61 155.04,162.9 154.69,162.9 154.1,162.31 154.1,161.32 154.07,161.3 154.07,161.02 154.1,161 154.1,160.55 153.98,160.44 153.98,159.68 153.8,159.5 UV1.AM6
  BOTTOM w0.14: UV8.U4 163.22,182.29 164.83,180.68 164.83,172.7 162.83,170.7 161.38,170.7 161.02,170.33 v4(161.02,169.25) 161.02,168.88 160.91,168.77 160.68,168.77 160.19,169.26 159.96,169.26 159.79,169.1 159.79,168.87 160.28,168.38 160.28,168.15 155.75,163.61
FBB1_D27: length 31.8
  BOTTOM w0.084: UV1.AM1 153.73,161.69 153.73,162.96 154.78,164.01
  BOTTOM w0.14: 154.78,164.01 158.83,168.06 158.83,169.51 v4(159.81,170.49) 160.98,171.66 162.43,171.66 163.87,173.1 163.87,177.99 163.43,178.42 163.43,178.8 163.84,179.21 163.84,179.44 163.67,179.6 163.44,179.6 162.92,179.08 162.69,179.08 162.53,179.25 162.53,179.48 163.05,180 163.05,180.23 162.88,180.39 162.65,180.39 162.12,179.86 161.89,179.86 161.73,180.03 161.73,180.26 162.26,180.79 162.26,181.02 162.09,181.18 161.86,181.18 161.64,180.96 161.4,180.96 160.99,181.37 160.99,181.68 160.6,182.07 UV8.T4
FBB1_D28: length 31.7
  BOTTOM w0.084: 156.11,163.29 155.01,162.19 155.01,162.05 154.77,161.81 154.77,160.73 UV1.AN4
  BOTTOM w0.14: UV8.U2 162.31,183.89 165.32,180.88 165.32,172.5 162.59,169.76 162.35,169.76 161.92,170.2 161.68,170.2 161.52,170.04 161.52,169.81 161.96,169.37 161.96,169.14 v4(159.9,167.08) 156.11,163.29
FBB1_D29: length 36.4
  BOTTOM w0.084: UV1.AP3 155.2,160.9 155.81,161.51 155.81,161.74 156.6,162.52 156.83,162.52
  BOTTOM w0.14: UV8.N2 158.2,184.17 158.56,184.52 158.56,185.26 158.86,185.56 162.03,185.56 166.29,181.31 166.29,171.98 v4(164.74,170.44) 156.83,162.52
FBB1_D30: length 30.7
  BOTTOM w0.084: 155.7,162.19 155.56,162.05 155.56,161.92 UV1.AP1
  BOTTOM w0.14: UV8.T2 161.06,184.35 162.53,184.35 165.8,181.08 165.8,172.3 v4(162.95,169.44) 155.7,162.19
FBB1_D31: length 39.4
  BOTTOM w0.102: UV1.AP5 155.57,160.33 155.57,160.73 155.98,161.14 156.1,161.14 156.4,161.44 156.4,161.69 156.72,162.02
  BOTTOM w0.14: 156.72,162.02 157.08,162.02 166.77,171.71 v4(166.77,173.57) 166.77,181.51 162.31,185.97 158.3,185.97 157.76,185.42 157.76,184.26 157.4,183.9 UV8.M2
FBB1_DBI0#: length 31.4
  TOP w0.14: v1(150.57,184.32) 150.37,184.32 149.79,183.73 146.92,183.73 143.06,179.88 v4(143.06,176.42) 143.06,173.24 144.07,172.22 144.07,166.54 145.4,165.22 145.4,164.86 146.08,164.17 v1(146.2,164.17)
  BOTTOM w0.084: v1(146.2,164.17) 145.69,163.66 145.69,162.3 145.68,162.3 145.68,162.19 146.13,161.74 146.13,161.4 146.05,161.25 146.05,161.1 146.11,160.93 146.13,160.85 146.13,160.63 146.4,160.36 UV1.AC4
  BOTTOM w0.14: v1(150.57,184.32) UV8.D2
FBB1_DBI1#: length 15.2
  IN3 w0.084: 150.46,165.11 150.46,164.77 v1(150.91,164.33)
  IN3 w0.14: 150.46,165.11 150.46,173.46 150.53,173.52 150.53,174.62 v1(150.6,174.69)
  BOTTOM w0.084: UV1.AH3 150.4,161.05 150.67,161.32 arc(150.69,161.35) 150.7,161.39 arc(150.72,161.41) 150.73,161.44 arc(150.75,161.47) 150.76,161.5 150.76,161.84 150.55,162.05 150.55,162.83 151.06,163.34 151.06,164.17 v1(150.91,164.33)
  BOTTOM w0.14: UV8.D13 v1(150.6,174.69)
FBB1_DBI2#: length 22.4
  IN3 w0.14: v1(159.4,174.69) 159.47,174.69 160.41,173.75 160.41,167.38 152.21,159.18 152.21,158.03 152.04,157.86 v1(151.73,157.86)
  BOTTOM w0.089: v1(151.73,157.86) 151.73,157.66 151.63,157.56 UV1.AJ8
  BOTTOM w0.14: UV8.P13 v1(159.4,174.69)
FBB1_DBI3#: length 32.2
  BOTTOM w0.084: UV1.AM3 153.4,160.96 153.4,161.3 153.27,161.42 153.27,161.7 153.55,161.97 153.55,163.46 154.18,164.1
  BOTTOM w0.14: 154.18,164.1 157.54,167.46 157.54,167.69 157.06,168.17 157.06,168.4 157.23,168.56 157.46,168.56 157.94,168.08 158.17,168.08 158.34,168.26 v4(158.34,168.8) 158.34,169.71 160.78,172.15 162.23,172.15 163.38,173.3 163.38,177.66 161.25,179.8 160.51,179.8 159.48,180.83 159.48,181.33 159.34,181.46 159.34,183.37 159,183.72 UV8.P2
FBB1_EDC0: length 31.8
  TOP w0.14: v1(146.2,164.76) 145.9,165.06 145.9,165.39 144.56,166.74 144.56,172.42 143.55,173.44 v4(143.55,174.21) 143.55,179.68 145.36,181.5 145.6,181.5 145.82,181.27 146.06,181.27 146.22,181.43 146.22,181.66 145.99,181.89 145.99,182.12 146.16,182.29 146.39,182.29 146.62,182.06 146.85,182.06 147.01,182.22 147.01,182.45 146.78,182.68 146.78,182.91 147.09,183.22 v3(147.35,183.22)
  BOTTOM w0.084: UV1.AB5 145.6,159.96 145.94,160.31 145.94,160.83 145.93,160.87 145.87,161.08 145.87,161.3 145.95,161.46 145.95,161.69 145.52,162.12 145.52,162.37 145.52,162.37 145.52,164.08 v1(146.2,164.76)
  BOTTOM w0.14: UV8.C2 149.86,183.55 148.41,183.55 148.22,183.73 147.86,183.73 v3(147.35,183.22)
FBB1_EDC1: length 20.8
  IN3 w0.084: v1(150.71,163.72) 150.02,164.4 150.02,164.93
  IN3 w0.14: v1(149.8,174.69) 149.7,174.59 149.7,173.53 150.02,173.22 150.02,172.97 149.85,172.81 149.45,172.81 149.28,172.64 149.28,172.41 149.45,172.25 149.85,172.25 150.02,172.08 150.02,171.85 149.85,171.69 149.45,171.69 149.28,171.53 149.28,171.29 149.45,171.13 149.85,171.13 150.02,170.97 150.02,170.73 149.85,170.57 149.45,170.57 149.28,170.41 149.28,170.18 149.45,170.01 149.85,170.01 150.02,169.85 150.02,169.62 149.85,169.45 149.45,169.45 149.28,169.29 149.28,169.06 149.45,168.89 149.85,168.89 150.02,168.73 150.02,168.5 149.85,168.34 149.45,168.34 149.28,168.17 149.28,167.94 149.45,167.78 149.85,167.78 150.02,167.61 150.02,167.38 149.85,167.22 149.45,167.22 149.28,167.05 149.28,166.82 149.45,166.66 149.85,166.66 150.02,166.5 150.02,164.93
  BOTTOM w0.084: v1(150.71,163.72) 150.36,163.37 150.36,161.6 UV1.AH1
  BOTTOM w0.14: UV8.C13 v1(149.8,174.69)
FBB1_EDC2: length 23.3
  IN3 w0.14: v1(151.81,157.18) 152.51,157.88 152.51,158.66 161.27,167.42 161.27,173.8 160.38,174.69 v1(160.2,174.69)
  BOTTOM w0.089: UV1.AJ9 151.62,157.18 v1(151.81,157.18)
  BOTTOM w0.14: UV8.R13 v1(160.2,174.69)
FBB1_EDC3: length 33.5
  BOTTOM w0.084: 155.46,164.01 153.93,162.48 153.93,161.39 153.9,161.37 153.9,160.95 153.93,160.93 153.93,160.62 153.6,160.29 UV1.AM5
  BOTTOM w0.14: 155.46,164.01 159.31,167.86 159.31,169.31 161.18,171.18 v4(161.75,171.18) 162.63,171.18 164.35,172.9 164.35,179.61 163.89,180.07 163.89,180.3 164.06,180.48 164.06,180.71 163.9,180.87 163.67,180.87 163.49,180.7 163.26,180.7 163.1,180.86 163.1,181.09 163.27,181.27 163.27,181.5 163.11,181.67 162.88,181.67 162.7,181.49 162.47,181.49 162.06,181.9 161.3,181.9 160.99,182.21 160.99,183.33 160.84,183.48 160.43,183.48 160.02,183.89 UV8.R2
FBB_ADBIB0: length 34.8
  IN1 w0.084: v1(140.85,158.69) 140.95,158.79 140.95,160.29 140.4,160.84 140.4,162.62 140.29,162.73
  IN1 w0.14: 140.29,162.73 140.2,162.82 140.2,164.96 141.47,166.24 141.47,178.34 140.77,179.03 140.77,179.76 140.61,179.92 140.38,179.92 140.22,179.76 140.22,179.39 140.05,179.22 139.82,179.22 139.66,179.39 139.66,179.76 139.49,179.92 139.26,179.92 139.1,179.76 139.1,179.39 138.93,179.22 136.64,179.22 135.8,180.06 133.62,180.06 132.97,180.71 132.97,181.52 v1(132.56,181.93)
  BOTTOM w0.084: UV1.T7 140.73,158.69 v1(140.85,158.69)
  BOTTOM w0.14: v1(132.56,181.93) 132.64,181.93 UV7.J4
FBB_ADBIB1: length 35.8
  IN1 w0.084: 144.21,162.73 144.21,160.45 143.43,159.67 v1(143.43,158.86)
  IN1 w0.14: v1(154.59,182.66) 154.2,182.27 151.15,182.27 150.2,181.32 148.88,181.32 148.44,180.89 147.15,180.89 146.93,180.67 146.93,180.44 147.15,180.23 147.15,180 146.98,179.83 146.75,179.83 146.54,180.04 146.31,180.04 146.14,179.88 146.14,179.65 146.36,179.44 146.36,179.21 146.19,179.04 145.96,179.04 145.75,179.25 145.52,179.25 145.35,179.09 145.35,178.86 145.56,178.65 145.56,178.42 145.4,178.25 145.17,178.25 144.96,178.46 144.73,178.46 144.21,177.95 144.21,162.73
  BOTTOM w0.084: UV1.W7 143.3,158.86 v1(143.43,158.86)
  BOTTOM w0.14: UV8.J4 154.59,182.7 v1(154.59,182.66)
FBB_CASB0#: length 37.3
  IN1 w0.084: v1(142.2,156.25) 141.96,156.48 141.96,159.19 143.44,160.67 143.44,162.42 143.19,162.68 143.19,162.73
  IN1 w0.14: 143.19,162.73 143.19,181.17 141.23,183.12 138.45,183.12 138.28,183.29 138.28,183.67 138.12,183.83 137.89,183.83 137.73,183.67 137.73,183.29 137.56,183.12 135.44,183.12 v1(134.98,182.67)
  BOTTOM w0.084: UV1.W10 142.51,156.25 v1(142.2,156.25)
  BOTTOM w0.14: v1(134.98,182.67) 134.98,182.71 UV7.L3
FBB_CASB1#: length 39.7
  IN1 w0.084: v1(144.63,156.27) 144.37,156.27 144.21,156.11 144.21,155.89 144.41,155.69 145.15,155.69 145.44,155.98 145.44,157.19 145.41,157.23 145.41,158.04 145.47,158.1 145.47,159.63 147.35,161.51 147.35,161.91
  IN1 w0.14: 147.35,161.91 147.35,165.3 147.01,165.64 147.01,169.45 147.17,169.61 147.67,169.61 147.83,169.78 147.83,170.01 147.67,170.17 147.17,170.17 147.01,170.34 147.01,170.57 147.17,170.73 147.67,170.73 147.83,170.9 147.83,171.13 147.67,171.29 147.17,171.29 147.01,171.45 147.01,171.71 147.17,171.87 148.16,171.87 148.64,172.34 148.64,172.57 148.46,172.75 148.46,172.98 148.62,173.14 148.86,173.14 149.07,172.93 149.2,172.93 149.32,173.05 149.32,174.3 149.4,174.38 149.4,177.26 150.22,178.08 152.21,178.08 153.57,179.44 v5(153.96,179.44)
  BOTTOM w0.084: v1(144.63,156.27) 144.95,155.96 UV1.AA10
  BOTTOM w0.14: v5(153.96,179.44) 152.96,180.43 152.96,182.54 153.4,182.97 UV8.G3
FBB_CKEB0: length 37.7
  IN1 w0.084: v1(141.03,156.22) 141.78,156.98 141.78,159.46 142.64,160.33 142.64,162.48 142.84,162.67 142.84,162.73
  IN1 w0.14: 142.84,162.73 142.84,180.95 141.56,182.23 134.75,182.23 134.67,182.32 133.96,182.32 133.71,182.56 133.71,183.2 v1(133.38,183.53)
  BOTTOM w0.084: UV1.U10 141.29,155.96 v1(141.03,156.22)
  BOTTOM w0.114: v1(133.38,183.53) 133.38,183.47 UV7.J3
FBB_CKEB1: length 38.8
  IN1 w0.084: v1(143.44,155.78) 142.73,156.49 142.73,159.61 143.67,160.55 143.67,162.47 143.53,162.61 143.53,162.73
  IN1 w0.14: 143.53,162.73 143.53,178.23 149.19,183.9 154.24,183.9 v1(154.62,183.52)
  BOTTOM w0.084: UV1.AA11 144.17,155.59 144.16,155.58 143.64,155.58 v1(143.44,155.78)
  BOTTOM w0.14: UV8.J3 155,183.13 v1(154.62,183.52)
FBB_CLKB0: length 39.6
  TOP w0.127: RV66.1 132.81,173.49 v3(132.81,174.36) 132.81,175.65 132.93,175.78 133.11,175.78 v1(133.4,175.49)
  IN1 w0.084: v1(137.52,157.12) 137.83,157.43 137.83,158 137.62,158.21 137.31,158.21 136.06,159.45 136.06,160.1 136.1,160.14 136.1,160.16
  IN1 w0.14: 136.1,160.16 136.1,162.52 134.83,163.79 134.83,164.94 134.35,165.42 133.03,165.42 132.84,165.61 132.84,166.13 133.23,166.52 133.23,167.2 132.86,167.57 130.89,167.57 130.75,167.71 130.75,168.1 130.94,168.29 132.99,168.29 133.32,168.62 133.32,169.09 132.99,169.42 130.87,169.42 130.65,169.64 130.65,169.9 130.82,170.07 132.76,170.07 133.09,170.4 133.09,170.87 132.76,171.2 130.99,171.2 130.8,171.39 130.8,171.66 130.99,171.85 132.3,171.85 132.63,172.18 132.63,175.18 132.94,175.49 v1(133.4,175.49)
  BOTTOM w0.084: v1(137.52,157.12) 137.16,157.12 UV1.L9
  BOTTOM w0.127: UV7.J12 v1(133.4,175.49)
FBB_CLKB0#: length 39.4
  TOP w0.127: RV67.2 132.58,173.48 132.58,175.74 132.84,176 133.11,176 v1(133.4,176.29)
  IN1 w0.084: v1(137.45,157.83) 135.89,159.38 135.89,160.1 135.86,160.14 135.86,160.16
  IN1 w0.14: 135.86,160.16 135.86,162.42 134.59,163.69 134.59,164.84 134.25,165.18 132.93,165.18 132.59,165.51 132.59,166.23 132.99,166.62 132.99,167.1 132.76,167.32 130.79,167.32 130.51,167.61 130.51,168.2 130.84,168.53 132.89,168.53 133.08,168.72 133.08,168.99 132.89,169.18 130.77,169.18 130.41,169.54 130.41,170 130.72,170.31 132.66,170.31 132.85,170.5 132.85,170.77 132.66,170.96 130.89,170.96 130.56,171.29 130.56,171.76 130.89,172.09 132.2,172.09 132.39,172.28 132.39,175.28 v1(133.4,176.29)
  BOTTOM w0.084: UV1.L8 137.21,157.56 137.45,157.8 v1(137.45,157.83)
  BOTTOM w0.127: UV7.J11 v1(133.4,176.29)
FBB_CLKB1: length 39.9
  TOP w0.127: RV78.1 154.81,173.49 154.81,175.65 154.93,175.78 155.11,175.78 v1(155.4,175.49)
  IN1 w0.084: 148.77,160.42 148.75,160.41 148.7,160.41 148.48,160.19 148.48,159.3 147.52,158.34 147.52,158.12 147.61,158.03 147.99,158.03 v1(148.11,158.15)
  IN1 w0.14: 148.77,160.42 150.28,161.94 150.28,165.22 150.86,165.81 150.86,166.28 151.54,166.96 152.01,166.96 152.56,167.5 152.56,167.98 151.53,169.01 151.53,169.39 151.69,169.56 151.96,169.56 153.26,168.26 153.72,168.26 154.06,168.59 154.06,169.06 152.81,170.31 152.81,170.57 153,170.76 153.27,170.76 154.51,169.52 154.98,169.52 155.31,169.85 155.31,170.32 154.07,171.56 154.07,171.83 154.26,172.02 154.53,172.02 155.41,171.14 155.88,171.14 156.21,171.47 156.21,171.94 155.58,172.57 155.58,173.55 154.63,174.5 154.63,175.69 154.88,175.94 155.2,175.94 155.4,175.74 v1(155.4,175.49)
  BOTTOM w0.084: UV1.AD8 148.11,158.07 v1(148.11,158.15)
  BOTTOM w0.127: UV8.J12 v1(155.4,175.49)
FBB_CLKB1#: length 39.6
  TOP w0.127: RV79.2 154.58,173.48 v3(154.58,174.33) 154.58,175.74 154.84,176 155.11,176 v1(155.4,176.29)
  IN1 w0.084: v1(147,158.18) 147.12,158.18 148.32,159.37 148.32,160.26 148.58,160.53 148.58,160.58 148.6,160.59
  IN1 w0.14: v1(155.4,176.29) 155.29,176.18 154.78,176.18 154.39,175.79 154.39,174.4 155.34,173.45 155.34,172.47 155.97,171.84 155.97,171.57 155.78,171.38 155.51,171.38 154.63,172.26 154.16,172.26 153.83,171.93 153.83,171.46 155.07,170.22 155.07,169.95 154.88,169.76 154.61,169.76 153.37,171 152.9,171 152.57,170.67 152.57,170.21 153.81,168.96 153.81,168.69 153.62,168.5 153.36,168.5 152.06,169.8 151.59,169.8 151.29,169.49 151.29,168.91 152.32,167.88 152.32,167.6 151.91,167.2 151.44,167.2 150.62,166.38 150.62,165.91 150.04,165.32 150.04,162.04 148.6,160.59
  BOTTOM w0.102: UV1.AD7 147.18,158.36 v1(147,158.18)
  BOTTOM w0.127: UV8.J11 v1(155.4,176.29)
FBB_CSB0#: length 36.7
  IN1 w0.084: 135.03,159.32 135.03,158.41 137.05,156.39 138.02,156.39 138.4,156.01 v1(138.6,156.01)
  IN1 w0.14: v1(131,175.49) 130.59,175.08 130.59,174.41 130.41,174.23 130.41,173.34 127.97,170.91 127.97,168.29 128.33,167.93 128.33,167.7 127.65,167.01 127.65,166.78 127.81,166.62 128.04,166.62 128.73,167.3 128.96,167.3 129.12,167.14 129.12,166.91 128.48,166.26 128.48,166.03 128.64,165.87 128.87,165.87 129.52,166.51 129.75,166.51 129.91,166.35 129.91,166.12 129.36,165.56 129.36,165.33 129.52,165.16 129.75,165.16 130.31,165.72 130.54,165.72 130.7,165.56 130.7,165.33 130.24,164.86 130.24,164.63 130.4,164.46 130.63,164.46 131.1,164.93 131.33,164.93 131.49,164.77 131.49,164.53 130.91,163.95 130.91,163.72 131.08,163.56 131.31,163.56 131.89,164.14 132.12,164.14 132.47,163.79 132.47,162.14 135.03,159.58 135.03,159.32
  BOTTOM w0.084: UV1.P10 138.65,155.96 v1(138.6,156.01)
  BOTTOM w0.14: UV7.G12 v1(131,175.49)
FBB_CSB1#: length 36.6
  IN1 w0.084: v1(146.95,156.94) 147.3,157.29 148.37,157.29 148.6,157.52 149.59,157.52 149.99,157.93 149.99,159.02
  IN1 w0.14: 149.99,159.02 149.99,159.5 152.22,161.72 152.22,162.49 154.95,165.22 154.95,165.46 154.54,165.87 154.54,166.1 154.7,166.27 154.93,166.27 155.35,165.85 155.58,165.85 155.74,166.01 155.74,166.25 155.33,166.66 155.33,166.89 155.49,167.06 155.72,167.06 156.14,166.64 156.37,166.64 156.54,166.81 156.54,167.04 156.12,167.45 156.12,167.68 156.28,167.85 156.51,167.85 156.93,167.43 157.16,167.43 157.34,167.61 157.34,168.28 157.5,168.45 158.01,168.45 158.17,168.61 158.17,168.84 158.01,169.01 157.24,169.01 157.08,169.17 157.08,169.4 157.24,169.57 158.01,169.57 158.17,169.73 158.17,169.96 158.01,170.12 157.19,170.12 157.03,170.29 157.03,170.52 157.19,170.68 158.01,170.68 158.17,170.85 158.17,171.08 158.01,171.24 157.5,171.24 157.34,171.41 157.34,171.64 157.5,171.8 158.01,171.8 158.17,171.96 158.17,172.2 158.01,172.36 157.5,172.36 157.34,172.52 157.34,175.15 v1(157,175.49)
  BOTTOM w0.084: v1(146.95,156.94) 147.6,156.28 UV1.AD10
  BOTTOM w0.14: UV8.L12 v1(157,175.49)
FBB_D0: length 42
  TOP w0.14: v1(130.2,184.29) 130.2,185.52 129.04,186.68 125.21,186.68 120.2,181.67 120.2,169.25 v4(120.49,168.96) 127.82,161.63 v1(129.53,161.63)
  BOTTOM w0.084: UV1.C5 130.91,159.86 130.54,160.24 130.05,160.24 129.53,160.76 v1(129.53,161.63)
  BOTTOM w0.14: UV7.F2 v1(130.2,184.29)
FBB_D1: length 38.4
  TOP w0.14: v1(129.4,184.29) 129.4,184.97 128.18,186.2 125.41,186.2 120.7,181.49 v4(120.7,171.87) 120.7,169.46 127.95,162.22 v1(129.39,162.22)
  BOTTOM w0.084: v1(129.39,162.22) 129.72,162.22 130.56,161.38 130.56,161.2 UV1.C3
  BOTTOM w0.14: UV7.E2 v1(129.4,184.29)
FBB_D2: length 34.4
  TOP w0.14: v1(125.63,184.6) 125.18,184.6 121.68,181.1 121.68,169.85 121.93,169.6 122.17,169.6 122.43,169.86 122.66,169.86 122.83,169.7 122.83,169.47 122.56,169.2 122.56,168.97 v4(122.88,168.66) 128.27,163.26 129.5,163.26 129.88,162.88 130.44,162.88 v1(130.46,162.9)
  BOTTOM w0.084: UV1.E3 131.61,161.05 131.61,162.11 130.82,162.9 v1(130.46,162.9)
  BOTTOM w0.14: v1(125.63,184.6) 126.04,184.6 126.37,184.27 127.02,184.27 UV7.B2
FBB_D3: length 34.4
  TOP w0.14: v1(130.18,163.49) 129.77,163.49 129.57,163.69 128.53,163.69 126.5,165.71 126.5,165.98 126.78,166.25 126.78,166.48 126.62,166.65 126.39,166.65 126.11,166.37 125.88,166.37 125.71,166.53 125.71,166.77 125.99,167.04 125.99,167.27 125.83,167.44 125.59,167.44 125.32,167.16 125.09,167.16 124.92,167.33 124.92,167.56 125.2,167.83 125.2,168.06 125.04,168.23 124.8,168.23 124.53,167.95 124.3,167.95 124.13,168.12 124.13,168.35 124.41,168.62 124.41,168.85 124.24,169.02 124.01,169.02 123.74,168.74 123.51,168.74 123.34,168.91 123.34,169.14 123.62,169.41 123.62,169.64 122.3,170.96 v4(122.3,176.9) 122.3,180.91 v1(125.18,183.78)
  BOTTOM w0.084: v1(130.18,163.49) 130.56,163.49 131.9,162.15 UV1.E1
  BOTTOM w0.14: v1(125.18,183.78) 126.49,183.78 UV7.A2
FBB_D4: length 35
  TOP w0.14: v1(125.91,181.85) 125.51,181.85 123.75,180.1 123.75,172.02 125.69,170.08 126.51,170.08 v4(126.87,169.72) 128.63,167.96 128.86,167.96 129.18,168.28 129.41,168.28 129.57,168.11 129.57,167.88 128.89,167.2 128.89,166.97 129.05,166.8 129.28,166.8 129.97,167.49 130.2,167.49 130.36,167.32 130.36,167.09 129.54,166.27 129.54,166.04 129.7,165.87 129.93,165.87 130.76,166.7 130.99,166.7 131.15,166.53 131.15,166.3 130.46,165.6 130.46,165.37 130.62,165.21 130.85,165.21 131.46,165.82 131.66,165.82 131.86,165.62 131.86,165.43 131.63,165.2 131.63,164.96 131.9,164.69 131.9,163.48 v1(131.71,163.29)
  BOTTOM w0.084: UV1.F1 132.6,161.76 132.6,162.18 132.47,162.31 132.47,163.08 132.26,163.29 v1(131.71,163.29)
  BOTTOM w0.14: v1(125.91,181.85) 126.16,181.85 UV7.A4
FBB_D5: length 34.8
  TOP w0.14: v1(132.04,162.79) 131.42,162.79 130.79,163.41 130.79,163.95 129.72,165.01 129.49,165.01 129.18,164.7 128.95,164.7 128.78,164.86 128.78,165.09 129.1,165.41 129.1,165.64 128.93,165.8 128.7,165.8 128.39,165.49 128.16,165.49 127.99,165.65 127.99,165.88 128.31,166.2 128.31,166.43 128.02,166.71 128.02,166.94 128.33,167.24 128.33,167.48 128.16,167.64 127.93,167.64 127.63,167.34 127.4,167.34 127.23,167.5 127.23,167.73 127.54,168.04 127.54,168.27 127.37,168.43 127.14,168.43 126.84,168.13 126.61,168.13 126.44,168.29 126.44,168.52 126.75,168.83 126.75,169.06 126.58,169.22 126.35,169.22 126.05,168.92 125.82,168.92 v4(124.33,170.41) 123.27,171.47 123.27,180.3 125.36,182.39 126.74,182.39 v1(127.02,182.67)
  BOTTOM w0.084: v1(132.04,162.79) 132.29,162.54 132.29,162.25 132.43,162.11 132.43,161.13 UV1.F3
  BOTTOM w0.14: UV7.B4 v1(127.02,182.67)
FBB_D6: length 35.1
  TOP w0.14: v1(132.89,162.41) 132.44,162.86 132.44,162.95 132.38,163.01 132.38,166.03 129.43,168.98 129.19,168.98 128.86,168.65 128.63,168.65 128.46,168.81 128.46,169.04 128.8,169.38 128.8,169.61 128.64,169.77 128.4,169.77 128.07,169.44 127.84,169.44 127.67,169.6 127.67,169.83 128.01,170.17 128.01,170.4 127.84,170.57 127.53,170.57 127.21,170.25 127.03,170.25 126.71,170.57 125.89,170.57 124.24,172.22 v4(124.24,173.8) 124.24,179.14 125.1,180 125.1,180.23 124.96,180.36 124.96,180.6 125.13,180.76 125.36,180.76 125.49,180.62 125.72,180.62 126.52,181.42 127.21,181.42 127.46,181.68 127.46,182.12 127.6,182.26 128.84,182.26 129.27,182.69 v1(129.4,182.69)
  BOTTOM w0.084: v1(132.89,162.41) 132.89,161.94 133.13,161.7 133.13,161.42 133.03,161.32 133.03,161 133.13,160.9 133.13,160.29 UV1.F5
  BOTTOM w0.14: v1(129.4,182.69) UV7.E4
FBB_D7: length 34.8
  TOP w0.14: v1(130.23,181.92) 130.23,182.07 130.09,182.21 129.47,182.21 129.27,182.01 129.27,181.08 129,180.81 128.75,180.81 128.56,181 128.56,181.61 128.42,181.75 128.2,181.75 128,181.55 128,181.1 127.83,180.94 127.38,180.94 126.72,180.94 126.58,180.79 126.58,180.56 126.72,180.42 126.72,180.19 126.55,180.03 126.32,180.03 126.18,180.17 125.95,180.17 125.79,180 125.79,179.77 125.93,179.63 125.93,179.4 125.76,179.24 125.53,179.24 125.39,179.38 125.16,179.38 124.72,178.93 124.72,172.42 126.09,171.05 128.04,171.05 v4(130.01,169.09) 132.87,166.23 132.87,165.65 133.1,165.41 133.1,165.01 132.87,164.78 132.87,164.59 133.13,164.33 133.13,163.77 132.87,163.51 132.87,163.04 v1(132.9,163.01)
  BOTTOM w0.084: v1(132.9,163.01) 133.24,162.66 133.24,162.14 133.19,162.09 133.19,161.87 133.3,161.77 133.3,161.35 133.19,161.25 133.19,161.07 133.3,160.97 133.3,160.66 UV1.G4
  BOTTOM w0.14: UV7.F4 v1(130.23,181.92)
FBB_D8: length 22.9
  IN3 w0.14: v1(126.2,176.29) 125.68,176.29 124.97,175.58 124.97,170.96 132.52,163.41 133.7,163.41 v1(133.82,163.29)
  BOTTOM w0.084: v1(133.82,163.29) 134.21,163.29 134.61,162.9 134.61,161.81 134.78,161.65 134.78,161.44 134.7,161.37 134.7,160.95 134.75,160.9 134.75,160.62 134.4,160.26 UV1.H5
  BOTTOM w0.14: UV7.A11 v1(126.2,176.29)
FBB_D9: length 20.8
  IN3 w0.084: 134.25,163.82 134.8,163.26 134.8,162.85 v1(134.98,162.68)
  IN3 w0.14: 134.25,163.82 133.82,164.25 132.85,164.25 126.2,170.9 v1(126.2,174.69)
  BOTTOM w0.084: v1(134.98,162.68) 134.85,162.55 134.85,161.81 134.95,161.72 134.95,161.37 134.87,161.3 134.87,161.02 134.92,160.97 134.92,160.55 134.78,160.4 134.78,159.68 134.26,159.16 UV1.H6
  BOTTOM w0.14: UV7.A13 v1(126.2,174.69)
FBB_D10: length 22.8
  IN3 w0.14: v1(127,176.29) 126.57,175.86 126.57,175.43 126.29,175.14 125.9,175.14 125.56,174.79 125.56,170.88 132.62,163.82 133.58,163.82 v1(133.61,163.85)
  BOTTOM w0.084: UV1.J4 135.2,160.66 135.59,161.05 135.59,161.27 135.5,161.35 135.5,161.77 135.63,161.89 135.63,162.62 134.4,163.85 v1(133.61,163.85)
  BOTTOM w0.14: UV7.B11 v1(127,176.29)
FBB_D11: length 21.7
  IN3 w0.14: v1(127.79,175.48) 127.39,175.08 127.39,173.67 126.96,173.24 126.96,170.65 132.92,164.68 133.47,164.68 v1(133.47,164.67)
  BOTTOM w0.084: v1(133.47,164.67) 133.81,164.67 135.8,162.69 135.8,161.83 135.67,161.7 135.67,161.42 135.8,161.29 135.8,161.03 135.67,160.9 135.67,160.62 135.8,160.49 135.8,160.23 135.67,160.1 135.67,159.29 UV1.K6
  BOTTOM w0.14: UV7.B13 v1(127.79,175.48)
FBB_D12: length 18.8
  IN3 w0.14: v1(129.4,174.69) 129.4,171.74 133.94,167.2 133.94,165.52 134.8,164.66 v1(135.36,164.66)
  BOTTOM w0.084: UV1.K5 136.39,160.35 136.39,161.2 136.5,161.3 136.5,161.77 136.3,161.96 136.3,162.96 135.9,163.35 135.9,164.11 135.68,164.34
  BOTTOM w0.14: 135.68,164.34 v1(135.36,164.66) ; UV7.E13 v1(129.4,174.69)
FBB_D13: length 18
  IN3 w0.14: v1(135.42,165.28) 135.18,165.28 134.28,166.17 134.28,167.77 130.2,171.85 130.2,174.62 v1(130.17,174.66)
  BOTTOM w0.084: v1(135.42,165.28) 136.07,164.62 136.07,163.42 137.04,162.46 137.04,161.55 arc(137.06,161.44) 137.1,161.33 137.12,161.31 arc(137.13,161.28) 137.14,161.25 137.15,161.16 arc(137.15,161.11) 137.14,161.07 137.11,160.99 arc(137.07,160.92) 137.03,160.85 136.89,160.65 arc(136.82,160.51) UV1.L4
  BOTTOM w0.14: UV7.F13 v1(130.17,174.66)
FBB_D14: length 21.3
  IN3 w0.14: v1(135.4,165.97) 135.4,165.97 134.83,166.54 134.83,168.29 130.6,172.52 130.6,174.89 130.4,175.09 130.03,175.09 129.8,175.32 129.8,175.71 129.4,176.11 v1(129.4,176.29)
  BOTTOM w0.084: 135.72,165.64 136.28,165.09 136.28,163.48 137.17,162.59 137.17,162.57 137.21,162.53 137.21,161.57 137.25,161.43 137.29,161.39 arc(137.31,161.36) 137.31,161.34 arc(137.35,161.22) 137.36,161.09 arc(137.34,161.04) 137.33,160.99 arc(137.31,160.95) 137.28,160.91 arc(137.27,160.88) 137.26,160.85 arc(137.25,160.83) 137.25,160.81 137.24,160.8 arc(137.22,160.72) 137.21,160.64 137.21,160.23 137.18,160.19 arc(137.14,160.03) 137.19,159.87 arc(137.35,159.53) UV1.M6
  BOTTOM w0.14: v1(135.4,165.97) 135.72,165.64 ; UV7.E11 v1(129.4,176.29)
FBB_D15: length 18.7
  IN3 w0.14: v1(130.2,176.29) 130.81,176.29 131.4,175.7 131.4,173.07 135.46,169 v1(135.46,166.61)
  BOTTOM w0.084: UV1.M1 137.6,161.68 137.41,161.87 137.41,162.61 136.51,163.51 136.51,163.87
  BOTTOM w0.14: UV7.F11 v1(130.2,176.29) ; 136.51,163.87 136.51,165.57 v1(135.46,166.61)
FBB_D16: length 17.9
  IN3 w0.14: v1(135.8,176.29) 136.57,175.52 136.57,172.79 138.03,171.33 138.03,165.14 v1(136.96,164.07)
  BOTTOM w0.084: v1(136.96,164.07) 136.96,163.32 137.59,162.69 137.59,162.06 137.95,161.7 137.95,161.5 137.94,161.46 137.9,161.38 137.8,161.23 UV1.M3
  BOTTOM w0.14: UV7.M11 v1(135.8,176.29)
