# Allegro board Lenovo ThinkPad E460 E560 BE560 NM-A561 boardview.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+PCH_CORE on IN1: 96.07,96.28 97.34,96.28 97.9,95.72 97.9,93.23 98.91,92.22 99.29,92.22 99.57,91.94 99.57,91.35 99.4,91.18 97.57,91.18 95.84,92.9 95.84,96.05
+RTCVCC on TOP (solid shape): 102.74,83.22 102.74,80.56 104.45,78.84 106.21,78.84 106.21,78.84 106.65,78.84 106.67,78.83 106.86,78.78 107.06,78.83 107.07,78.84 110.94,78.84 114.81,74.97 117.22,74.97 117.78,75.53 118.28,75.53 118.42,75.39 118.42,74.21 114.41,74.21 110.66,77.95 104.2,77.95 101.4,80.75 101.4,82.72 101.97,83.29 102.67,83.29
+RTCVCC on IN3: 98.61,85.32 98.1,85.83 98.1,88.24 98.61,88.75 98.61,89.13 98.55,89.19 97.72,89.19 97.59,89.07 97.59,84.18 100.51,81.26 101.78,81.26 101.97,81.45 101.97,81.89 101.85,82.02 100.83,82.02 98.61,84.24
+USB_VCCA on TOP (solid shape): 26.27,25.9 26.27,24.47 26.02,24.22 24.09,24.22 23.59,23.73 22.41,23.73 21.9,24.23 21.9,26 22.18,26.28 25.89,26.28
+USB_VCCA on TOP (solid shape): 24.19,47 24.19,46.6 22.38,44.79 19.34,44.79 19.01,44.46 16.06,44.46 15.4,45.12 14.05,45.12 13.52,45.66 13.52,46.47 13.95,46.9 15.42,46.9 16.34,45.99 17.28,45.99 17.28,45.94 17.66,45.56 18.04,45.94 18.04,45.99 21.19,45.99 21.65,46.45 21.65,46.47 22.13,46.95 22.82,46.95 23.3,47.44 23.76,47.44
+USB_VCCA on BOTTOM (solid shape): 18.57,50.28 18.57,49.75 18.8,49.52 21.82,49.52 22.08,49.27 23.22,49.27 23.82,48.67 23.82,46.7 23.27,46.15 23.27,45.84 22.15,44.72 14,44.72 13.54,45.18 13.54,45.94 17.28,45.94 17.28,45.88 17.29,45.83 17.31,45.78 17.34,45.73 17.37,45.68 17.41,45.64 17.46,45.61 17.51,45.59 17.56,45.57 17.62,45.56 17.67,45.56 17.73,45.56 17.78,45.58 17.83,45.6 17.88,45.63 17.92,45.66 17.96,45.7 17.99,45.75 18.02,45.8 18.03,45.85 18.04,45.91 18.04,45.97 18.03,46.02 18.02,46.07 17.99,46.12 17.96,46.17 17.92,46.21 17.88,46.25 17.83,46.28 17.78,46.3 17.73,46.31 17.67,46.32 17.62,46.32 17.56,46.31 17.51,46.29 17.46,46.26 17.41,46.23 17.37,46.19 17.34,46.15 17.31,46.1 17.29,46.05 17.28,45.99 17.28,45.94 13.54,45.94 13.54,46.95 13.87,47.28 14.92,47.28 17.15,49.52 17.84,49.52 17.99,49.67 17.99,50.2 18.17,50.38 18.47,50.38
+USB_VCCA on VCC: 23.02,21.5 21.9,22.62 21.9,47.05 22.77,47.92 28.15,47.92 29.65,46.42 29.65,35.07 28.76,34.18 28.76,22.75 27.51,21.5
+VGA_B+ on TOP (solid shape): 197.62,154.19 197.62,142.15 197.49,142.03 196.14,142.03 195.99,142.18 195.99,142.89 195.54,143.35 195.54,153.2 196.12,153.79 196.12,154.4 196.22,154.5 197.31,154.5
+VGA_B+ on BOTTOM (solid shape): 201.15,160.67 201.15,135.55 200.83,135.23 198.55,135.23 198.43,135.11 198.43,135.04 198.4,135.04 198.4,134.23 198.25,134.23 198.25,135.04 198.24,135.04 198.24,135.12 198.17,135.19 196.7,135.19 196.22,135.68 196.22,141.11 196.12,141.21 196.12,142.91 195.76,143.27 195.76,153.35 196.07,153.66 196.07,156.25 195.87,156.45 195.87,160.77 196.22,161.13 200.69,161.13
+VGA_CORE on TOP (solid shape): 172.32,150.89 174.71,150.89 175.72,149.87 175.72,145.1 174.22,143.6 173.03,143.6 172.24,142.81 167.04,142.81 165.28,144.57 165.28,149.95 166.3,150.97 172.24,150.97
+VGA_CORE on BOTTOM (solid shape): outline of 325 points within 164.5,134.74 178.97,160.81
+VGA_CORE on TOP: 141.04,142.29 140.92,142.41 140.92,143.12 141.02,143.22 145.34,143.22 145.58,143.47 145.58,143.99 145.31,144.27 140.76,144.27 140.56,144.46 139.39,144.46 139.11,144.75 139.11,146 139.1,146 139.1,146.03 138.28,146.85 138.28,148.05 137.96,148.38 137.96,149.11 138.28,149.44 138.28,150.87 138.28,151.05 137.74,151.59 137.74,153.27 137.83,153.35 139.38,153.35 139.98,153.96 140.41,153.96 140.58,153.8 140.58,153.51 140.72,153.36 142.54,153.36 142.69,153.51 142.75,153.51 143.44,153.41 143.21,154.06 143.22,154.11 143.24,154.16 143.26,154.17 146.91,154.17 147.54,153.54 147.54,151.64 147.94,151.25 149.89,151.25 149.91,151.24 150.1,151.17 150.3,151.23 150.34,151.24 150.37,151.22 150.42,151.17 150.42,148.95 150.42,148.95 150.42,148.63 150.53,148.52 150.53,145.7 150.36,145.53 149.54,145.53 149.46,145.57 149.45,145.67 149.12,146.12 148.8,145.67 148.79,145.57 148.7,145.53 147.87,145.53 147.87,145.53 147.75,145.53 147.58,145.36 147.58,144.74 147.1,144.27 146.84,144.27 146.68,144.11 146.68,143.42 146.84,143.26 147.34,143.26 147.55,143.05 147.55,142.51 147.4,142.36 145.4,142.36 145.33,142.29
+VGA_CORE on BOTTOM: 137.62,150.92 138.82,152.11 138.82,152.36 138.36,152.82 138.16,152.82 137.67,152.34 137.55,152.34 137.37,152.16 137.37,151.09 137.55,150.92
+VGA_CORE on IN1: 136.91,145.76 137.48,146.33 137.48,147.04 137.53,147.09 137.37,147.26 137.37,148.58 137.98,149.19 137.98,150.71 137.83,150.71 136.91,151.63 136.91,153.2 137.62,153.91 153.93,153.91 155.15,155.13 170.72,155.13 175.85,150 175.85,145.56 173.54,143.25 158.88,143.25 154.77,139.13 146.97,139.13 146.95,139.16 145.88,139.16 145.85,139.13 145.8,139.18 137.47,139.18 136.91,139.74
+VGA_CORE on VCC: 138.61,131.74 138.61,140.48 138.47,140.63 138.29,140.63 137.85,141.06 137.85,143.24 138.74,144.13 138.74,148.05 138.41,148.38 138.03,148.38 137.85,148.56 137.85,153.66 138.16,153.96 148.21,153.96 148.52,153.66 148.52,153.6 148.67,153.46 163.1,153.46 163.48,153.84 174.05,153.84 174.05,134.51 169.37,129.83 161.2,129.83 159.29,131.74
+VGA_CORE on IN3: 158.55,153.91 158.59,153.87 159.91,153.87 160.71,153.07 175.11,153.07 176.18,152.01 176.18,143.3 174.15,141.26 146.61,141.26 146.61,141.29 146.23,141.67 140.19,141.67 138.66,143.19 138.66,147.72 138.16,148.22 138.13,148.22 137.65,148.71 137.65,153.66 137.9,153.91
ACN on BOTTOM (solid shape): 179.53,169.38 179.53,169.05 179.36,168.87 178.57,168.87 178.39,169.05 178.39,170.09 178.42,170.12 178.8,170.12
APDIN on BOTTOM (solid shape): 233.43,175.4 233.43,173.5 235.57,171.36 235.57,170.03 235.56,170.02 235.53,169.72 235.72,169.5 235.73,169.49 235.85,169.38 236.91,169.38 237.6,168.7 237.6,166.59 237.47,166.33 237.6,166.07 237.6,161.2 237.39,161 235.21,161 235.19,161.04 234.83,161.31 234.47,161.04 234.45,161 232.77,161 230.03,163.74 230.03,175.25 230.41,175.63 233.2,175.63
B+ on TOP (solid shape): 149.76,58.92 149.76,56.96 149.26,56.45 146.61,56.45 146.32,56.75 146.32,58.99 146.75,59.43 149.26,59.43
B+ on TOP (solid shape): 191.85,170.07 191.85,168.16 191.6,167.91 187.84,167.91 187.59,168.16 187.59,170.14 187.99,170.55 191.37,170.55
B+ on TOP (solid shape): 146.64,29.45 146.64,26.94 146.44,26.74 145.07,26.74 144.79,27.01 144.79,29.43 144.91,29.55 146.54,29.55
B+ on TOP (solid shape): 45.4,50.14 45.4,45.38 44.44,44.43 37.59,44.43 37.08,43.92 37.08,42.46 36.89,42.27 34.6,42.27 33.46,43.41 33.46,48.36 35.93,50.84 44.7,50.84
B+ on TOP (solid shape): 204.32,145.15 204.32,142.89 203.71,142.28 203.71,141.06 203.56,140.91 202.09,140.91 201.73,141.26 201.73,145.25 202.05,145.57 202.48,145.57 202.55,145.63 203.84,145.63
B+ on BOTTOM (solid shape): 196.7,171.36 196.7,168.31 196.53,168.14 188.19,168.14 187.89,168.44 187.89,171.44 188.02,171.57 196.5,171.57
B+ on BOTTOM (solid shape): 42.2,54.07 42.2,49.82 41.61,49.24 38.47,49.24 37.46,48.22 37.46,42.84 36.82,42.2 31.35,42.2 30.31,43.25 30.31,54.95 30.92,55.56 40.7,55.56
B+ on BOTTOM (solid shape): 222.4,181.36 223.01,181.36 223.37,180.99 223.37,178.25 222.89,177.76 220.4,177.76 220.27,177.89 220.27,178.3 220.1,178.47 219.51,178.47 219.44,178.4 219.44,177.87 219.34,177.76 216.11,177.76 215.86,178.02 215.86,181.52 215.87,181.54 215.87,181.66 216.16,181.95 221.8,181.95
B+ on BOTTOM (solid shape): 146.46,29.38 146.46,26.86 146.26,26.66 144.35,26.66 144.18,26.84 144.18,27.32 144.25,27.4 144.71,27.4 144.74,27.42 144.74,27.9 144.66,27.98 144.23,27.98 144.18,28.03 144.18,28.13 144.23,28.18 144.68,28.18 144.74,28.23 144.74,28.74 144.71,28.77 144.23,28.77 144.18,28.82 144.18,29.45 144.25,29.53 146.31,29.53
B+ on BOTTOM (solid shape): 181.46,10.25 181.46,8.57 181.36,8.47 179.48,8.47 179.46,8.45 179.46,8.02 179.38,7.94 178.57,7.94 178.42,7.79 178.42,6.75 178.16,6.49 175.32,6.49 175.19,6.62 175.19,7.58 175.24,7.63 175.67,7.63 175.75,7.71 175.75,8.98 175.72,9.01 175.32,9.01 175.22,9.11 175.22,10.12 175.44,10.35 181.36,10.35
B+ on BOTTOM (solid shape): 149.33,60.21 149.33,57.19 149.08,56.94 147.22,56.94 147.02,57.14 147.02,58.46 146.21,59.27 144.74,59.27 144.71,59.3 144.71,59.81 144.68,59.83 144.2,59.83 144.15,59.78 144.15,59.3 144.13,59.27 143.92,59.27 143.9,59.3 143.9,59.81 143.87,59.83 143.39,59.83 143.34,59.78 143.34,59.3 143.31,59.27 142.86,59.27 142.63,59.5 142.63,61.71 142.93,62.02 147.53,62.02
B+ on BOTTOM (solid shape): outline of 285 points within 144.56,96.53 155.99,103.34
B+ on IN1 (solid shape): outline of 1148 points within 100.82,122.95 148.72,136.34
B+ on TOP: 102.1,132.74 102.71,133.35 102.71,133.58 102.04,134.25 102.04,134.69 102.9,135.55 103.06,135.55 104.48,134.13 104.48,132.68 104.16,132.36 102.86,132.36 102.58,132.07 102.41,132.07 102.1,132.38
B+ on TOP: 151.62,75.27 153.19,73.7 153.19,72.15 152.56,71.52 150.07,71.52 148.37,73.22 147.15,73.22 146.92,73.45 146.92,75.12 147.07,75.27
B+ on BOTTOM: 204.78,144.79 204.78,142.84 204.3,142.36 204.27,142.36 204.27,141.44 203.71,140.88 202.06,140.88 201.53,141.42 201.53,145.43 201.75,145.65 203.93,145.65
B+ on IN2: 156.65,52.87 163.12,46.39 163.12,31.28 181.57,12.84 181.57,7.53 177.53,3.49 173.44,3.49 172.9,4.03 172.9,6.26 171.51,7.66 171.51,10.33 168.65,13.18 162.93,13.18 149.51,26.61 145.9,26.61 145.09,27.42 145.09,29.73 152.2,36.84 152.2,41.82 149.41,44.62 149.41,52.36 149.92,52.87
B+ on VCC: 53.5,16.04 48.66,20.89 46.33,20.89 36.7,30.52 29.27,30.52 29.27,33.97 30.16,34.86 30.16,46.39 38.18,46.39 54.69,29.88 57.1,29.88 61.42,25.57 69.17,25.57 70.56,24.17 84.28,24.17 87.84,20.61 124.5,20.61 124.88,20.99 128.05,20.99 143.44,36.38 143.44,43.12 146.87,46.55 146.87,57.72 151.34,62.19 151.34,96.26 151.31,96.28 151.31,97.32 164.27,110.28 195.23,110.28 199.32,114.37 199.32,115.2 199.07,115.46 199.07,159.68 193.48,165.27 190.05,165.27 188.4,166.92 188.4,178.22 190.92,178.22 196,183.3 219.87,183.3 220.13,183.55 223.73,183.55 224.47,182.81 224.47,178.2 218.65,172.38 215.6,172.38 210.24,167.02 210.24,155.36 209.86,154.98 209.86,149.46 210.24,149.07 210.24,113.45 198.18,101.39 198.18,95.01 165.54,62.38 165.54,61.99 156.14,52.59 156.14,52.59 156.14,26 155.71,25.57 155.71,25.57 149.31,25.57 139.78,16.04
B+ on IN3: 149.73,124.5 159.28,124.5 160.65,123.13 169.38,123.13 171.57,120.94 174.59,120.94 175.29,121.64 179.51,121.64 180.71,122.85 180.71,123.99 181.22,124.5 197.01,124.5 200.7,120.8 200.7,118.02 199.92,117.24 196.88,117.24 196.53,116.88 186.94,116.88 184.71,119.1 170.82,119.1 168.59,116.87 155.93,116.87 155.46,117.34 155.43,117.34 155.19,117.58 149.01,117.58 145.78,120.82 145.78,125.32 146.11,125.65 148.58,125.65
B+_1.35V on TOP (solid shape): 137.5,30.09 137.5,28.92 137.42,28.84 135.64,28.84 135.57,28.92 135.57,29.99 135.72,30.14 137.45,30.14
B+_1.35V on BOTTOM (solid shape): 140.8,29.48 143.9,29.48 144,29.38 144,28.61 144.02,28.59 144.53,28.59 144.56,28.56 144.56,28.39 144.53,28.36 144.02,28.36 144,28.34 144,27.83 144.05,27.78 144.53,27.78 144.56,27.75 144.56,27.6 144.53,27.57 144.02,27.57 144,27.55 144,26.84 143.82,26.66 137.75,26.66 136.61,27.8 132.52,27.8 132.21,28.11 132.21,28.82 132.11,28.92 131.17,28.92 131.15,28.95 131.15,29.05 131.17,29.07 132.14,29.07 132.21,29.15 132.21,29.88 132.47,30.14 140.14,30.14
BATT+ on BOTTOM (solid shape): 207.96,182.54 207.96,179.57 207.82,179.43 207.36,179.43 207.24,179.31 207.24,178.73 207.37,178.6 207.8,178.6 207.96,178.45 207.96,177.97 207.5,177.51 198.68,177.51 198.18,178.02 198.18,182.03 200.75,182.03 200.76,181.98 200.77,181.92 200.79,181.87 200.82,181.82 200.85,181.78 200.89,181.74 200.94,181.7 200.99,181.68 201.04,181.66 201.09,181.65 201.15,181.65 201.21,181.66 201.26,181.67 201.31,181.69 201.36,181.72 201.4,181.76 201.44,181.8 201.47,181.84 201.49,181.89 201.51,181.95 201.52,182 201.52,182.06 201.51,182.11 201.49,182.17 201.47,182.22 201.44,182.26 201.4,182.31 201.36,182.34 201.31,182.37 201.26,182.39 201.21,182.41 201.15,182.41 201.09,182.41 201.04,182.4 200.99,182.38 200.94,182.36 200.89,182.32 200.85,182.29 200.82,182.24 200.79,182.19 200.77,182.14 200.76,182.09 200.75,182.03 198.18,182.03 198.18,182.54 198.68,183.05 207.45,183.05
BQ24780_BATDRV on BOTTOM (solid shape): 215.32,181.95 215.32,180.76 215.14,180.58 211.89,180.58 211.72,180.76 211.72,181.85 212.02,182.16 215.12,182.16
BQ24780_VDD on BOTTOM (solid shape): 182.43,173.37 182.43,172.35 182.38,172.3 181.44,172.3 181.11,171.97 178.97,171.97 178.92,172.02 178.92,172.18 178.97,172.23 180.93,172.23 181.36,172.66 181.36,173.34 181.46,173.45 182.35,173.45
BST_1.00VS on BOTTOM (solid shape): 139.48,49.77 139.48,49.62 139.43,49.57 137.5,49.57 136.86,48.93 135.72,48.93 135.62,49.04 135.62,49.75 135.69,49.82 139.43,49.82
BST_CHG on BOTTOM (solid shape): 182.68,172.1 182.68,171.19 182.58,171.08 181.92,171.08 181.77,171.24 181.77,171.41 181.59,171.59 178.95,171.59 178.9,171.64 178.9,171.77 178.97,171.85 181.59,171.85 181.92,172.18 182.61,172.18
CHG on BOTTOM (solid shape): 215.37,180.1 215.37,168.67 213.44,166.74 206.94,166.74 206.25,167.43 206.25,176.16 207.24,177.15 208.74,177.15 209.02,177.43 209.02,178.5 209.15,178.63 209.63,178.63 209.73,178.73 209.73,179.29 209.63,179.39 209.12,179.39 209.02,179.49 209.02,180.1 209.3,180.38 215.09,180.38
DH_1.35V on TOP (solid shape): 132.54,27.19 132.54,26.15 132.44,26.05 131.86,26.05 131.76,26.15 131.76,27.22 131.88,27.34 132.39,27.34
DH_1.35V on BOTTOM (solid shape): 136.15,36.95 136.15,35.55 136.43,35.27 136.43,34.38 136.33,34.28 136.05,34.28 135.9,34.43 135.9,36.95 135.95,37 136.1,37
DH_1.35V on BOTTOM (solid shape): 133.08,27.09 133.08,26.28 132.92,26.13 132.06,26.13 131.93,26.25 131.93,27.19 131.98,27.24 132.92,27.24
DH_1.35V on IN3: 136.3,35.45 136.4,35.35 136.4,33.44 136.2,33.24 135.26,33.24 135.16,33.34 135.16,35.24 135.36,35.45
DH_1.35V on IN3: 132.54,26.23 132.47,26.15 131.86,26.15 131.78,26.23 131.78,27.98 131.93,28.13 132.47,28.13 132.54,28.06
DH_CHG on BOTTOM (solid shape): 198.43,168.92 198.43,168.16 198.35,168.09 197.36,168.09 197.31,168.14 197.31,169.03 197.41,169.13 198.23,169.13
DH_CHG on BOTTOM (solid shape): 181.54,171.34 181.54,171.06 181.44,170.96 180.57,170.96 180.35,171.19 178.95,171.19 178.9,171.24 178.9,171.39 178.95,171.44 181.44,171.44
DH_CHG on IN3 (solid shape): 198.51,168.98 198.51,168.09 198.41,167.98 197.49,167.98 197.34,168.14 197.34,168.82 197.64,169.13 198.35,169.13
DH_CHG on IN3 (solid shape): 182.56,171.46 182.56,170.85 182.53,170.83 181.69,170.83 181.62,170.91 180.52,170.91 180.35,171.08 180.35,171.31 180.47,171.44 181.67,171.44 181.79,171.57 182.45,171.57
DL_1.35V on TOP (solid shape): 142.7,21.63 142.7,21.2 142.58,21.07 141.43,21.07 141.28,21.22 141.28,21.66 141.41,21.78 142.55,21.78
DL_1.35V on TOP (solid shape): 138.56,36.29 138.56,36.03 138.28,35.75 138,35.75 137.22,36.54 137.22,36.79 137.5,37.07 137.78,37.07
DL_1.35V on BOTTOM (solid shape): 142.58,22.14 142.58,21.27 142.5,21.2 141.53,21.2 141.43,21.3 141.43,22.16 141.51,22.24 142.47,22.24
DL_1.35V on BOTTOM (solid shape): 138.33,36.67 138.33,35.98 138.28,35.93 137.88,35.93 136.66,37.15 136.66,37.28 136.73,37.35 137.65,37.35
DL_1.35V on IN3: 142.63,21.22 142.58,21.17 140.8,21.17 140.7,21.27 140.7,21.91 140.85,22.06 142.47,22.06 142.63,21.91
DL_1.35V on IN3: 137.55,36.92 137.75,36.92 139.2,35.47 139.2,35.17 139.15,35.12 138.5,35.12 138.42,35.19 138.42,35.46 137.34,36.54 137.34,36.72
DL_CHG on BOTTOM (solid shape): 195.51,176.67 195.51,175.76 195.36,175.6 194.54,175.6 194.34,175.81 194.34,176.62 194.47,176.75 195.43,176.75
DL_CHG on BOTTOM (solid shape): 181.16,173.55 181.16,172.76 180.78,172.38 178.95,172.38 178.87,172.46 178.87,172.56 178.95,172.63 180.35,172.63 180.6,172.89 180.6,173.52 180.75,173.67 181.03,173.67
DL_CHG on IN3 (solid shape): 195.56,176.72 195.56,176.29 195.43,176.16 193.81,176.16 193.71,176.06 193.05,176.06 192.92,176.19 192.92,176.62 193.15,176.85 195.43,176.85
DL_CHG on IN3 (solid shape): 182.35,173.57 182.35,173.01 182.28,172.94 181.26,172.94 181.13,172.81 181.13,172.63 181.03,172.53 180.7,172.53 180.59,172.65 180.59,173.53 180.83,173.78 182.15,173.78
EC_SMCA on BOTTOM (solid shape): 199.57,188.63 199.57,186.98 199.45,186.86 197.8,186.86 197.67,186.98 197.67,188.63 197.8,188.76 199.45,188.76
EC_SMDA on BOTTOM (solid shape): 201.61,188.63 201.61,186.98 201.48,186.86 199.83,186.86 199.7,186.98 199.7,188.64 199.83,188.76 201.48,188.76
FB_1.35V on BOTTOM (solid shape): 134.96,40.04 134.96,39.16 134.88,39.08 134.73,39.08 133.94,39.87 133.94,40.17 134.07,40.3 134.7,40.3
HG_1PH on BOTTOM (solid shape): 142.09,76.62 142.09,75.73 141.87,75.5 141.2,75.5 141.05,75.66 141.05,76.67 141.15,76.77 141.94,76.77
HG_1PH on BOTTOM (solid shape): 140.8,83.94 140.8,83 140.67,82.87 139.81,82.87 139.71,82.97 139.71,83.91 139.81,84.01 140.72,84.01
HG_1PH on IN1 (solid shape): 142.09,76.65 142.09,75.68 141.99,75.58 140.72,75.58 140.54,75.76 140.54,76.54 140.72,76.72 142.02,76.72
HG_1PH on IN1 (solid shape): 140.16,83.94 140.16,82.87 140.01,82.72 138.94,82.72 138.79,82.87 138.79,83.86 138.97,84.04 140.06,84.04
HG_A1 on BOTTOM (solid shape): 137.93,103.24 137.93,102.25 137.78,102.1 136.58,102.1 136.45,102.22 136.45,103.19 136.68,103.42 137.75,103.42
HG_A1 on BOTTOM (solid shape): 128.99,101.16 128.99,100.32 128.91,100.24 127.9,100.24 127.79,100.34 127.79,101.16 127.9,101.26 128.89,101.26
HG_A1 on IN3: 127.82,100.78 129.9,100.78 130.03,100.65 130.03,100.14 129.9,100.01 127.82,100.01 127.69,100.14 127.69,100.65
HG_A1 on IN3: 137.29,103.29 137.78,103.29 137.9,103.16 137.9,101.39 137.65,101.13 137.22,101.13 137.12,101.23 137.12,103.11
HG_B1 on TOP (solid shape): 40.34,64.23 40.34,63.36 40.27,63.29 38.87,63.29 38.69,63.46 38.69,64.17 38.84,64.33 40.24,64.33
HG_B1 on BOTTOM (solid shape): 37.34,74.11 37.34,73.24 37.27,73.17 36.38,73.17 36.3,73.24 36.3,74.11 36.48,74.28 37.17,74.28
HG_B1 on BOTTOM (solid shape): 40.52,64.84 40.52,63.64 40.29,63.41 39.17,63.41 39,63.59 39,64.99 39.1,65.09 40.27,65.09
HG_B1 on IN3: 36.63,74.39 36.81,74.21 36.81,72.4 36.61,72.2 35.77,72.2 35.67,72.3 35.67,74.28 35.77,74.39
HG_B1 on IN3: 40.06,63.36 39.17,63.36 38.97,63.57 38.97,64.61 39.33,64.96 40.14,64.96 40.34,64.76 40.34,63.64
HGNDA on TOP (solid shape): 218.09,18.82 218.09,18.15 218.01,18.07 216.24,18.07 216.21,18.1 216.21,18.73 216.29,18.81 217.35,18.81 217.44,18.9 218.01,18.9
HGNDA on TOP: 221.37,8.29 221.65,8.57 222.87,8.57 222.94,8.5 222.94,7.33 222.64,7.02 219.79,7.02 218.65,8.17 218.65,8.98 218.76,9.09 219.22,9.09 220.02,8.29 ; 2 cut-outs
HGNDA on TOP: 208.69,16.78 209.18,16.78 209.3,16.65 209.3,15.51 209.15,15.36 208.59,15.36 208.46,15.48 208.46,16.55
HGNDA on IN3: 207.78,15.84 207.78,18.18 207.98,18.38 211.89,18.38 212.48,18.96 218.24,18.96 218.52,18.68 218.52,16.25 219.59,15.18 219.59,10.63 221.11,9.11 222.69,9.11 222.89,8.9 222.89,7.18 222.69,6.97 219.69,6.97 215.98,10.68 215.98,12.71 215.82,12.88 210.79,12.88 210.04,13.63 210.04,13.96 209.33,14.67 207.98,14.67 207.73,14.92 207.73,15.79
HGNDB on TOP: 216.29,17.95 218.04,17.95 218.12,17.87 218.12,17.18 217.99,17.06 216.29,17.06 216.24,17.11 216.24,17.9
HGNDB on TOP: 220.4,5.37 220.25,5.53 220.25,5.81 221.21,5.81 221.21,6.01 220.25,6.01 220.25,6.29 221.14,6.29 221.14,6.49 220.25,6.49 220.25,6.75 220.3,6.8 222.76,6.8 222.92,6.64 222.92,5.78 222.51,5.37
HGNDB on IN1: 214.48,16.58 215.96,18.05 218.14,18.05 218.5,17.69 218.5,16.19 219.54,15.15 219.54,10.68 220.38,9.84 220.53,9.84 221.42,8.96 221.42,7.99 221.7,7.71 222.81,7.71 222.94,7.58 222.94,5.58 222.61,5.25 219.64,5.25 219.56,5.32 219.56,7.08 215.96,10.68 215.96,12.74 215.8,12.89 212.71,12.89 212.55,12.74 210.78,12.74 210.06,13.45 210.06,13.96 209.38,14.64 208.59,14.64 208.31,14.92 208.31,16.22 208.67,16.58
LANGND on BOTTOM (solid shape): 22.41,127.29 22.41,125.39 22.28,125.26 21.14,125.26 20.76,124.88 20.76,123.23 20.88,123.1 21.52,123.1 21.65,122.98 21.65,121.2 20.63,120.18 20.63,116.63 20.25,116.24 20.25,114.09 20.63,113.7 21.77,113.7 22.15,113.32 22.15,113.07 22.4,112.83 22.4,109.27 22.13,109.01 21.27,109.01 20.88,108.62 20.51,108.62 19.49,109.65 19.49,111.93 17.84,113.58 17.84,121.45 19.23,122.85 19.23,126.91 19.87,127.55 22.15,127.55
LANGND on BOTTOM (solid shape): outline of 621 points within 3.41,107.61 30.38,131.99
LANGND on TOP: 18.62,128.39 16.29,126.05 15.03,126.05 14.93,126.13 14.82,126.19 14.81,126.2 13.82,125.9 14.01,124.88 14.02,124.87 14.68,124.75 15.19,125.18 17.38,125.18 17.84,124.73 17.84,124.45 18.34,123.94 20.15,123.94 20.55,123.53 20.55,113.2 21,112.75 21,108.87 20.66,108.52 20.66,108.47 17.48,108.47 16.26,109.69 13.85,109.69 12.73,108.57 3.99,108.57 3.41,109.16 3.41,109.69 11.91,109.69 13.49,109.49 13.29,111.07 13.29,115.97 13.05,116.55 12.48,116.78 12.29,116.78 12.29,120.22 12.48,120.22 13.05,120.45 13.29,121.02 13.29,125.93 13.59,126.2 13.76,126.56 13.16,127.73 11.91,127.31 3.41,127.31 3.41,131.99 8.84,131.99 8.84,131 10.5,129.34 12.16,131 12.16,131.99 16.79,131.99 19.49,129.29 19.81,129.07 20.18,128.99 24.32,128.99 24.52,128.99 24.52,128.56 24.34,128.39
LANGND on GND1, VCC, GND2: 3.41,108.4 3.41,109.69 11.91,109.69 13.49,109.49 13.29,111.07 13.29,115.98 13.05,116.55 12.48,116.78 12.29,116.78 12.29,120.22 12.48,120.22 13.05,120.45 13.29,121.02 13.29,125.93 13.49,127.51 11.91,127.31 3.41,127.31 3.41,131.99 8.84,131.99 8.84,131 10.5,129.34 12.16,131 12.16,131.99 16.79,131.99 19.49,129.29 19.82,129.07 20.21,128.99 25.09,128.99 25.27,128.95 25.43,128.85 25.85,128.43 26.34,128.11 26.91,127.99 30.59,127.99 30.59,109.25 30.06,108.73 5.45,108.73 5.41,108.76 4.36,108.76 3.99,108.4
LANGND on IN2: 16.79,131.99 19.49,129.29 19.82,129.07 20.21,128.99 25.09,128.99 25.27,128.95 25.43,128.85 25.85,128.43 25.91,128.37 26.38,128.09 26.91,127.99 30.59,127.99 30.59,108.57 29.93,107.91 17.56,107.91 15.73,109.74 14.03,109.74 12.88,108.6 5.04,108.6 4.16,109.47 4.13,109.61 4.25,109.69 11.91,109.69 13.49,109.49 13.29,111.07 13.29,112.44 13.78,112.93 16.16,112.93 17.59,114.35 20.85,114.35 21.72,113.48 22.11,113.48 22.31,113.68 22.31,115.19 22.85,115.73 26.51,115.73 27.54,116.77 27.54,123.63 26.99,124.18 25.07,124.18 22.02,121.13 17.93,121.13 14.98,124.08 14.07,124.08 13.67,123.68 13.67,118.89 13.78,118.78 13.78,117.62 12.98,116.82 12.98,116.8 12.87,116.68 12.68,116.76 12.48,116.78 12.29,116.78 12.29,120.22 12.48,120.22 13.05,120.45 13.29,121.02 13.29,122.44 13.29,125.93 13.49,127.51 11.91,127.31 3.41,127.31 3.41,131.99 8.84,131.99 8.84,131 10.5,129.34 12.16,131 12.16,131.99
LG_1PH on BOTTOM (solid shape): 143.11,83.86 143.11,82.84 143.03,82.77 142.2,82.77 141.99,82.97 141.99,83.91 142.04,83.96 143.01,83.96
LG_1PH on BOTTOM (solid shape): 143.24,77.89 143.24,77.05 143.14,76.95 141.94,76.95 141.71,77.18 141.71,77.89 141.81,77.99 143.14,77.99
LG_1PH on IN1 (solid shape): 143.08,83.78 143.08,82.01 142.96,81.88 142.53,81.88 142.35,82.06 142.35,83.76 142.47,83.89 142.98,83.89
LG_1PH on IN1 (solid shape): 143.08,78.93 143.08,77.51 143.24,77.36 143.24,77.08 143.14,76.98 142.14,76.98 142.09,77.03 142.09,77.43 142.27,77.61 142.27,78.88 142.4,79.01 143.01,79.01
LG_A1 on BOTTOM (solid shape): 145.45,108.45 145.45,107.33 145.34,107.23 144.13,107.23 143.97,107.38 143.97,108.4 144.18,108.6 145.29,108.6
LG_A1 on BOTTOM (solid shape): 145.57,103.01 145.57,101.94 145.37,101.74 144.18,101.74 143.95,101.97 143.95,102.96 144.13,103.14 145.45,103.14
LG_A1 on BOTTOM (solid shape): 129.98,103.7 129.98,102.55 129.85,102.43 128.5,102.43 128.45,102.48 128,102.48 127.9,102.58 127.9,102.96 127.97,103.04 128.71,103.04 129.06,103.39 129.06,103.72 129.14,103.8 129.88,103.8
LG_A1 on IN3: 129.93,102.78 129.93,104.51 129.75,104.69 129.28,104.69 128.99,104.4 128.99,103.27 128.76,103.04 128.76,102.78 128.9,102.64 129.79,102.64
LG_A1 on IN3: 143.95,107.89 145.22,107.89 145.42,107.69 145.42,101.82 145.22,101.61 144.05,101.61 143.74,101.92 143.74,107.69
LG_B1 on TOP (solid shape): 41.2,60.44 41.2,59.3 41.05,59.15 40.54,59.15 40.42,59.27 40.42,60.42 40.57,60.57 41.08,60.57
LG_B1 on TOP (solid shape): 47.02,60.42 47.02,59.17 46.87,59.02 46.31,59.02 46.16,59.17 46.16,60.39 46.41,60.64 46.79,60.64
LG_B1 on BOTTOM (solid shape): 39.15,74.08 39.15,71.95 39.07,71.87 38.61,71.87 38.54,71.95 38.54,74.08 38.61,74.16 39.07,74.16
LG_B1 on BOTTOM (solid shape): 42.04,60.31 42.04,59.32 41.89,59.17 40.6,59.17 40.47,59.3 40.47,60.31 40.65,60.49 41.87,60.49
LG_B1 on BOTTOM (solid shape): 47.71,60.29 47.71,59.2 47.5,58.99 46.49,58.99 46.34,59.15 46.34,60.26 46.54,60.47 47.53,60.47
LG_B1 on IN3: 40.54,60.57 46.82,60.57 46.95,60.44 46.95,59.07 46.89,59.02 40.6,59.02 40.39,59.22 40.39,60.42
LG_B1 on IN3: 38.66,73.06 40.34,73.06 40.47,72.94 40.47,72.05 39.91,71.49 39,71.49 38.59,71.9 38.59,72.99
LX_1.35V on TOP (solid shape): 139.22,26.3 139.22,25.52 139.1,25.39 138.46,25.39 137.83,24.75 137.12,24.75 137.04,24.83 137.04,26.3 137.17,26.43 139.1,26.43
LX_1.35V on BOTTOM (solid shape): 137.5,35.96 137.5,33.06 137.39,32.96 136.43,32.96 136.3,33.09 136.3,33.95 136.58,34.23 136.58,35.83 136.3,36.11 136.3,36.92 136.35,36.97 136.48,36.97
LX_1.35V on BOTTOM (solid shape): 137.65,26 138.64,26 139.88,24.75 140.11,24.75 140.77,24.09 140.77,21.96 140.24,21.43 131.53,21.43 131.07,21.88 131.07,24.35 131.45,24.73 132.06,24.73 132.16,24.83 132.16,25.67 132.39,25.9 133.13,25.9 133.38,26.15 133.38,27.19 133.46,27.27 136.38,27.27
LX_1.35V on IN3: 137.5,24.83 137.55,24.88 137.55,26.58 137.45,26.68 136.84,26.68 136.73,26.58 136.73,26.33 137.04,26.02 137.04,24.88 137.09,24.83
LX_1.35V on IN3: 136.91,35.73 137.42,35.73 137.5,35.65 137.5,33.97 137.34,33.82 136.81,33.82 136.71,33.92 136.71,34.25 136.81,34.36 136.81,35.63
LX_CHG on TOP (solid shape): 181.79,170.12 181.79,169.89 181.62,169.71 181.08,169.71 180.57,170.22 180.57,170.58 180.68,170.68 181.24,170.68
LX_CHG on BOTTOM (solid shape): 180.5,170.68 181.64,170.68 181.79,170.83 182.48,170.83 182.58,170.73 182.58,169.81 182.53,169.76 181.03,169.76 180.02,170.78 178.97,170.78 178.9,170.85 178.9,170.98 178.95,171.03 180.14,171.03
LX_CHG on BOTTOM (solid shape): 205.11,176.44 205.11,167.32 204.68,166.89 200.13,166.89 198.94,168.09 198.94,169.13 198.71,169.36 197.52,169.36 197.29,169.58 197.29,172.81 196.93,173.17 196.5,173.17 195.99,173.67 195.99,176.04 196.42,176.47 199.22,176.47 199.88,177.13 204.43,177.13
LX_CHG on IN3 (solid shape): 182.45,169.46 182.45,169.28 182.14,168.96 182.12,168.98 181.87,168.98 180.52,170.32 180.52,170.47 180.7,170.65 181.26,170.65
LX_CHG on IN3 (solid shape): 201.02,167.55 201.02,167.17 200.92,167.07 199.75,167.07 199.52,166.84 199.07,166.84 198.96,166.94 198.96,167.58 199.07,167.68 200.89,167.68
MCT1 on BOTTOM (solid shape): 26.3,126.55 26.3,124.65 25.74,124.09 25.29,124.09 25.04,123.84 25.04,122.51 25.32,122.23 25.5,122.23 25.61,122.22 25.71,122.23 26.15,122.23 26.46,121.91 26.5,121.91 26.51,121.91 27.09,121.91 27.31,121.68 28.66,121.68 28.76,121.58 28.76,120.89 28.61,120.74 26.12,120.74 24.59,122.26 24.59,123.18 24.5,123.27 23.95,123.27 23.87,123.34 23.87,127.13 23.98,127.24 25.61,127.24
MCT2 on BOTTOM (solid shape): 24.39,123.1 24.39,121.58 25.58,120.39 28.68,120.39 28.89,120.18 28.89,119.72 28.66,119.5 27.01,119.5 26.83,119.32 23.48,119.32 23.32,119.47 23.32,120.69 22.94,121.07 22.94,122.98 23.09,123.13 24.36,123.13
MCT3 on BOTTOM (solid shape): 25.6,114.59 26.27,114.59 26.57,114.29 26.98,114.29 27.23,114.04 28.68,114.04 28.84,113.88 28.84,113.35 28.61,113.12 25.89,113.12 24.82,112.05 24.82,111.44 24.72,111.34 23.6,111.34 23.55,111.39 23.55,114.87 23.63,114.96 25.23,114.96
MCT4 on BOTTOM (solid shape): 28.84,112.71 28.84,112 28.66,111.83 27.13,111.83 26.92,111.61 26.5,111.61 25.66,110.77 25.44,110.77 24.93,110.44 25.01,109.84 25.06,109.06 25.84,109.08 25.93,109.17 26,109.18 26.04,109.12 26.04,107.46 25.76,107.18 23.86,107.18 23.65,107.38 23.65,111.04 23.76,111.14 24.77,111.14 25.03,111.39 25.03,111.95 25.91,112.84 28.71,112.84
MPLL_PVDD on TOP: 134.58,157.62 134.32,157.87 134.32,158.56 134.8,159.04 134.96,159.04 135.41,159.5 136.25,159.5 136.44,159.32 137.45,159.32 138.16,158.61 138.16,155.95 138.36,155.74 139.35,155.74 139.6,155.49 139.6,155.03 139.45,154.88 136.56,154.88 135.62,155.82 135.62,156.86 134.85,157.62
NTC_V_1 on BOTTOM (solid shape): 212.63,132.5 212.63,131.05 212.32,130.75 209.05,130.75 208.92,130.88 208.92,132.35 209.18,132.6 212.53,132.6
P2 on BOTTOM (solid shape): 224.82,161.28 225.81,161.28 225.99,161.1 225.99,158.05 225.81,157.88 224.42,157.88 224.21,158.08 224.21,159.15 223.98,159.37 222.89,159.37 222.56,159.7 221.54,159.7 221.37,159.88 221.37,161.76 221.54,161.94 224.16,161.94
P3 on BOTTOM (solid shape): 224.21,167.58 224.21,163.49 223.86,163.13 221.42,163.13 220.83,162.55 220.83,156.76 220.63,156.55 219.61,156.55 219.47,156.69 218.38,156.69 218.07,157.01 218.07,164.35 217.46,164.96 217.46,167.48 217.86,167.88 223.91,167.88
PG_VDD on BOTTOM (solid shape): 211.46,150.69 211.46,150.18 210.98,149.7 210.57,149.7 210.5,149.77 210.5,150.03 211.21,150.74 211.41,150.74
PS_2 on TOP: 151.39,140.25 151.39,138.85 150.5,137.96 148.9,137.96 148.39,138.47 148.39,138.9 148.77,139.28 149.69,139.28 149.99,139.59 149.99,140.53 150.3,140.83 150.3,141.95 150.6,142.25 151.06,142.25 151.24,142.08 151.24,140.37 151.36,140.25
RJ45_GND on BOTTOM (solid shape): 23.17,108.75 23.17,107.23 23.04,107.1 21.14,107.1 20.88,107.35 20.88,108.37 21.39,108.88 22.18,108.88 22.18,108.88 23.04,108.88
RJ45_GND on BOTTOM (solid shape): 23.17,124.88 23.17,123.48 22.92,123.23 21.57,123.23 21.57,123.23 21.27,123.23 21.14,123.36 21.14,124.88 21.33,125.07 22.47,125.07 22.47,125.13 22.92,125.13
RJ45_GND on BOTTOM (solid shape): 23.3,113.7 23.17,113.58 22.08,113.58 21.83,113.83 20.76,113.83 20.76,114.47 20.87,114.58 20.9,114.58 21.13,114.59 21.33,114.69 22.01,114.69 22.27,114.96 23.3,114.96
RJ45_GND on BOTTOM (solid shape): 22.92,120.58 22.92,119.29 23.17,119.04 23.93,119.04 24.19,118.78 24.19,118.52 24.18,118.51 24.15,118.33 24.18,118.15 24.19,118.14 24.19,117.75 24.18,117.67 24.19,117.58 24.19,116.7 24.01,116.52 22,116.52 21.52,117.01 21.52,120.54 21.84,120.85 22.64,120.85
RJ45_GND on TOP: 21.37,125.01 23.45,125.01 24.35,124.11 24.35,108.92 22.66,107.23 21.24,107.23 20.99,107.48 20.99,108.42 21.29,108.73 21.29,113.02 20.83,113.48 20.83,124.47
SPK_L1- on TOP: 201.07,22.98 204.35,22.98 205.19,22.14 205.19,22.11 204.96,21.88 201.15,21.88 200.97,22.06 200.97,22.87
SPK_L1-_CON on BOTTOM (solid shape): 230.87,188 230.96,187.91 231.07,187.86 231.12,187.85 231.12,182.26 231.02,182.16 230.23,182.16 230.13,182.26 230.13,187.9 230.23,188
SPK_L1-_CON on TOP: 199.07,23.92 200.46,23.92 200.59,23.79 200.59,22.01 200.46,21.88 199.07,21.88 198.81,22.14 198.81,23.66
SPK_L1-_CON on IN1: 199.32,21.88 199.07,22.14 199.07,23.92 199.19,24.04 200.39,24.04 200.54,23.89 200.54,22.11 200.31,21.88
SPK_L1-_CON on IN1: 230.13,181.98 230.13,184.09 230.31,184.27 230.99,184.27 231.12,184.14 231.12,181.98 230.97,181.83 230.28,181.83
SPK_L2+ on TOP: 201.07,25.24 205.77,25.24 206.38,24.63 206.38,23.15 206.23,23 205.72,23 204.6,24.12 201.07,24.12 200.97,24.22 200.97,25.14
SPK_L2+_CON on BOTTOM (solid shape): 232.39,187.92 232.39,183.05 232.24,182.89 231.53,182.89 231.4,183.02 231.4,187.9 231.5,188 232.31,188
SPK_L2+_CON on TOP: 198.94,26.46 200.46,26.46 200.59,26.33 200.59,24.3 200.46,24.17 199.07,24.17 198.81,24.42 198.81,26.33
SPK_L2+_CON on IN1: 231.4,183.02 231.4,186.04 231.5,186.15 232.26,186.15 232.39,186.02 232.39,183.07 232.21,182.89 231.53,182.89
SPK_L2+_CON on IN1: 199.32,24.42 199.19,24.55 199.19,26.61 199.4,26.81 200.39,26.81 200.49,26.71 200.49,24.6 200.31,24.42
SPK_R1- on TOP: 201.1,21.71 202.6,21.71 202.75,21.86 204.76,21.86 205.14,21.48 205.14,21.1 205.01,20.97 203.69,20.97 203.36,20.64 201.05,20.64 201,20.69 201,21.6
SPK_R1-_CON on BOTTOM (solid shape): 233.64,187.92 233.64,184.77 233.43,184.57 232.8,184.57 232.64,184.72 232.64,187.9 232.75,188 233.56,188
SPK_R1-_CON on TOP: 199.07,21.76 200.46,21.76 200.59,21.63 200.59,19.72 200.34,19.47 199.07,19.47 198.94,19.6 198.94,21.63
SPK_R1-_CON on IN1: 233.64,181.42 233.56,181.35 232.92,181.35 232.64,181.62 232.64,186.04 232.75,186.15 233.51,186.15 233.64,186.02
SPK_R1-_CON on IN1: 199.32,19.6 199.07,19.85 199.07,21.63 199.19,21.76 200.46,21.76 200.54,21.68 200.54,19.88 200.26,19.6
SPK_R2+ on TOP: 201.05,19.45 202.14,19.45 202.42,19.72 204.3,19.72 204.48,19.55 204.48,19.27 203.59,18.38 202.04,18.38 201.91,18.25 201.07,18.25 200.92,18.4 200.92,19.32
SPK_R2+_CON on BOTTOM (solid shape): 234.88,187.92 234.88,184.77 234.68,184.57 234.04,184.57 233.89,184.72 233.89,187.9 233.99,188 234.8,188
SPK_R2+_CON on TOP: 199.07,19.34 200.46,19.34 200.59,19.22 200.59,17.44 200.34,17.18 199.07,17.18 198.94,17.31 198.94,19.22
SPK_R2+_CON on IN1: 234.88,181.42 234.8,181.35 234.17,181.35 233.89,181.62 233.89,186.04 233.99,186.15 234.75,186.15 234.88,186.02
SPK_R2+_CON on IN1: 199.32,17.18 199.07,17.44 199.07,19.22 199.19,19.34 200.39,19.34 200.46,19.27 200.46,17.39 200.26,17.18
SPLL_VDDC on TOP: 164.17,164 164.17,165.17 164.78,165.77 168.33,165.77 168.84,165.27 168.84,164.12 168.59,163.87 164.29,163.87
SW_1.00VS on BOTTOM (solid shape): 138.39,54.27 138.39,52.54 139.5,51.42 139.5,50.1 139.35,49.95 135.39,49.95 134.7,49.27 133.94,49.27 133.76,49.44 133.76,50.1 133.55,50.32 132,50.32 131.18,51.13 131.18,54.4 131.46,54.68 137.98,54.68
SW_1PH on TOP (solid shape): 141.18,80.63 141.18,79.26 141.1,79.19 139.99,79.19 139.86,79.31 139.86,80.66 139.96,80.76 141.05,80.76
SW_1PH on BOTTOM (solid shape): 141.31,83.91 141.31,81.35 141.2,81.24 140.14,81.24 139.91,81.47 139.91,82.26 140.01,82.36 140.44,82.36 140.98,82.89 140.98,83.89 141.05,83.96 141.26,83.96
SW_1PH on BOTTOM (solid shape): 134.07,80.33 134.07,78.45 134.32,78.2 134.96,78.2 135.24,78.48 135.24,80.1 135.79,80.66 141,80.66 141.1,80.56 141.1,77.38 140.77,77.05 140.77,75.6 140.65,75.48 139.01,75.48 138.66,75.83 131.45,75.83 131.04,76.23 131.04,80.25 131.45,80.66 133.74,80.66
SW_1PH on IN1 (solid shape): 141.28,82.29 141.28,80.46 140.93,80.1 140.04,80.1 139.93,80.2 139.93,80.48 140.7,81.24 140.7,82.39 140.77,82.46 141.1,82.46
SW_A1 on BOTTOM (solid shape): 131.48,102 131.48,100.55 131.27,100.34 129.65,100.34 129.37,100.62 129.37,101.13 129.04,101.46 127.95,101.46 127.87,101.54 127.87,101.72 127.95,101.79 130.13,101.79 130.54,102.2 131.27,102.2
SW_A1 on BOTTOM (solid shape): 142.3,113.83 142.3,113.04 142.53,112.82 142.98,112.82 143.21,112.59 143.21,102.48 142.8,102.07 138.69,102.07 138.36,102.4 138.36,103.37 137.99,103.74 136.04,103.74 135.72,103.42 135.72,102.43 135.52,102.22 132.04,102.22 131.83,102.43 131.83,103.95 133.28,105.4 133.28,107.23 133.51,107.46 135.44,107.46 135.54,107.56 135.54,108.22 135.41,108.35 133.58,108.35 133.28,108.65 133.28,111.47 133.31,111.47 133.61,111.77 137.5,111.77 139.83,114.11 142.02,114.11
SW_A1 on IN3: 132.57,103.27 132.57,102.43 131.4,101.26 129.55,101.26 129.39,101.41 129.39,101.72 129.65,101.97 130.49,101.97 132.04,103.52 132.31,103.52
SW_B1 on TOP (solid shape): 37.95,72.99 37.95,71.82 37.88,71.74 37.39,71.74 37.24,71.9 37.24,72.99 37.42,73.17 37.78,73.17
SW_B1 on TOP (solid shape): 41.23,68.75 41.23,67.53 41.08,67.38 40.54,67.38 40.39,67.53 40.39,68.8 40.54,68.95 41.03,68.95
SW_B1 on TOP (solid shape): 49.21,63.31 49.21,62.35 49.03,62.17 46.77,62.17 46.56,62.37 46.56,63.41 46.67,63.51 49,63.51
SW_B1 on BOTTOM (solid shape): 37.9,74.08 37.9,71.95 37.8,71.85 36.43,71.85 36.38,71.9 36.38,72.86 36.53,73.01 37.5,73.01 37.55,73.06 37.55,74.11 37.62,74.18 37.8,74.18
SW_B1 on BOTTOM (solid shape): 45.62,71.24 45.62,69.64 45.83,69.43 46.56,69.43 46.69,69.56 46.69,71.29 47,71.59 51.11,71.59 51.9,70.8 51.9,61.81 51.34,61.25 41.46,61.25 40.95,61.76 40.95,65.14 40.44,65.65 39.2,65.65 39.1,65.75 39.1,68.8 41.54,71.24 41.56,71.24 41.92,71.59 45.27,71.59
SW_B1 on IN3: 37.34,72.91 37.47,73.04 38,73.04 38.06,72.99 38.06,71.01 37.93,70.88 37.42,70.88 37.34,70.96
SW_B1 on IN3: 39.88,67.43 39.68,67.63 39.68,68.8 39.86,68.98 41.28,68.98 41.46,68.8 41.46,67.58 41.31,67.43
VBUCK_1V5 on BOTTOM (solid shape): 31.11,80.49 34.66,80.49 35.11,80.05 35.11,78.4 34.85,78.14 29.84,78.14 29.33,78.65 29.33,80.11 30.28,81.07 30.54,81.07
VBUCK_1V5 on TOP: 27.49,85.1 27.36,85.23 27.36,86.32 27.41,86.37 27.74,86.37 27.74,85.36 27.92,85.36 27.92,86.37 28.2,86.37 28.28,86.3 28.28,82.53 28.76,82.04 28.76,81.27 28.96,81.07 29.42,81.07 29.44,81.09 30.54,81.09 30.79,80.84 30.79,78.97 30.47,78.65 28.44,78.65 27.93,79.16 27.93,80.24 27.49,80.68
VGA_LGATE1 on TOP (solid shape): 208.51,152.26 208.51,152.01 207.91,151.4 207.65,151.4 207.47,151.58 207.47,151.78 208.13,152.44 208.34,152.44
VGA_LGATE1 on TOP (solid shape): 189.36,143.68 189.36,143.09 189.11,142.84 189.11,141.59 188.86,141.34 188.7,141.34 188.45,141.59 188.45,142.84 188.09,143.19 188.09,143.65 188.25,143.8 189.24,143.8
VGA_LGATE1 on BOTTOM (solid shape): 189.36,143.65 189.36,143.14 189.08,142.86 189.08,141.44 189.01,141.37 188.58,141.37 188.45,141.49 188.45,142.89 188.17,143.17 188.17,143.58 188.4,143.8 189.21,143.8
VGA_LGATE1 on BOTTOM (solid shape): 211,152.34 211,152.19 210.93,152.11 208.69,152.11 207.98,151.4 207.68,151.4 207.66,151.39 207.55,151.5 207.55,151.78 208.16,152.39 210.95,152.39
VGA_LGATE1 on IN3: 206.56,151.27 206.56,152.03 206.69,152.16 207.91,152.16 208.16,152.41 208.41,152.41 208.57,152.26 208.57,152.08 207.63,151.14 206.69,151.14
VGA_LGATE1 on IN3: 188.35,142.64 189.21,142.64 189.46,142.89 189.46,144.9 189.26,145.1 188.42,145.1 188.22,144.9 188.22,142.76
VGA_LGATE2 on TOP (solid shape): 189.24,153.76 189.24,151.75 189.11,151.63 188.17,151.63 188.07,151.73 188.07,153.86 188.3,154.09 188.91,154.09
VGA_LGATE2 on BOTTOM (solid shape): 209.07,153.58 211,153.58 211.05,153.53 211.05,153.38 210.98,153.3 208.62,153.3 207.82,154.1 207.82,154.2 208.06,154.43 208.22,154.43
VGA_LGATE2 on BOTTOM (solid shape): 188.91,153.89 188.91,152.41 189.24,152.08 189.24,151.73 189.08,151.58 188.17,151.58 188.04,151.7 188.04,152.08 188.35,152.39 188.35,153.94 188.4,153.99 188.8,153.99
VGA_LGATE2 on IN3: 188.19,151.63 189.13,151.63 189.26,151.75 189.26,153.74 189.11,153.89 188.25,153.89 188.07,153.71 188.07,151.75
VGA_LGATE2 on IN3: 207.88,154.45 208.24,154.45 208.84,153.84 208.84,153.58 208.69,153.43 208.49,153.43 207.96,153.96 206.66,153.96 206.51,154.12 206.51,154.57 206.84,154.9 207.42,154.9
VGA_PHASE1 on TOP (solid shape): 209.18,151.4 209.18,151.17 208.54,150.53 208.34,150.53 208.13,150.74 208.13,150.92 208.79,151.58 209,151.58
VGA_PHASE1 on TOP (solid shape): 194.24,139.61 194.24,134.79 193.99,134.53 183.88,134.53 183.04,135.37 183.04,140.02 183.44,140.43 193.43,140.43
VGA_PHASE1 on BOTTOM (solid shape): 211.03,151.96 211.03,151.78 210.98,151.73 209.68,151.73 208.02,150.06 206.27,150.06 206.18,150.15 206.18,150.79 206.28,150.89 208.16,150.89 209.25,151.98 211,151.98
VGA_PHASE1 on BOTTOM (solid shape): 183.75,140.5 192.54,140.5 194.19,138.85 195.15,138.85 195.41,138.6 195.41,135.09 195.08,134.76 180.09,134.76 179.76,135.09 179.76,137.3 180.19,137.73 181.06,137.73 181.24,137.91 181.24,138.52 181.08,138.67 180.24,138.67 179.76,139.16 179.76,141.26 180.14,141.64 182.61,141.64
VGA_PHASE1 on IN3: 193.58,138.67 193.91,138.67 194.06,138.83 194.06,139 193.6,139.46 193.6,141.64 193.5,141.75 193.07,141.75 192.92,141.59 192.92,139.33
VGA_PHASE1 on IN3: 207.88,150.64 208.82,151.58 209,151.58 209.18,151.4 209.18,151.2 207.83,149.85 206.84,149.85 206.74,149.95 206.74,150.53 206.84,150.64
VGA_PHASE2 on TOP (solid shape): 208.79,154.85 208.79,154.6 208.67,154.47 208.46,154.47 207.78,155.16 207.78,155.34 207.93,155.49 208.16,155.49
VGA_PHASE2 on TOP (solid shape): 193.73,156.83 193.73,155.79 193.53,155.59 192.18,155.59 191.98,155.79 191.98,156.68 192.36,157.06 193.5,157.06
VGA_PHASE2 on BOTTOM (solid shape): 209.61,153.99 210.98,153.99 211.03,153.94 211.03,153.76 210.98,153.71 209.2,153.71 207.98,154.93 206.39,154.93 206.27,155.06 206.27,155.63 206.41,155.77 207.83,155.77
VGA_PHASE2 on BOTTOM (solid shape): 192.59,160.45 192.59,159.74 192.96,159.37 194.82,159.37 195,159.2 195,155.97 193.96,154.93 183.61,154.93 182.31,153.63 179.76,153.63 179.28,154.12 179.28,155.77 180.04,156.53 180.83,156.53 181.01,156.71 181.01,157.55 180.85,157.7 179.94,157.7 179.28,158.36 179.28,160.57 179.48,160.77 192.27,160.77
VGA_PHASE2 on TOP: 188.96,160.87 188.98,160.85 192.23,160.85 192.59,160.49 192.59,158.66 192.11,158.18 190.43,158.18 189.46,157.22 189.46,155.34 188.96,154.83 183.32,154.83 182.15,156 182.15,160.49 182.53,160.87
VGA_PHASE2 on IN3: 208.77,154.85 208.77,154.65 208.62,154.5 208.41,154.5 207.14,155.77 206.53,155.77 206.36,155.95 206.36,156.48 206.44,156.57 207.05,156.57
VGA_PHASE2 on IN3: 194.49,155.92 194.32,155.75 193.15,155.75 193.05,155.86 193.05,156.81 193.25,157.01 194.37,157.01 194.49,156.88
VGA_UGATE1 on TOP (solid shape): 209.61,150.87 209.61,150.64 208.95,149.98 208.79,149.98 208.59,150.18 208.59,150.31 208.69,150.41 208.69,150.43 209.28,151.02 209.45,151.02
VGA_UGATE1 on BOTTOM (solid shape): 195.46,140.68 195.46,139.66 195.31,139.51 194.44,139.51 194.06,139.89 194.06,140.68 194.21,140.83 195.31,140.83
VGA_UGATE1 on BOTTOM (solid shape): 211,151.55 211,151.35 210.98,151.32 210.01,151.32 209.61,150.92 209.61,150.61 208.93,149.94 208.81,149.94 208.62,150.13 208.62,150.38 209.81,151.58 210.98,151.58
VGA_UGATE1 on IN3: 194.19,140.86 196.45,140.86 196.58,140.73 196.58,140.2 196.42,140.04 195.56,140.04 195.36,140.25 194.16,140.25 194.09,140.32 194.09,140.76
VGA_UGATE1 on IN3: 209.25,150.99 209.45,150.99 209.58,150.87 209.58,150.41 208.36,149.19 208.36,148.99 208.13,148.76 207.14,148.76 206.97,148.93 206.97,149.37 207.07,149.47 207.73,149.47
VGA_UGATE2 on TOP (solid shape): 209.78,154.93 209.78,154.78 209.58,154.57 209.4,154.57 208.62,155.36 208.62,155.56 208.77,155.72 209,155.72
VGA_UGATE2 on BOTTOM (solid shape): 194.95,161.15 194.95,159.82 194.75,159.62 193.22,159.62 192.97,159.87 192.97,161.08 193.17,161.28 194.82,161.28
VGA_UGATE2 on BOTTOM (solid shape): 210.29,154.4 210.95,154.4 211.03,154.32 211.03,154.19 210.95,154.12 209.86,154.12 208.73,155.25 208.73,155.45 208.9,155.61 209.07,155.61
VGA_UGATE2 on IN3: 196.37,160.91 196.37,160.29 195.7,159.62 193.22,159.62 193.03,159.81 193.03,160.69 193.35,161.01 196.27,161.01
VGA_UGATE2 on IN3: 209.3,154.62 209.53,154.62 209.71,154.8 209.71,156.4 209.48,156.63 208.92,156.63 208.77,156.48 208.77,155.16
VMB on BOTTOM (solid shape): 197.75,182.89 197.75,178.14 197.26,177.66 192.64,177.66 192.21,178.09 192.21,183.1 192.51,183.4 197.24,183.4
VMB2 on BOTTOM (solid shape): 196.4,188.74 196.4,184.67 196.14,184.42 195.69,184.42 195.57,184.49 195.59,184.62 195.28,185.23 194.98,184.62 194.99,184.49 194.87,184.42 192.08,184.42 191.55,184.95 191.55,188.91 191.84,189.21 195.93,189.21
VSUM- on BOTTOM (solid shape): 215.4,147.66 215.4,145.2 215.47,145.12 216.34,145.12 216.46,145 216.46,144.59 216.34,144.46 213.37,144.46 213.26,144.57 213.26,144.97 213.39,145.1 213.75,145.1 213.87,145.23 213.87,146.78 214.03,146.93 214.53,146.93 214.66,147.06 214.66,147.72 214.71,147.77 215.3,147.77
VSYSTEM on BOTTOM (solid shape): 229.83,167.48 229.83,163.62 231.3,162.14 231.3,157.82 231.02,157.55 227.07,157.55 227.06,157.55 226.88,157.6 226.7,157.55 226.69,157.55 226.57,157.55 226.37,157.75 226.37,162.4 225.61,163.16 224.59,163.16 224.36,163.39 224.36,167.5 224.64,167.78 229.52,167.78
N18669 on BOTTOM (solid shape): 208.18,149.6 208.18,148.73 208.06,148.6 206.23,148.6 206.08,148.76 206.08,149.54 206.28,149.75 208.03,149.75
N18705 on BOTTOM (solid shape): 211.05,151.09 211.05,151.02 209.66,149.62 209.66,148.73 209.56,148.63 208.72,148.63 208.62,148.73 208.62,149.7 208.69,149.77 209.1,149.77 210.37,151.04 210.37,151.12 210.45,151.2 210.95,151.2
N22144 on BOTTOM (solid shape): 208.46,157.11 208.46,156.17 208.36,156.07 206.36,156.07 206.25,156.17 206.25,157.09 206.41,157.24 208.34,157.24
N22186 on BOTTOM (solid shape): 209.76,157.09 209.76,156.12 211.03,154.85 211.03,154.6 210.95,154.52 210.52,154.52 208.9,156.15 208.9,157.09 208.97,157.16 209.68,157.16
N15168718 on BOTTOM (solid shape): 137.47,32.63 137.47,31.84 137.37,31.74 134.94,31.74 134.82,31.87 134.82,32.64 134.91,32.73 137.37,32.73
N15172206 on BOTTOM (solid shape): 137.9,39.54 137.9,38.93 137.67,38.7 136.79,38.7 136.71,38.77 136.71,38.93 137.39,39.61 137.83,39.61
N15172224 on BOTTOM (solid shape): 140.77,39.07 140.77,38.14 140.7,38.06 138.92,38.06 138.69,38.29 136.73,38.29 136.66,38.37 136.66,38.44 136.73,38.52 136.73,38.55 138.66,38.55 139.02,38.9 139.73,38.9 139.97,39.14 140.7,39.14
N15173757 on BOTTOM (solid shape): 137.14,40.2 137.14,39.69 136.51,39.05 136.33,39.05 136.3,39.08 136.3,40.15 136.43,40.27 137.06,40.27
N16794121 on BOTTOM (solid shape): 219.49,176.68 219.49,176.09 219.56,176.01 220.15,176.01 220.27,176.14 220.27,176.66 220.38,176.76 223.67,176.76 223.93,176.49 223.93,174.74 222.76,173.57 222.76,169.43 222.03,168.7 218.09,168.7 217.73,169.05 217.73,175.96 218.53,176.76 219.41,176.76
N16794165 on BOTTOM (solid shape): 180.8,169.56 184.18,169.56 184.38,169.36 184.38,167.76 184.28,167.65 183.01,167.65 182.91,167.76 182.91,168.06 182.56,168.42 181.97,168.42 181.5,168.89 180.41,168.89 178.95,170.35 178.95,170.6 179,170.65 179.71,170.65
N16794166 on BOTTOM (solid shape): 186.9,170.88 186.9,168.63 187.95,167.58 187.95,166.47 187.64,166.16 186.87,166.16 186.43,166.6 186.43,166.92 185.02,168.33 185.02,171.03 185.15,171.16 186.62,171.16
N16794173 on BOTTOM (solid shape): 184.03,172.1 184.03,169.84 183.93,169.74 183.17,169.74 182.96,169.94 182.96,172.07 183.09,172.2 183.93,172.2
N16794279 on BOTTOM (solid shape): 222.43,159.37 222.43,158.59 222.33,158.49 221.49,158.49 221.39,158.59 221.39,159.42 221.47,159.5 222.31,159.5
N16794344 on BOTTOM (solid shape): 176.21,170.04 176.21,169.41 175.82,169.03 175.22,169.03 175.14,169.1 175.14,169.38 175.85,170.09 176.16,170.09
N16794345 on BOTTOM (solid shape): 175.7,170.58 175.7,170.25 174.96,169.51 174.63,169.51 174.48,169.66 174.48,170.22 174.89,170.63 175.65,170.63
N16902103 on TOP (solid shape): 191.55,156.73 191.55,154.9 191.42,154.78 190.71,154.78 190.43,155.06 190.43,156.76 190.53,156.86 191.42,156.86
N16922606 on BOTTOM (solid shape): 179.38,174.33 179.38,173.98 178.7,173.29 178.52,173.29 178.39,173.42 178.39,174.08 178.85,174.54 179.18,174.54
N16922835 on BOTTOM (solid shape): 196.93,172.81 196.93,171.82 196.86,171.74 195.43,171.74 195.31,171.87 195.31,172.81 195.38,172.89 196.86,172.89
N16954250 on BOTTOM (solid shape): 203.51,188.63 203.51,186.98 203.38,186.86 201.86,186.86 201.73,186.98 201.73,188.64 201.86,188.76 203.38,188.76
N26325477 on BOTTOM (solid shape): 144.15,101.11 144.15,98.59 144.48,98.26 144.48,96.66 144.05,96.23 137.78,96.23 137.29,95.75 134.91,95.75 133.99,96.66 133.15,96.66 133.05,96.56 133.05,95.67 133.03,95.65 132.95,95.65 132.9,95.7 132.9,96.56 132.8,96.66 132.57,96.66 132.16,97.07 132.16,101.11 132.44,101.39 143.87,101.39
N26386889 on BOTTOM (solid shape): 144.28,113.98 144.28,113.22 144.02,112.97 142.8,112.97 142.65,113.12 142.65,113.96 142.83,114.14 144.13,114.14
N31349437 on BOTTOM (solid shape): 131.3,99.94 131.3,98.95 131.17,98.82 128.91,98.82 128.86,98.87 128.86,99.91 129.01,100.07 131.17,100.07
N31349441 on BOTTOM (solid shape): 127.64,100.07 128.38,100.07 128.45,99.99 128.45,98.97 128.33,98.85 127.56,98.85 125.99,100.42 125.99,101.13 126.14,101.28 126.42,101.28
N31382737 on BOTTOM (solid shape): 38.31,69 38.31,63.57 39.5,62.37 39.5,61.69 39.53,61.66 39.53,56.4 39.12,56 33.99,56 33.61,56.38 33.61,66.54 33.38,66.77 32.67,66.77 32.62,66.82 32.62,66.89 32.65,66.92 33.48,66.92 33.61,67.05 33.61,69.05 33.81,69.25 38.06,69.25
N31382737 on TOP: 34.14,60.7 39.25,60.7 39.71,60.24 39.71,57.34 39.45,57.09 34.4,57.09 33.89,57.6 33.89,60.44
N31383366 on TOP (solid shape): 49.18,61.56 49.18,60.26 49.05,60.14 47.99,60.14 47.91,60.21 47.91,61.61 48.04,61.74 49,61.74
N31383897 on BOTTOM (solid shape): 36,74.13 36,72 35.85,71.85 35.03,71.85 34.88,72 34.88,74.11 35.06,74.28 35.85,74.28
N31383905 on BOTTOM (solid shape): 37.34,76.04 37.34,75.5 37.27,75.43 36.68,75.43 36.23,74.97 36.23,74.67 36.15,74.59 34.93,74.59 34.83,74.69 34.83,75.48 34.93,75.58 36.07,75.58 36.61,76.11 37.27,76.11
N31389989 on TOP (solid shape): 146.54,75.12 146.54,73.47 146.34,73.27 143.44,73.27 143.21,73.5 143.21,75.05 143.44,75.27 146.39,75.27
N31389989 on BOTTOM (solid shape): 145.5,75.78 145.5,73.03 145.41,72.94 141.82,72.94 141.43,72.56 140.49,72.56 140.37,72.43 140.37,71.39 140.32,71.34 140.26,71.34 140.21,71.39 140.21,72.38 140.04,72.56 138.69,72.56 138.54,72.71 138.54,74.49 138.89,74.84 141.59,74.84 142.68,75.94 145.34,75.94
N31390138 on TOP (solid shape): 141.81,78.86 141.81,77.92 141.66,77.76 140.01,77.76 139.86,77.92 139.86,78.91 139.96,79.01 141.66,79.01
N31390261 on BOTTOM (solid shape): 139.5,83.66 139.5,81.35 139.43,81.27 138.49,81.27 138.41,81.35 138.41,83.61 138.59,83.78 139.38,83.78
N31390261 on BOTTOM (solid shape): 139.5,83.63 139.5,81.32 139.43,81.24 138.49,81.24 138.41,81.32 138.41,83.58 138.59,83.76 139.38,83.76
N31390277 on BOTTOM (solid shape): 140.8,85.76 140.8,85.36 140.7,85.26 140.01,85.26 139.63,84.88 139.63,84.34 139.4,84.11 138.56,84.11 138.39,84.29 138.39,85.59 138.66,85.87 140.7,85.87
N31396697 on BOTTOM (solid shape): 68.45,124.61 68.45,123.93 68.36,123.84 68.13,123.84 67.42,124.55 67.42,124.78 67.57,124.93 68.13,124.93
N31396821 on BOTTOM (solid shape): 74.2,119.09 74.2,118.35 74.07,118.23 73.87,118.23 73.08,119.01 73.08,119.14 73.16,119.22 74.07,119.22
N31396963 on BOTTOM (solid shape): 73.67,118.05 73.67,117.87 73.59,117.79 72.8,117.79 72.65,117.95 72.65,118.76 72.68,118.78 72.93,118.78
N31397188 on BOTTOM (solid shape): 73.77,124.83 73.77,124.7 72.9,123.84 72.73,123.84 72.65,123.92 72.65,124.6 73.01,124.96 73.64,124.96
N31397190 on BOTTOM (solid shape): 74.2,124.35 74.2,123.84 73.77,123.41 73.21,123.41 73.16,123.46 73.16,123.69 73.97,124.5 74.05,124.5
N36436059 on TOP (solid shape): 140.14,24.58 140.14,23.66 139.88,23.41 138.41,23.41 138.16,23.66 138.16,24.68 138.26,24.78 139.93,24.78
N36436199 on BOTTOM (solid shape): 135.74,36.92 135.74,34.1 135.9,33.95 135.9,33.11 135.82,33.03 135.03,33.03 134.87,33.2 134.87,34.14 135.52,34.79 135.52,36.95 135.54,36.97 135.69,36.97
