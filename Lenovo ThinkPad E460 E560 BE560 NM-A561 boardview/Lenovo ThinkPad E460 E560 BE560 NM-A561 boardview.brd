# Allegro board Lenovo ThinkPad E460 E560 BE560 NM-A561 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBB_D17: length 17.2
  IN3 w0.14: v1(136.96,164.76) 136.99,164.76 137.6,165.37 137.6,170.85 135.54,172.91 135.54,174.43 v3(135.8,174.69)
  BOTTOM w0.084: v1(136.96,164.76) 137.45,164.28 137.45,163.32 137.81,162.96 137.81,162.11 138.13,161.79 138.13,161.57 138.11,161.52 138.11,161.48 138.1,161.41 138.05,161.31 138.05,160.44 137.6,159.99 UV1.M5
  BOTTOM w0.14: UV7.N13 v3(135.8,174.69)
FBB_D18: length 17.3
  IN3 w0.14: v3(134.24,173.22) 137.09,170.37 137.09,165.62 v1(136.99,165.52)
  BOTTOM w0.084: UV1.N4 138.76,160.72 138.76,161.27 138.67,161.36 138.67,162.83 137.93,163.56 137.93,164.58 137.17,165.34
  BOTTOM w0.14: v3(134.24,173.22) 135,173.98 135,174.69 UV7.M13 ; v1(136.99,165.52) 137.17,165.34
FBB_D19: length 20
  IN3 w0.14: v3(137.4,172.99) 138.49,171.9 138.49,165.37 v1(138.87,164.99)
  BOTTOM w0.084: UV1.P6 139,159.29 138.74,159.55 138.74,160.06 138.99,160.31 139.23,160.31 139.55,160.63 139.55,160.89 139.47,160.96 139.47,161.36 139.55,161.43 139.55,161.67 139.53,161.68 139.53,161.7 139.34,161.89 139.32,161.89 139.29,161.93 139.29,162.39 139.5,162.61 139.5,164.35 v1(138.87,164.99)
  BOTTOM w0.14: v3(137.4,172.99) 136.99,172.99 136.57,173.4 136.57,176.32 UV7.N11
FBB_D20: length 16.6
  IN3 w0.14: v1(140.67,163.92) 140.67,173.82 v1(139.8,174.69)
  BOTTOM w0.084: UV1.P5 139.2,160.05 139.73,160.58 139.73,160.94 139.65,161.02 139.65,161.3 139.76,161.41 139.76,161.72 139.47,162 139.47,162.31 139.69,162.53 139.69,162.94 v1(140.67,163.92)
  BOTTOM w0.14: UV7.U13 v1(139.8,174.69)
FBB_D21: length 17.7
  IN3 w0.14: v1(139,175.49) 139.4,175.09 140.6,175.09 141.13,174.56 141.13,163.78 v1(140.68,163.34)
  BOTTOM w0.084: v1(140.68,163.34) 140.35,163 140.35,160.71 UV1.R4
  BOTTOM w0.14: UV7.T13 v1(139,175.49)
FBB_D22: length 19.7
  IN3 w0.14: v1(139.8,176.29) 139.96,176.13 140.49,176.13 141.64,174.99 141.64,163.61 v1(140.77,162.75)
  BOTTOM w0.084: v1(140.77,162.75) 141.13,162.4 141.13,161.42 141.09,161.37 141.09,160.95 141.23,160.8 141.23,159.6 140.79,159.16 UV1.T6
  BOTTOM w0.14: UV7.U11 v1(139.8,176.29)
FBB_D23: length 18.7
  IN3 w0.14: v1(139,177.09) 139.4,176.69 140.63,176.69 142.12,175.2 142.12,163.44 v1(140.77,162.09)
  BOTTOM w0.084: v1(140.77,162.09) 140.8,162.07 UV1.T1
  BOTTOM w0.14: UV7.T11 v1(139,177.09)
FBB_D24: length 27.1
  BOTTOM w0.084: 139.53,166.12 139.53,165.67 141.3,163.91 141.3,161.35 141.25,161.3 141.25,161.02 141.43,160.84 141.43,160.53 UV1.U4
  BOTTOM w0.14: 139.53,166.12 v4(139.53,167.04) 139.53,172.79 140.33,173.59 140.33,177.47 139.42,178.39 136.79,178.39 134.98,180.2 134.98,181.87 UV7.M4
FBB_D25: length 28
  BOTTOM w0.084: UV1.V6 142.2,159.67 142.05,159.82 142.05,159.92 141.95,160.03 141.95,160.49 141.89,160.55 141.89,160.56 141.87,160.58 141.87,160.93 141.89,160.96 141.89,160.97 141.95,161.03 141.95,161.29 141.89,161.35 141.89,161.77 142.01,161.9 142.01,162.56 141.53,163.03 141.53,164.02 140.16,165.39 140.16,165.52
  BOTTOM w0.14: 140.16,165.52 v4(140.16,169.61) 140.16,172.68 140.9,173.42 140.9,177.66 139.61,178.96 137.37,178.96 135.82,180.51 135.82,181.91 UV7.N4
FBB_D26: length 27.7
  BOTTOM w0.084: 141.13,165.85 141.13,165.16 142.09,164.2 142.09,163.09 142.34,162.84 142.34,161.62 UV1.V1
  BOTTOM w0.14: 141.13,165.85 141.13,168.16 v4(141.57,168.6) 141.87,168.89 141.87,169.61 141.7,169.77 141.32,169.77 141.15,169.94 141.15,170.17 141.32,170.33 141.7,170.33 141.87,170.5 141.87,170.73 141.7,170.89 141.32,170.89 141.15,171.05 141.15,171.29 141.32,171.45 141.7,171.45 141.87,171.61 141.87,178.03 141.56,178.34 141.56,178.57 141.83,178.84 141.83,179.07 141.67,179.23 141.44,179.23 141.17,178.96 140.94,178.96 140.77,179.13 140.77,179.36 141.08,179.67 141.08,179.9 140.91,180.06 140.68,180.06 140.38,179.75 140.14,179.75 139.98,179.92 139.98,180.15 140.25,180.42 140.25,180.65 139.91,180.99 139.42,180.99 139.06,181.35 139.06,181.36 139.05,181.37 139.05,181.85 UV7.T4
FBB_D27: length 27.2
  BOTTOM w0.084: 141.61,165.85 141.61,165.03 142.37,164.28 142.37,163.14 142.51,163.01 142.51,161.94 142.75,161.7 142.75,161.46 142.67,161.3 142.67,161.03 UV1.V3
  BOTTOM w0.14: 141.61,165.85 141.61,167.79 142.35,168.52 v4(142.35,171.29) 142.35,179.34 142.02,179.68 142.02,179.91 142.34,180.23 142.34,180.46 142.18,180.63 141.95,180.63 141.62,180.3 141.39,180.3 141.23,180.47 141.23,180.7 141.55,181.02 141.55,181.25 141.39,181.42 141.15,181.42 140.83,181.09 140.6,181.09 140.43,181.26 140.43,181.49 140.76,181.81 140.76,182.04 140.6,182.21 140.36,182.21 140.04,181.88 139.81,181.88 UV7.U4
FBB_D28: length 27.9
  BOTTOM w0.084: UV1.Y6 144,159.32 143.64,159.68 143.64,161.18 143.47,161.36 143.47,161.94 143.42,161.98 143.42,161.99 143.4,162 143.4,163.11 142.95,163.56 142.95,164.64 142.58,165.01 142.58,165.85
  BOTTOM w0.14: UV7.U2 139.41,183.89 140.48,183.89 143.32,181.04 v4(143.32,176.37) 143.32,168.07 142.58,167.33 142.58,165.85
FBB_D29: length 31.6
  BOTTOM w0.084: 143.55,166.08 143.55,163.58 143.74,163.39 143.74,162.14 144,161.88 UV1.Y1
  BOTTOM w0.14: 143.55,166.08 143.55,166.8 144.3,167.55 v4(144.3,180.61) 144.3,181.47 140.09,185.69 136.99,185.69 136.56,185.26 136.56,184.25 UV7.N2
FBB_D30: length 27.8
  BOTTOM w0.084: 143.07,165.85 143.07,165.16 143.3,164.92 143.3,163.48 143.57,163.21 143.57,162.07 143.64,162 143.64,161.45 143.9,161.2 143.9,160.86 UV1.Y3
  BOTTOM w0.14: UV7.T2 139,184.29 140.76,184.29 143.8,181.24 v4(143.8,178.73) 143.8,167.74 143.07,167 143.07,165.85
FBB_D31: length 35.4
  BOTTOM w0.084: UV1.Y5 144,160.01 144.3,160.31 144.3,160.6 144.33,160.62 144.33,160.9 144.25,160.97 144.25,161.35 144.33,161.42 144.33,161.79 143.92,162.19 143.92,165.61 144.03,165.72 144.03,166.05
  BOTTOM w0.14: UV7.M2 135.74,184.23 135.74,185.54 136.38,186.17 140.34,186.17 144.79,181.72 v4(144.79,172.66) 144.79,167.33 144.03,166.57 144.03,166.05
FBB_MAB0_0: length 34.4
  IN1 w0.084: v1(139.91,157.82) 140.32,158.23 140.32,159.02 140.75,159.45 140.75,159.98 140.22,160.52 140.22,162.34 139.83,162.73
  IN1 w0.14: v1(131.83,181.88) 132.01,181.88 132.63,181.26 132.63,180.57 133.8,179.39 134.68,179.39 135.01,179.72 135.66,179.72 136.5,178.88 140.23,178.88 141.13,177.98 141.13,166.38 139.82,165.07 139.82,162.73 139.83,162.73
  BOTTOM w0.084: UV1.P8 139.46,157.82 v1(139.91,157.82)
  BOTTOM w0.14: v1(131.83,181.88) 131.83,181.92 UV7.H4
FBB_MAB0_1: length 35.7
  IN1 w0.084: v1(139.96,157.11) 139.5,157.57 139.5,159.64 139.33,159.82 139.33,162.57 139.48,162.73
  IN1 w0.14: v1(132.2,180.99) 132.2,180.42 133.74,178.88 134.78,178.88 135.12,178.54 135.51,178.54 135.68,178.37 135.68,178.16 135.84,177.99 136.07,177.99 136.24,178.16 136.24,178.37 136.4,178.54 136.63,178.54 136.8,178.37 136.8,178.16 136.96,177.99 137.19,177.99 137.35,178.16 137.35,178.37 137.52,178.54 137.75,178.54 137.91,178.37 137.91,178.16 138.08,177.99 138.31,177.99 138.47,178.16 138.47,178.37 138.64,178.54 138.87,178.54 139.03,178.37 139.03,178.16 139.19,177.99 139.43,177.99 139.59,178.16 139.59,178.37 139.75,178.54 140.09,178.54 140.79,177.84 140.79,166.52 139.48,165.21 139.48,162.73
  BOTTOM w0.084: UV1.T9 140.31,156.76 v1(139.96,157.11)
  BOTTOM w0.14: UV7.H5 v1(132.2,180.99)
FBB_MAB0_2: length 35.5
  IN1 w0.084: 135.39,160.21 135.39,158.38 137.04,156.73 137.94,156.73 v1(138.54,157.33)
  IN1 w0.14: v1(131.73,177.1) 131.73,176.22 131.4,175.89 131.4,173.52 129.72,171.85 129.72,171.2 129.56,171.04 128.62,171.04 128.45,170.88 128.45,170.64 128.62,170.48 129.56,170.48 129.72,170.32 129.72,170.08 129.56,169.92 128.62,169.92 128.45,169.76 128.45,169.53 128.62,169.36 129.56,169.36 129.72,169.2 129.72,168.97 129.56,168.8 128.62,168.8 128.45,168.64 128.45,168.41 128.62,168.24 129.56,168.24 129.72,168.08 129.72,167.38 130.76,166.34 130.99,166.34 131.32,166.67 131.55,166.67 131.71,166.5 131.71,166.27 131.38,165.95 131.38,165.71 133.07,164.03 133.07,163.44 133.68,162.84 134.25,162.84 134.79,162.3 134.79,160.81 135.39,160.21
  BOTTOM w0.084: UV1.P9 138.63,157.33 v1(138.54,157.33)
  BOTTOM w0.14: v1(131.73,177.1) 131.79,177.1 UV7.H11
FBB_MAB0_3: length 34.3
  IN1 w0.084: v1(137.47,158.61) 137.19,158.89 137.19,162.39 136.86,162.73
  IN1 w0.14: v3(131.78,177.91) 133,176.69 133.57,176.69 133.8,176.46 133.8,174.08 133.28,173.56 133.28,172.32 133.8,171.79 135.97,171.79 136.11,171.65 136.11,171.41 135.95,171.25 134.92,171.25 134.75,171.09 134.75,170.86 134.92,170.69 135.95,170.69 136.11,170.53 136.11,170.3 135.95,170.13 134.92,170.13 134.75,169.97 134.75,169.74 134.92,169.57 135.95,169.57 136.11,169.41 136.11,169.18 135.95,169.02 134.92,169.02 134.75,168.85 134.75,168.62 134.92,168.46 135.95,168.46 136.11,168.29 136.11,168.06 135.95,167.9 134.92,167.9 134.75,167.73 134.75,167.5 134.92,167.34 135.95,167.34 136.11,167.18 136.11,163.47 136.86,162.73
  BOTTOM w0.084: v1(137.47,158.61) 137.75,158.61 UV1.N7
  BOTTOM w0.14: UV7.H10 v3(131.78,177.91)
FBB_MAB0_4: length 34.2
  IN1 w0.084: v1(138.56,157.91) 138.45,157.91 137.85,158.51 137.85,158.82 137.39,159.27 137.39,162.68 137.34,162.73
  IN1 w0.14: v1(134.2,176.29) 134.25,176.29 134.6,175.93 134.6,175.66 134.6,174.39 134.93,174.06 134.93,172.88 134.77,172.72 133.93,172.72 133.76,172.55 133.76,172.32 133.95,172.14 137.38,172.14 137.61,171.91 137.61,171.76 137.45,171.59 136.85,171.59 136.68,171.43 136.68,171.2 136.85,171.03 137.45,171.03 137.61,170.87 137.61,170.64 137.45,170.47 136.85,170.47 136.68,170.31 136.68,170.08 136.85,169.92 137.45,169.92 137.61,169.75 137.61,169.52 137.45,169.36 136.85,169.36 136.68,169.19 136.68,168.96 136.85,168.8 137.45,168.8 137.61,168.63 137.61,168.4 137.45,168.24 136.85,168.24 136.68,168.08 136.68,167.84 136.85,167.68 137.45,167.68 137.61,167.52 137.61,167.29 137.45,167.12 136.85,167.12 136.68,166.96 136.68,166.73 136.85,166.56 137.65,166.56 137.81,166.4 137.81,166.19 137.62,166 136.59,166 136.45,165.86 136.45,163.62 137.34,162.73
  BOTTOM w0.084: v1(138.56,157.91) 138.21,157.56 UV1.N8
  BOTTOM w0.14: UV7.K11 v1(134.2,176.29)
FBB_MAB0_5: length 35.2
  IN1 w0.084: v1(139.76,155.92) 139.13,156.54 139.13,159.38 138.68,159.83 138.68,162.56 138.5,162.74
  IN1 w0.14: 138.5,162.74 137.95,163.29 137.95,165.24 140.1,167.39 140.1,168.35 139.94,168.51 139.64,168.51 139.48,168.68 139.48,168.91 139.64,169.07 139.94,169.07 140.1,169.23 140.1,169.47 139.94,169.63 139.64,169.63 139.48,169.79 139.48,170.02 139.64,170.19 139.94,170.19 140.1,170.35 140.1,170.58 139.94,170.75 139.64,170.75 139.48,170.91 139.48,171.14 139.64,171.31 139.94,171.31 140.1,171.47 140.1,171.7 139.94,171.86 139.64,171.86 139.48,172.03 139.48,172.26 139.64,172.42 139.94,172.42 140.1,172.59 140.1,172.85 139.33,173.62 139.33,174.87 139.15,175.05 138.87,175.05 138.72,174.89 138.72,174.39 138.56,174.23 136.67,174.23 136.53,174.37 136.53,175.35 135.99,175.89 135.63,175.89 135.4,176.12 135.4,176.48 135.01,176.87 v1(135.01,177.03)
  BOTTOM w0.084: UV1.N9 138.2,156.96 138.66,156.96 138.87,156.75 138.87,156.62 139.06,156.43 139.19,156.43 139.71,155.92 v1(139.76,155.92)
  BOTTOM w0.14: UV7.K10 134.19,177.1 134.93,177.1 v1(135.01,177.03)
FBB_MAB0_6: length 35.8
  IN1 w0.084: 142.41,162.73 142.41,160.38 141.59,159.56 141.59,157.4 v1(141,156.81)
  IN1 w0.14: v1(134.2,181.89) 134.2,181.89 139.67,181.89 139.83,181.73 139.83,181.23 140,181.07 140.23,181.07 140.39,181.23 140.39,181.73 140.56,181.89 141.42,181.89 142.5,180.81 142.5,162.82 142.41,162.73
  BOTTOM w0.084: v1(141,156.81) 141.55,156.81 UV1.U9
  BOTTOM w0.14: UV7.K5 v1(134.2,181.89)
FBB_MAB0_7: length 35.5
  IN1 w0.084: 142.07,160.85 142.07,160.54 141.41,159.88 141.41,157.8 v1(141.03,157.42)
  IN1 w0.14: v1(133.44,181.86) 133.44,181.58 133.73,181.29 134.4,181.29 134.65,181.55 138.89,181.55 139.74,180.7 140.74,180.7 140.91,180.86 140.91,181.28 141.07,181.45 141.3,181.45 141.46,181.28 141.46,180.86 141.63,180.7 141.9,180.7 142.16,180.44 142.16,163.16 142.07,163.07 142.07,160.85
  BOTTOM w0.084: v1(141.03,157.42) 141.46,157.42 UV1.U8
  BOTTOM w0.14: UV7.K4 133.43,181.92 133.43,181.86 v1(133.44,181.86)
FBB_MAB0_8: length 34.6
  IN1 w0.084: 141.22,160.78 141.22,158.38 v1(140.86,158.02)
  IN1 w0.14: v1(133.76,180.52) 133.88,180.41 135.95,180.41 136.79,179.57 138.17,179.57 138.95,180.35 141.26,180.35 141.81,179.8 141.81,165.44 141.65,165.28 141.06,165.28 140.9,165.11 140.9,164.88 141.06,164.72 141.65,164.72 141.81,164.55 141.81,163.36 141.25,162.8 141.25,160.81 141.22,160.78
  BOTTOM w0.084: v1(140.86,158.02) UV1.T8
  BOTTOM w0.14: UV7.J5 133,181.28 v1(133.76,180.52)
FBB_MAB1_0: length 36.6
  IN1 w0.084: v1(144.64,157.49) 144.89,157.74 144.89,158.17 145.1,158.38 145.1,159.87 146.67,161.43 146.67,161.76
  IN1 w0.14: 146.67,161.76 146.67,164.91 146.32,165.25 146.32,173.64 146.49,173.8 147.31,173.8 147.48,173.97 147.48,174.2 147.31,174.36 146.49,174.36 146.32,174.53 146.32,174.76 146.49,174.92 147.31,174.92 147.48,175.08 147.48,175.32 147.31,175.48 146.87,175.48 146.73,175.62 146.73,176.05 148.82,178.14 149.13,178.14 149.99,179.01 152.12,179.01 153.32,180.2 154.72,180.2 156.23,181.71 v1(156.23,181.86)
  BOTTOM w0.084: v1(144.64,157.49) 144,156.85 UV1.Y9
  BOTTOM w0.14: UV8.K4 v1(156.23,181.86)
FBB_MAB1_1: length 36.4
  IN1 w0.084: v1(143.41,157.06) 144.05,157.7 144.05,159.58 145.43,160.96 145.43,161.41
  IN1 w0.14: v3(155.37,181.92) 154.89,181.43 153.23,181.43 152.33,180.53 149.41,180.53 148.11,179.24 148.11,178.43 144.9,175.21 144.9,174.96 145.06,174.79 145.46,174.79 145.62,174.63 145.62,174.4 145.46,174.23 145.06,174.23 144.9,174.07 144.9,173.84 145.06,173.67 145.46,173.67 145.62,173.51 145.62,173.28 145.46,173.12 145.06,173.12 144.9,172.95 144.9,166.12 145.43,165.59 145.43,161.41
  BOTTOM w0.084: v1(143.41,157.06) 143.1,157.06 UV1.W9
  BOTTOM w0.14: UV8.K5 v3(155.37,181.92)
FBB_MAB1_2: length 36
  IN1 w0.084: v1(147.02,157.56) 147.16,157.7 148.37,157.7 148.95,158.28 148.95,159.68 149.92,160.64
  IN1 w0.14: 149.92,160.64 150.4,160.64 151.62,161.86 151.62,162.45 152.38,163.21 152.38,163.9 151.38,164.9 151.38,165.18 151.52,165.32 151.75,165.32 152.36,164.71 152.59,164.71 152.75,164.88 152.75,165.11 152.08,165.78 152.08,166.01 152.25,166.17 152.48,166.17 153.05,165.61 153.28,165.61 153.44,165.77 153.44,166 152.9,166.54 152.9,166.78 153.06,166.94 153.29,166.94 153.94,166.29 154.17,166.29 154.33,166.46 154.33,166.69 153.85,167.17 153.85,167.4 154.02,167.57 154.25,167.57 154.73,167.09 154.96,167.09 155.12,167.25 155.12,167.48 154.68,167.92 154.68,168.15 154.85,168.32 155.08,168.32 155.52,167.88 155.75,167.88 155.92,168.04 155.92,168.27 155.7,168.49 155.7,168.72 155.86,168.88 156.1,168.88 156.31,168.67 156.54,168.67 156.71,168.83 156.71,169.06 156.27,169.5 156.27,170.5 156.93,171.16 156.93,174.06 156.6,174.39 156.6,175.66 156.6,175.93 156.25,176.29 v1(156.2,176.29)
  BOTTOM w0.084: v1(147.02,157.56) UV1.AC8
  BOTTOM w0.14: UV8.K11 v1(156.2,176.29)
FBB_MAB1_3: length 35.7
  IN1 w0.084: 150.51,159.13 150.2,158.82 150.2,157.8 149.69,157.29 148.72,157.29 148.42,156.99 147.55,156.99 147,156.43 v1(147,156.28)
  IN1 w0.14: 150.51,159.13 158.53,167.15 158.53,168.2 158.69,168.36 159.33,168.36 159.49,168.52 159.49,168.75 159.33,168.92 158.69,168.92 158.53,169.08 158.53,169.31 158.69,169.48 159.33,169.48 159.49,169.64 159.49,169.87 159.33,170.04 158.69,170.04 158.53,170.2 158.53,170.43 158.69,170.59 159.33,170.59 159.49,170.76 159.49,170.99 159.33,171.15 158.69,171.15 158.53,171.32 158.53,171.55 158.69,171.71 159.33,171.71 159.49,171.88 159.49,172.11 159.33,172.27 158.69,172.27 158.53,172.43 158.53,175.35 157.99,175.89 157.63,175.89 157.4,176.12 157.4,176.48 156.85,177.04 156.25,177.04 v1(156.25,177.04)
  BOTTOM w0.084: UV1.AC9 146.88,156.28 v1(147,156.28)
  BOTTOM w0.14: v1(156.25,177.04) UV8.K10
FBB_MAB1_4: length 34.6
  IN1 w0.084: v1(145.85,158.54) 145.85,158.76 146.55,159.46 146.55,160.17 148.22,161.84 148.22,162.12
  IN1 w0.14: 148.22,162.12 148.22,164.97 148.05,165.13 147.85,165.13 147.71,165.27 147.71,165.55 147.85,165.69 148.05,165.69 148.22,165.86 148.22,166.09 148.05,166.25 147.54,166.25 147.38,166.42 147.38,166.65 147.54,166.81 148.05,166.81 148.22,166.97 148.22,167.21 148.05,167.37 147.54,167.37 147.38,167.53 147.38,167.77 147.54,167.93 148.05,167.93 148.22,168.09 148.22,168.32 148.05,168.49 147.54,168.49 147.38,168.65 147.38,168.88 147.54,169.05 148.05,169.05 148.22,169.21 148.22,171.44 149.66,172.88 149.66,173.83 150.2,174.36 150.2,177.28 150.48,177.56 153.65,177.56 153.88,177.79 153.88,178.68 154.06,178.86 154.34,178.86 154.51,178.68 154.51,177 v1(153.8,176.29)
  BOTTOM w0.084: v1(145.85,158.54) 145.68,158.36 UV1.AA7
  BOTTOM w0.14: UV8.H11 v1(153.8,176.29)
FBB_MAB1_5: length 35.1
  IN1 w0.084: 148.56,162.07 148.56,161.77 146.87,160.09 146.87,159.35 146.26,158.74 146.26,157.52 v1(145.85,157.11)
  IN1 w0.14: 148.56,162.07 148.56,165.62 148.8,165.86 148.8,166.26 148.56,166.5 148.56,166.73 148.72,166.9 149.32,166.9 149.49,167.06 149.49,167.29 149.32,167.46 148.72,167.46 148.56,167.62 148.56,167.85 148.72,168.01 149.32,168.01 149.49,168.18 149.49,168.41 149.32,168.57 148.72,168.57 148.56,168.74 148.56,168.97 148.72,169.13 149.32,169.13 149.49,169.3 149.49,169.53 149.32,169.69 148.72,169.69 148.56,169.85 148.56,170.09 148.72,170.25 149.32,170.25 149.49,170.41 149.49,170.64 149.32,170.81 148.72,170.81 148.56,170.97 148.56,171.29 148.93,171.66 149.16,171.66 149.73,171.1 149.96,171.1 150.12,171.26 150.12,171.49 149.55,172.06 149.55,172.29 149.72,172.45 149.95,172.45 150.52,171.89 150.75,171.89 150.91,172.05 150.91,172.28 150.34,172.85 150.34,173.08 150.55,173.29 150.55,173.93 151,174.38 151,174.86 151.23,175.09 151.66,175.09 151.8,175.23 151.8,175.71 151.97,175.89 152.46,175.89 153.64,177.06 v3(153.77,177.06)
  BOTTOM w0.084: v1(145.85,157.11) 145.65,157.11 UV1.AA8
  BOTTOM w0.14: UV8.H10 v3(153.77,177.06)
FBB_MAB1_6: length 37.1
  IN1 w0.084: v1(144.5,158.06) 144.51,158.06 144.92,158.46 144.92,159.96 145.78,160.82 145.78,162.73
  IN1 w0.14: v1(154.44,180.63) 154.29,180.63 153.8,181.12 153.32,181.12 152.3,180.1 149.71,180.1 148.55,178.93 148.55,178.37 145.98,175.81 145.98,172.54 145.82,172.37 145.43,172.37 145.27,172.21 145.27,171.98 145.43,171.81 145.82,171.81 145.98,171.65 145.98,171.42 145.82,171.26 145.43,171.26 145.27,171.09 145.27,170.86 145.43,170.7 145.82,170.7 145.98,170.53 145.98,170.3 145.82,170.14 145.43,170.14 145.27,169.97 145.27,169.74 145.43,169.58 145.82,169.58 145.98,169.42 145.98,169.18 145.82,169.02 145.43,169.02 145.27,168.86 145.27,168.63 145.43,168.46 145.82,168.46 145.98,168.3 145.98,168.07 145.82,167.9 145.43,167.9 145.27,167.74 145.27,167.51 145.43,167.34 145.82,167.34 145.98,167.18 145.98,166.95 145.82,166.79 145.43,166.79 145.27,166.62 145.27,166.24 145.78,165.73 145.78,162.73
  BOTTOM w0.084: UV1.Y8 v1(144.5,158.06)
  BOTTOM w0.14: UV8.H5 154.44,181.25 v1(154.44,180.63)
FBB_MAB1_7: length 38
  IN1 w0.084: 147.01,161.84 147.01,161.47 145.29,159.75 145.29,158.31 145.07,158.09 145.07,157.33 v1(144.63,156.89)
  IN1 w0.14: v5(155.43,179.82) 155.38,179.87 153.45,179.87 152.08,178.5 150.09,178.5 149.21,177.61 148.93,177.61 148.6,177.28 148.6,174.13 148.43,173.96 148.43,173.48 148.29,173.34 146.87,173.34 146.67,173.14 146.67,172.94 146.83,172.77 147.98,172.77 148.14,172.61 148.14,172.38 147.98,172.21 146.83,172.21 146.67,172.05 146.67,165.44 147.01,165.1 147.01,161.84
  BOTTOM w0.084: UV1.AA9 145.07,156.89 v1(144.63,156.89)
  BOTTOM w0.14: v5(155.43,179.82) 154.59,179.82 153.98,180.43 153.98,181.09 153.83,181.24 153.83,181.75 154.2,182.12 UV8.H4
FBB_MAB1_8: length 35.8
  IN1 w0.084: v1(143.41,157.65) 143.72,157.65 143.86,157.79 143.86,159.75 145.09,160.97 145.09,161.48
  IN1 w0.14: 145.09,161.48 145.09,165.44 144.56,165.98 144.56,175.55 145.07,176.06 145.07,176.29 144.71,176.65 144.71,176.88 144.88,177.04 145.11,177.04 145.46,176.69 145.69,176.69 145.86,176.85 145.86,177.08 145.5,177.44 145.5,177.67 145.67,177.83 145.9,177.83 146.25,177.48 146.48,177.48 147.48,178.47 147.48,179.06 149.4,180.98 150.77,180.98 151.16,181.37 152.46,181.37 153.02,181.93 v1(154.62,181.93)
  BOTTOM w0.084: v1(143.41,157.65) 142.89,157.65 UV1.W8
  BOTTOM w0.14: v1(154.62,181.93) 155,181.55 UV8.J5
FBB_RASB0#: length 36.2
  IN1 w0.084: 138.94,162.73 138.94,159.94 139.32,159.56 139.32,157.04 v1(139.83,156.53)
  IN1 w0.14: 138.94,162.73 138.94,162.78 138.39,163.34 138.39,165.19 140.44,167.25 140.44,177.15 140.04,177.56 135.24,177.56 134.38,178.41 133.6,178.41 131.73,180.28 131.73,181.19 131.4,181.52 131.4,182.24 v1(131.81,182.64)
  BOTTOM w0.084: v1(139.83,156.53) UV1.T10
  BOTTOM w0.14: v1(131.81,182.64) 131.81,182.68 UV7.G3
FBB_RASB1#: length 38.8
  IN1 w0.084: v1(143.46,156.4) 142.91,156.94 142.91,159.46 143.87,160.42 143.87,162.73
  IN1 w0.14: v1(156.14,183.48) 155.75,183.09 148.85,183.09 148.44,182.68 148.44,181.65 148.14,181.35 147.13,181.35 143.87,178.09 143.87,162.73
  BOTTOM w0.084: UV1.Y10 143.56,156.4 v1(143.46,156.4)
  BOTTOM w0.14: v1(156.14,183.48) 156.21,183.48 UV8.L3
FBB_WCKB0_0: length 30.4
  TOP w0.127: v1(133.68,162.37) 133.84,162.53 133.84,162.72 133.99,162.88 134,162.88 134.24,163.12 134.24,163.12 134.27,163.15 134.27,166.75 129.32,171.69 126.35,171.69 125.36,172.68 v3(125.36,177.33) 125.36,177.89 126.76,179.29 128.66,179.29 128.78,179.41 128.78,179.85 v1(128.35,180.28)
  BOTTOM w0.084: v1(133.68,162.37) 133.68,162.33 134.04,161.96 134.04,161.51 UV1.H3
  BOTTOM w0.127: v1(128.35,180.28) 128.58,180.51 128.58,181.87 UV7.D4
FBB_WCKB0_1: length 30.4
  IN3 w0.14: v1(139.82,159.85) 140,160.02 140,160.21 139.43,160.78 138.77,160.78 136.19,163.36 136.19,169.97 132.58,173.57 132.58,177.71 134.48,179.61 135.67,179.61 136.93,180.86 137.24,180.86 v1(137.41,181.03)
  BOTTOM w0.084: UV1.T3 140.66,160.62 140.34,160.3 140.34,160.23 139.96,159.85 v1(139.82,159.85)
  BOTTOM w0.127: v1(137.41,181.03) 137.41,181.64 137,182.04 UV7.P4
FBB_WCKB0B_0: length 30
  TOP w0.127: v1(134.25,162.26) 134.07,162.44 134.07,162.63 134.09,162.65 134.09,162.65 134.47,163.03 134.47,163.03 134.5,163.06 134.5,163.25 134.5,166.84 129.42,171.92 v3(128.91,171.92) 128.48,171.92 128.38,172.02 127.97,172.02 127.87,171.92 127.46,171.92 127.36,172.02 126.96,172.02 126.85,171.92 126.45,171.92 125.59,172.78 125.59,173.73 125.69,173.83 125.69,174.24 125.59,174.34 125.59,174.75 125.69,174.85 125.69,175.25 125.59,175.36 125.59,175.76 125.69,175.86 125.69,176.27 125.59,176.37 125.59,176.78 125.69,176.88 125.69,177.29 125.59,177.39 125.59,177.79 126.14,178.34 126.28,178.34 126.57,178.63 126.57,178.77 126.85,179.06 127.76,179.06 127.86,178.96 128.27,178.96 128.37,179.06 128.75,179.06 129.01,179.32 129.01,179.72 v1(129.62,180.33)
  BOTTOM w0.084: UV1.H1 134.23,161.73 134.23,162.23 v1(134.25,162.26)
  BOTTOM w0.127: UV7.D5 128.81,181.3 128.81,180.46 128.94,180.33 v1(129.62,180.33)
FBB_WCKB0B_1: length 30.7
  IN3 w0.14: v1(140.37,159.63) 140.24,159.76 140.24,160.31 139.53,161.03 138.87,161.03 136.43,163.46 136.43,170.07 132.82,173.67 132.82,177.61 134.58,179.36 135.77,179.36 137.03,180.62 137.26,180.62 137.4,180.48 v1(137.4,180.29)
  BOTTOM w0.084: v1(140.37,159.63) 140.37,159.99 140.53,160.15 140.53,160.22 140.73,160.43 140.95,160.43 141.04,160.35 141.04,160.2 UV1.T5
  BOTTOM w0.127: v1(137.4,180.29) 137,180.69 UV7.P5
FBB_WCKB1_0: length 28.1
  TOP w0.127: v1(150.62,179.59) 150.89,179.86 150.89,179.97 150.79,180.07 150.19,180.07 147.48,177.36 147.48,173.47 149.18,171.77 v3(149.18,168.14) 149.18,163.49 148.69,162.99 148.13,162.99 147.78,162.65 v1(147.78,162.6)
  BOTTOM w0.084: v1(147.78,162.6) 147.78,162.71 147.97,162.89 148.18,162.89 148.3,162.77 148.3,161.35 148.39,161.27 148.39,161.05 148.3,160.97 148.3,160.37 148.19,160.25 148.11,160.25 UV1.AE4
  BOTTOM w0.127: UV8.D4 150.58,181.52 150.58,181.41 150.51,181.33 150.51,180.44 150.77,180.18 150.77,179.74 v1(150.62,179.59)
FBB_WCKB1_1: length 28.2
  IN3 w0.14: v5(153.09,164.3) 153.09,164.65 152.88,164.86 152.88,165.47 154.65,167.25 154.65,178.32 156.1,179.77 158.15,179.77 158.67,180.3 v3(158.67,180.4)
  BOTTOM w0.084: v5(153.09,164.3) 152.83,164.57 152.7,164.57 152.58,164.46 152.58,162.33 152.45,162.19 152.45,161.89 152.52,161.82 152.52,161.34 152.47,161.3 152.47,161.02 152.52,160.98 152.52,160.54 152.47,160.5 152.47,160.22 152.52,160.18 152.52,159.7 152.37,159.56 152.35,159.56 152.23,159.53 152.23,159.53 152.18,159.53 152.14,159.47 152.14,159.39 UV1.AK6
  BOTTOM w0.127: UV8.P4 159,182.05 158.65,181.7 158.65,181.35 158.73,181.27 158.73,180.46 v3(158.67,180.4)
FBB_WCKB1B_0: length 28.2
  TOP w0.127: v1(151.44,179.67) 151.27,179.67 151.12,179.82 151.12,180.06 150.88,180.3 150.1,180.3 147.25,177.45 147.25,173.38 148.95,171.67 v3(148.95,171.03) 148.95,163.58 148.59,163.22 147.8,163.22 v1(147.78,163.21)
  BOTTOM w0.084: UV1.AF5 148.47,160.29 148.47,160.9 148.55,160.98 148.55,161.34 148.47,161.42 148.47,162.87 148.26,163.08 147.91,163.08 v1(147.78,163.21)
  BOTTOM w0.127: UV8.D5 150.99,181.49 150.73,181.24 150.73,180.54 151.01,180.27 151.01,179.68 151.18,179.5 151.27,179.5 v1(151.44,179.67)
FBB_WCKB1B_1: length 27.9
  IN3 w0.14: v3(159.13,179.79) 158.98,179.95 158.66,179.95 158.25,179.53 156.2,179.53 154.9,178.22 154.9,167.15 153.12,165.37 153.12,164.96 153.29,164.79 153.45,164.79 v5(153.55,164.89)
  BOTTOM w0.084: v5(153.55,164.89) 153.42,164.75 152.62,164.75 152.4,164.53 152.4,162.4 152.26,162.26 152.26,161.82 152.33,161.75 152.33,161.42 152.29,161.37 152.29,160.95 152.33,160.9 152.33,160.62 152.29,160.57 152.29,160.15 152.33,160.1 152.33,159.86 152.25,159.78 152.18,159.78 UV1.AK5
  BOTTOM w0.127: v3(159.13,179.79) 159.13,180.2 159.17,180.24 159.17,180.6 159,180.77 UV8.P5
FBB_WEB0#: length 35
  IN1 w0.084: 137.75,162.73 137.7,162.68 137.7,159.4 138.06,159.04 138.06,158.59 138.36,158.28 138.77,158.28 138.95,158.1 138.95,157.02 v1(138.52,156.59)
  IN1 w0.14: 137.75,162.73 137.75,162.88 137.47,163.16 137.47,165.25 139.58,167.35 139.58,167.76 139.41,167.93 138.12,167.93 137.95,168.09 137.95,168.32 138.12,168.49 138.91,168.49 139.07,168.65 139.07,168.88 138.91,169.05 138.12,169.05 137.95,169.21 137.95,169.44 138.12,169.61 138.91,169.61 139.07,169.77 139.07,170 138.91,170.16 138.12,170.16 137.95,170.33 137.95,170.56 138.12,170.72 138.91,170.72 139.07,170.89 139.07,171.12 138.91,171.28 138.12,171.28 137.95,171.45 137.95,171.68 138.12,171.84 138.91,171.84 139.07,172 139.07,173.12 138.89,173.29 138.61,173.29 138.46,173.14 138.46,172.61 138.33,172.48 136.02,172.48 135.31,173.19 135.31,175.18 v1(135,175.49)
  BOTTOM w0.084: UV1.N10 138,156.07 v1(138.52,156.59)
  BOTTOM w0.14: UV7.L12 v1(135,175.49)
FBB_WEB1#: length 35.9
  IN1 w0.084: v1(145.82,155.76) 146.49,156.43 146.49,158.35 147.15,159.01 147.15,160.1 148.9,161.85 148.9,162.14
  IN1 w0.14: 148.9,162.14 148.9,165.22 149.84,166.16 149.84,166.9 150,167.06 150.39,167.06 150.58,167.25 150.58,167.48 150.44,167.62 150,167.62 149.84,167.79 149.84,168.02 150,168.18 150.39,168.18 150.58,168.37 150.58,168.6 150.44,168.74 150,168.74 149.84,168.9 149.84,169.14 150,169.3 150.39,169.3 150.58,169.49 150.58,169.72 150.44,169.86 150,169.86 149.84,170.02 149.84,170.32 150.44,170.92 150.67,170.92 151.15,170.44 151.38,170.44 151.55,170.6 151.55,170.84 151.07,171.32 151.07,171.55 151.23,171.71 151.46,171.71 151.94,171.23 152.17,171.23 152.34,171.39 152.34,171.63 151.25,172.72 151.25,172.95 151.41,173.11 151.64,173.11 152.73,172.02 152.96,172.02 153.85,172.91 153.85,173.19 153.68,173.37 153.45,173.37 153.04,172.96 152.58,172.96 152.33,173.21 152.33,174.08 152.57,174.33 152.57,175.06 v1(153,175.49)
  BOTTOM w0.084: v1(145.82,155.76) 145.6,155.54 UV1.AB11
  BOTTOM w0.14: UV8.G12 v1(153,175.49)
FDO: length 18.5
  IN3 w0.084: v3(156.95,133.14) 156.95,137.63 155.86,138.72 155.29,138.72 155.09,138.92 153.22,138.92 152.96,138.66 152.96,137.93 v1(152.6,137.57)
  BOTTOM w0.084: UV1.AK32 152.2,137.96 v1(152.6,137.57)
  BOTTOM w0.114: RV147.2 159.7,127.98 159.7,130.21 v2(159.82,130.34) 159.82,130.72 157.41,133.14 v3(156.95,133.14)
FN_LED#: length 115.5
  TOP w0.114: v4(130.87,79.48) 130.24,80.1 v3(130.18,80.1) ; v3(172.65,113.98) 172.65,114.15 172.89,114.39 JKB.26
  IN1 w0.14: v3(146.46,81.65) 147.52,80.59 147.52,77.93 148.08,77.37 148.08,72.14 147.23,71.29 138.64,71.29 137.6,72.33 137.6,73.24 136.76,74.08 132.11,74.08 130.28,75.91 130.28,77.1 129.57,77.81 129.57,78.55 130.18,79.16 v3(130.18,80.1)
  IN3 w0.114: v3(146.46,81.65) 146.46,81.9 146.92,82.36 146.92,83.66 147.88,84.62 148.9,84.62 151.14,86.86 152.95,86.86 157.09,91 157.09,91.94 160.89,95.73 161.93,95.73 167.2,101 167.2,101.3 167.77,101.87 v3(168.38,101.87) ; v3(111.59,92.47) 112.2,93.08 115.35,93.08 115.66,92.77 118.2,92.77 118.49,92.48 119.21,92.48 120.74,90.95 122,90.95 123.25,89.7 123.25,89.41 126.22,86.44 126.22,84.35 126.91,83.65 126.91,81.91 128.62,80.2 130.08,80.2 v3(130.18,80.1)
  BOTTOM w0.076: v3(111.59,92.47) 111.33,92.72 109.47,92.72 UC1.AC1
  BOTTOM w0.114: v3(172.65,113.98) 172.65,108.18 168.13,103.65 168.13,102.12 v3(168.38,101.87)
FSCE#: length 123.9
  TOP w0.114: UE1.101 188.91,43.71 v3(192.31,47.11)
  IN1 w0.14: v3(172.62,54.88) 172.62,55.44 171.35,56.71 171.35,60.77 161.04,71.08 160.69,71.08 157.52,74.25 157.52,76.52 153.32,80.72 153.32,85.41 155.4,87.5 155.4,89.9 156.88,91.37 156.88,94.34 158.91,96.37 158.91,105.88 157.11,107.69 157.11,110.97 155.12,112.95 155.12,114.85 152.3,117.67 138.64,117.67 137.32,118.99 v3(137.29,118.99)
  IN2 w0.14: v3(172.62,54.88) 173.08,54.42 173.67,54.42 174,54.75 177.02,54.75 177.7,54.07 182.53,54.07 183.14,53.45 187.94,53.45 192.31,49.08 v3(192.31,47.11)
  BOTTOM w0.114: RC311.1 138.94,118.01 138.61,118.34 137.94,118.34 v3(137.29,118.99)
FW_GPIO: length 311.8
  TOP w0.084: JLCD.38 88.61,129.72
  TOP w0.114: R9449.1 112.35,72.53 112.05,72.53 111.03,73.55 111.03,74.18 110.34,74.87 110.34,75.97 v3(110.76,76.39) ; v3(33,69.31) v4(33,70.07) v3(34.52,71.59) ; v3(80.26,109.2) 80.51,109.2 81.73,110.42 81.73,116.45 83.31,118.02 84,118.02 86.26,120.28 86.26,123.71 86.49,123.94 86.49,124.86 88.91,127.27 88.91,129.43 88.61,129.72
  IN1 w0.14: v3(34.52,71.59) 32.77,73.34 32.77,77.79 39.91,84.93 39.91,90.41 47.62,98.12 47.62,98.91 54.02,105.31 55.62,105.31 58.76,108.45 58.76,109.16 60.38,110.78 64.83,110.78 65.97,109.64 68.97,109.64 69.25,109.36 72.86,109.36 73.34,109.83 74.92,109.83 75.5,110.4 77.63,110.4 78.83,109.2 v3(80.26,109.2) ; v3(110.76,76.39) 112.51,74.64 113.87,74.64 114.33,74.18 114.33,72.75 115.76,71.32 117.37,71.32 117.6,71.09 118.09,70.6 118.09,70.09 119.14,69.04 119.14,67.79 122.1,64.84 122.1,63.29 121.28,62.46 121.28,60.62 125.51,56.39 125.51,48.93 126.45,48 126.45,44.77 122.42,40.74 121.25,40.74 117.96,37.46 117.96,29.84 113.5,25.38 83.38,25.38 79.69,21.68 39.76,21.68 27.79,33.64 27.79,41.98 32.43,46.61 32.43,56.37 33.7,57.64 33.7,68.61 v3(33,69.31)
  BOTTOM w0.076: UC1.BB7 106.21,82.34 106.36,82.19 106.4,82.19 109.65,78.93
  BOTTOM w0.102: 109.65,78.93 110.76,77.82 v3(110.76,76.39)
GPD7: length 33.2
  TOP w0.114: v3(115.27,66.77) 113.67,66.77 RC351.2 113.85,65.22 v4(114.13,65.22)
  IN3 w0.076: v3(101.08,85.75) 100.7,85.37 100.7,84.96 101.02,84.64 101.26,84.64 101.57,84.34 101.86,84.34 102.21,83.99
  IN3 w0.114: 102.21,83.99 103.58,82.62 104.2,82.62 105.24,81.58 107.06,81.58 110.09,78.55 110.09,77.66 111.18,76.57 111.18,74.72 110.75,74.29 110.75,71.87 112.83,69.79 114.4,69.79 115.65,68.53 115.65,67.15 v3(115.27,66.77)
  BOTTOM w0.076: UC1.AT15 101.43,86.1 v3(101.08,85.75)
GPIO01: length 2.6
  BOTTOM w0.114: TP120.1 112.92,121.03 UTPM1.30
GPIO2: length 16
  BOTTOM w0.114: R9489.2 122.18,126.71 121.95,126.48 Q27.1 118.17,126.48 117.63,127.01 113.85,127.01 112.91,126.07 R9480.1 113.67,124.5 115.13,124.5 v4(115.92,123.71) UTPM1.3
GPIO03: length 2.9
  BOTTOM w0.114: TP121.1 117.42,124.18 UTPM1.6
GPIO04: length 2.2
  BOTTOM w0.114: TP124.1 120.17,120.03 UTPM1.13
GPIO5_AC_BATT: length 20.1
  TOP w0.114: v1(151.83,147.18) 151.83,147.42 153.04,148.63 155.4,148.63 155.76,148.99 156.34,148.99 156.8,148.53 159.87,148.53 160.13,148.78 161.32,148.78 RV117.2 RV149.2 163.92,149.24 DV5.2 164.21,149.31 165.46,150.56 v2(165.46,150.81)
  BOTTOM w0.102: v1(151.83,147.18) 151.4,147.18 150.93,147.65 150.51,147.65 150.17,147.99 150.17,149.32 150.6,149.74 UV1.AH17
GPIO8_ROMSO: length 9.1
  TOP w0.114: TPV3.1 157.11,154.9 153.9,154.9 v1(153.47,154.47)
  BOTTOM w0.084: UV1.AJ13 151.69,153.76 152.41,154.47 v1(153.47,154.47)
GPIO9_ROMSI: length 11.3
  TOP w0.114: TPV4.1 159.29,153.63 158.27,152.62 154.11,152.62 152.3,150.81 v1(151.92,150.81)
  BOTTOM w0.102: v1(151.92,150.81) 151.81,150.92 151.81,151.97 151.63,152.15 151.23,152.15 151.22,152.16 UV1.AH15
GPIO10_ROMSCK: length 19.8
  TOP w0.114: TPV15.1 159.09,152.36 154.44,152.36 v1(154.03,151.96) 151.8,149.72 v1(151.8,149.6) 152.1,149.6 153.85,151.35 157,151.35 157.33,151.02 159.06,151.02 TPV5.1
  BOTTOM w0.084: UV1.AM14 153.8,152.19 v1(154.03,151.96) ; UV1.AJ16 151.4,150.8 151.8,150.4 151.8,150 151.8,150 v1(151.8,149.6)
GPIO15_PWRCNTL_0: length 9.9
  TOP w0.114: RV178.1 161.32,155.44 v4(159.54,155.44) 158.86,155.44 157,153.58 154.64,153.58 154.18,153.12 v3(154.18,153.04)
  BOTTOM w0.084: UV1.AM13 153.8,153.59 154.18,153.21 v3(154.18,153.04)
GPIO17_THERMAL_INT: length 20.4
  TOP w0.114: RV104.1 164.65,131.48 164.14,131.99 162.87,131.99 162.05,132.82 v3(161.92,132.82)
  IN3 w0.084: v1(150.76,138.34) 151.09,138.67 152.05,138.67 152.66,139.29 155.25,139.29 155.44,139.09 156.02,139.09 157.88,137.23 157.88,136.27 157.99,136.16
  IN3 w0.114: 157.99,136.16 161.33,132.82 v3(161.92,132.82)
  BOTTOM w0.084: UV1.AG30 150.76,138.8 v1(150.76,138.34)
GPIO19_CTF: length 45.5
  TOP w0.114: v4(162.21,126.81) 162.53,127.13 v3(162.86,127.13) 163.13,126.86 RV118.1 RV102.1
  BOTTOM w0.084: 160.1,139.74 159.37,139.74 158.43,140.68 158.43,148.24 157.45,149.22 157.45,149.4 157.04,149.81 155.64,149.81 155.54,149.91 155.34,149.91 154.74,150.51 154.15,150.51 UV1.AM17
  BOTTOM w0.114: v3(162.86,127.13) 163.39,126.61 169.31,126.61 170.36,127.66 170.36,130.72 168.97,132.12 165.98,132.12 163.82,134.28 163.82,134.85 163.38,135.29 163.38,138.24 161.88,139.74 160.1,139.74
GPIO20_PWRCNTL_1: length 10.7
  TOP w0.114: RV179.1 161.6,153.66 v4(160.81,153.66) 159.9,154.57 158.45,154.57 157.03,153.15 v3(154.82,153.15)
  BOTTOM w0.084: 153.47,154.09 153.14,153.76 UV1.AL13
  BOTTOM w0.102: v3(154.82,153.15) 154.77,153.15 154.52,153.4 154.41,153.4 154.24,153.57 154.24,153.9 154.02,154.12 153.65,154.12 153.63,154.09 153.47,154.09
GPIO22_ROMCSB: length 10.1
  TOP w0.114: TPV6.1 159.52,155.89 158.91,155.89 156.9,153.89 154.29,153.89 v1(153.57,153.16)
  BOTTOM w0.102: UV1.AK13 152.49,153.76 152.59,153.67 153.09,153.16 v1(153.57,153.16)
GPP_B18: length 24.9
  TOP w0.114: v4(119.74,70.12) 119.26,70.6 RC98.2 RC97.2 119.21,72.13 v3(119.21,73.45)
  IN3 w0.114: v3(105.65,86.39) 106.11,85.93 106.11,84.71 106.33,84.5 106.84,84.5 107.34,84 107.34,83.69 111.96,79.07 111.96,78.59 114.18,76.37 114.18,75.54 115.41,74.31 118.65,74.31 119.21,73.75 v3(119.21,73.45)
  BOTTOM w0.076: UC1.AR7 106.02,86.75 v3(105.65,86.39)
GPP_B22: length 25.9
  TOP w0.114: RC99.2 RC100.1 120.52,73.14 v3(120.35,72.97)
  IN3 w0.114: v3(120.35,72.97) 120.37,72.99 120.37,73.63 120.15,73.85 119.51,73.85 118.7,74.67 116.74,74.67 115.03,76.38 114.51,76.38 112.24,78.65 112.24,79.18 109.53,81.88 109.53,86.91 v3(110.04,87.41)
  BOTTOM w0.076: v3(110.04,87.41) 109.58,87.87 107.21,87.87 UC1.AN5
GPP_B23: length 31.2
  TOP w0.114: v4(125.2,72.89) 125.2,73.72 v3(125.02,73.9) 124.97,73.95 124.69,73.95 RC101.2
  IN1 w0.076: v3(105.65,88.29) 105.65,88.22 105.26,87.83 105.26,84.63 106.65,83.25 108.08,83.25 111.95,79.39
  IN1 w0.14: 111.95,79.39 114.49,79.39 117.29,76.6 117.79,76.6 118.12,76.26 121.01,76.26 122.34,74.93 122.96,74.93 123.17,74.72 123.34,74.72 124.16,73.9 v3(125.02,73.9)
  BOTTOM w0.076: UC1.AM7 106.06,88.7 v3(105.65,88.29)
GPP_C2: length 15.6
  TOP w0.076: v1(112.3,97.88) 113.14,98.72 RC306.1 115.88,99.18 116.69,99.18 116.82,99.05 116.82,98.44 RC307.1
  IN1 w0.076: 109.62,97.45 108.33,96.16 104.87,96.16 104.67,96.36 v3(104.67,96.53)
  IN1 w0.14: 109.62,97.45 111.87,97.45 v1(112.3,97.88)
  BOTTOM w0.076: UC1.R10 v3(104.67,96.53)
GPP_C5: length 10.8
  BOTTOM w0.076: UC1.W1 109.95,94.82 110.29,95.16 111.77,95.16 111.88,95.28 112.79,95.28 v2(112.81,95.29) 113.3,95.29 113.79,94.81 RC83.2 115.58,94.81 115.73,94.65 115.73,93.46 115.87,93.32 116.96,93.32 117.02,93.38
  BOTTOM w0.114: RC350.1 117.91,94.5 117.43,94.02 117.43,93.79 117.02,93.38
GPU_VR_HOT#: length 190.1
  TOP w0.114: UE1.66 184.68,56.47 v1(184.46,56.68) ; RV149.1 162.67,151.3 163.43,152.06 v3(164.9,152.06) ; v3(206.2,130.5) 207.02,130.5 208.21,131.69 RE9.1 209.15,132.5 211.66,132.5 218.81,139.65 218.81,143.87 222.24,147.3 222.24,152.35 v4(220.43,154.17) v3(219.92,154.68)
  IN1 w0.14: v1(184.46,56.68) 183.78,57.37 183.78,61.61 184.77,62.6 187.81,62.6 190.02,64.81 192.36,64.81 203,75.45 203,94.55 202.39,95.16 202.39,118.43 204.63,120.66 204.63,127.4 206.2,128.97 v3(206.2,130.5)
  IN2 w0.14: v3(206.2,130.5) 193,130.5 190.79,132.71 183.32,132.71 182,131.38 181.12,131.38 180.13,130.39 175.46,130.39 171.33,134.53 171.33,137.73 169.45,139.61 165.18,139.61 164.65,140.14 164.65,149.65 165.16,150.15 165.16,151.8 v3(164.9,152.06)
  BOTTOM w0.254: PR610.1 v3(219.92,154.68)
GSENSE_INT: length 3.3
  TOP w0.114: RG7.2 202.29,68.01 v4(202.29,68.77)
  TOP w0.254: RG7.2 202.88,67.94 UGSEN1.11
GSENSE_INT2: length 4.9
  TOP w0.114: UGSEN1.9 203.42,68.94 202.98,69.38 202.98,72.36 TG1.1
H_CPUPWRGD: length 13.3
  BOTTOM w0.076: UC1.A68 70.82,105.04 70.24,105.61 68.89,105.61 67.17,107.33 66.77,107.33 66.03,108.07
  BOTTOM w0.114: 66.03,108.07 65.72,108.38 65.72,109.89 65.17,110.44 65.17,111.82 66.22,112.88 66.22,113.58 66.53,113.88 T59.1
H_HDMI_TX0+: length 3.5
  TOP w0.114: L1.1 18.17,64.15 18.34,64.33 18.83,64.33 19.32,63.83 v3(19.87,63.83) 20.46,63.83 20.54,63.75 UX1.19
H_HDMI_TX0-: length 3.5
  TOP w0.114: L1.4 18.17,64.75 18.36,64.56 v3(18.75,64.56) 18.92,64.56 19.42,64.06 20.46,64.06 20.54,64.15 UX1.18
H_HDMI_TX1+: length 3.5
  TOP w0.114: L2.1 18.12,62.27 18.32,62.47 18.63,62.47 18.69,62.41 v3(19.49,62.41) 19.88,62.41 20.1,62.63 20.58,62.63 20.66,62.55 UX1.22
H_HDMI_TX1-: length 3.5
  TOP w0.114: UX1.21 20.72,62.95 20.63,62.85 20,62.85 19.79,62.64 18.79,62.64 18.73,62.7 18.27,62.7 18.1,62.87 L2.4
H_HDMI_TX2+: length 3.7
  TOP w0.114: L3.1 18.19,60.29 18.4,60.49 19.07,60.49 v3(19.55,60.97) 19.99,61.41 20.55,61.41 20.62,61.35 UX1.25
H_HDMI_TX2-: length 3.7
  TOP w0.114: UX1.24 20.67,61.75 20.55,61.63 19.89,61.63 18.98,60.72 18.37,60.72 18.2,60.89 L3.4
H_HDMI_TXC+: length 4.2
  TOP w0.114: L4.1 18.21,66.47 v3(18.8,66.47) 19,66.47 19.16,66.32 19.34,66.13 19.34,65.47 19.55,65.25 19.77,65.03 20.46,65.03 20.54,64.95 UX1.16
H_HDMI_TXC-: length 4.3
  TOP w0.114: UX1.15 20.54,65.35 20.46,65.26 19.87,65.26 v3(19.71,65.42) 19.57,65.56 19.57,66.23 19.09,66.7 18.25,66.7 L4.4
H_PECI: length 236.9
  TOP w0.114: v5(197.85,37.58) 197.92,37.66 RE1.1 ; v1(123.95,121.96) 123.95,121.26 125.53,119.67 131.76,119.67 132.58,118.85 133.53,118.85 134.39,119.71 139.48,119.71 139.48,119.71 140.11,119.71 140.96,120.56 141.86,120.56 142.23,120.18 146.05,120.18 146.3,119.94 146.3,118.59 152.84,112.05 152.84,104.88 153.6,104.12 153.6,101.64 v3(153.35,101.39)
  IN1 w0.14: v1(111.18,117.01) 111.69,117.01 113.47,118.78 115.44,118.78 117.85,121.2 120.2,121.2 v1(121.02,122.02) ; v3(172.44,19.97) 173.39,20.92 173.39,36.46 172.62,37.23 171.02,37.23 169.42,38.83 169.42,45.02 171.71,47.31 171.71,50.33 170.72,51.32 170.72,54.09 170.44,54.37 170.44,56 169.86,56.58 169.86,60.29 v3(170.26,60.7)
  IN2 w0.14: v1(123.95,121.96) 123.37,122.53 121.53,122.53 v1(121.02,122.02) ; v1(111.18,117.01) 109.01,114.84 101.85,114.84 100.59,113.58 83.37,113.58 81.02,111.23 81.02,110.21 80.64,109.83 79.85,109.83 v3(78.57,108.55) ; v3(170.26,60.7) 166.99,60.7 166.24,61.44 162.09,61.44 158.87,64.67 158.87,68.61 153.92,73.56 153.92,84.05 153.12,84.85 153.12,85.39 151.62,86.89 151.62,89.42 151.35,89.7 151.35,94.66 152.79,96.1 152.79,100.83 v3(153.35,101.39)
  IN3 w0.114: v3(172.44,19.97) 173.25,20.79 177.65,20.79 179.69,22.84 184.07,22.84 186.26,25.03 186.67,25.03 189.47,27.83 189.47,28.82 197.85,37.2 v5(197.85,37.58)
  BOTTOM w0.076: v3(78.57,108.55) 78.03,108.02 78.03,106.96 78.8,106.2 78.8,105.07 UC1.A54
H_PROCHOT_EC: length 16.9
  TOP w0.114: UE1.80 v3(184.16,50.87) ; v3(186.39,38.88) 186.64,39.12 QE1.2 186.24,40.1 v4(186.24,41.09)
  IN1 w0.14: v3(184.16,50.87) 184.66,50.36 184.66,44.16 186.26,42.56 186.26,39 v3(186.39,38.88)
H_THERMTRIP#: length 132.3
  TOP w0.114: RV110.2 171.08,129.25 v3(169.7,127.88) ; v3(153.63,107.48) 153.93,107.18 v4(155.91,107.18) 162.65,107.18 v3(164.55,109.07)
  IN1 w0.14: v3(169.7,127.88) 169.7,127.37 168.1,125.77 166.43,125.77 165.42,124.77 165.42,121.47 163.73,119.78 163.73,116.6 163.02,115.89 163.02,114.04 164.55,112.51 v3(164.55,109.07)
  IN2 w0.14: v3(70.34,110.91) 71.01,111.58 71.65,111.58 72.45,110.78 78.16,110.78 78.99,111.61 79.3,111.61 80.19,112.5 81.21,112.5 82.89,114.17 100.35,114.17 101.6,115.43 108.65,115.43 110.86,117.64 111.31,117.64 114.17,114.78 130.36,114.78 131.44,113.7 135.31,113.7 136.63,115.02 150.56,115.02 152.08,113.5 152.08,109.03 v3(153.63,107.48)
  BOTTOM w0.114: RC54.1 v3(70.34,110.91)
HDA_BCLK: length 27.7
  TOP w0.114: v3(99.8,75.94) 100.41,75.33 100.41,73.93 101.02,73.32 101.02,71.16 100.82,70.96 100.82,70.58 100.95,70.45 101.17,70.45 101.33,70.3 101.33,70.12 101.23,70.02 100.92,70.02 100.82,69.92 100.82,69.69 101.12,69.38 101.86,69.38 101.99,69.25 101.99,68.85 101.86,68.72 101.66,68.72 101.5,68.56 101.5,68.38 101.64,68.24 101.89,68.24 101.99,68.14 101.99,67.85 101.86,67.72 v4(101.59,67.72) 100.64,67.72 100.51,67.59 100.51,67.44 100.63,67.31 101.58,67.31 101.71,67.18 101.71,67 101.58,66.88 100.56,66.88 100.44,66.75 100.44,66.57 100.56,66.44 101.47,66.44 101.59,66.32 101.59,65.58 101.72,65.45 RPC2.7
  BOTTOM w0.076: 98.49,78.54 98.49,79.06 97.99,79.56 97.99,80.55 97.59,80.95 97.59,81.64 97.26,81.97 97.26,82.44 97.31,82.56 97.31,82.7 97.25,82.93 97.25,83.05 97.32,83.26 97.42,83.37 97.52,83.48 UC1.AY22
  BOTTOM w0.102: v3(99.8,75.94) 98.49,77.25 98.49,78.54
HDA_RST#: length 24.1
  TOP w0.114: RPC2.8 101.45,64.95 101.1,65.31 v4(101.1,65.5) 100.65,65.5 99.88,66.27 99.88,67.67 100.51,68.3 100.96,68.3 101.23,68.57 101.23,68.87 100.49,69.61 100.49,73.01 99.75,73.75 v3(99.75,75.27)
  BOTTOM w0.076: 98.06,78.54 98.06,78.76 97.43,79.4 97.43,81.55 97.09,81.89 97.09,82.48 97.11,82.51 97.14,82.59 97.14,82.71 97.07,82.93 97.07,83.07 97.13,83.23 97.13,83.31 97.35,84.01 97.35,84.01 97.52,84.19 UC1.AW22
  BOTTOM w0.102: v3(99.75,75.27) 98.06,76.97 98.06,78.54
HDA_SDOUT: length 29.1
  TOP w0.114: v4(99.57,68.06) 98.66,68.98 98.66,69.59 RC302.1 99.96,70.88 RC21.2 RC299.1 99.96,73.17 99.35,73.78 99.35,76.17 v3(99.78,76.6) 100.1,76.6 101.07,75.63 101.07,74.05 101.56,73.57 101.56,69.97 102.22,69.31 102.22,68.83 102.49,68.55 102.49,66.98 102.09,66.58 102.09,66.21 102.35,65.95 RPC2.6
  BOTTOM w0.076: UC1.BB22 97.52,82.15 97.6,82.07 97.6,81.87 97.76,81.7 97.76,81.1 98.27,80.59 98.27,79.68 98.8,79.16 98.8,78.64 98.8,78.64 98.8,78.54
  BOTTOM w0.102: v3(99.78,76.6) 98.8,77.57 98.8,78.54
HDA_SYNC: length 23.1
  TOP w0.114: v4(103.31,62.63) RC356.1 103.18,63.86 103.18,66.27 103,66.45 RPC2.5 102.73,66.58 102.73,68.65 102.46,68.93 102.46,69.41 101.76,70.1 101.76,73.63 101.26,74.13 101.26,75.8 v3(99.83,77.24)
  BOTTOM w0.076: 99.03,78.54 99.03,79.19 98.45,79.77 98.45,80.64 97.93,81.16 97.93,81.77 97.79,81.91 97.79,82.52 97.52,82.78 UC1.BA22
  BOTTOM w0.102: 99.03,78.54 99.03,78.04 v3(99.83,77.24)
HDD_DETECT#: length 111.8
  TOP w0.114: RE15.2 203.46,51.04 203.41,51.09 v4(202.95,51.09) 202.95,50.84 202.18,50.07 UE1.15 200.56,50.07 200.24,49.75 188.98,49.75 v3(188.21,50.52)
  IN1 w0.14: v3(202.93,118.12) 203.71,117.34 203.71,104.4 202.73,103.42 202.73,95.22 203.31,94.64 203.31,75.15 186.7,58.54 186.7,52.03 v3(188.21,50.52)
  BOTTOM w0.114: JHDD.12 190.47,123.73 189.62,122.87 189.62,121.63 190.3,120.94 199.07,120.94 201.89,118.12 v3(202.93,118.12)
HDD_DEVSLP0: length 107.7
  TOP w0.114: v4(188.02,124.68) 188.02,123.61 v3(187.93,123.52) 188.63,122.82 188.63,120.16 184.08,115.61 184.08,111.44 v3(184.31,111.22)
  IN2 w0.14: v3(148.9,98.8) 148.88,98.77 148.88,97.68 148.39,97.19 147.76,97.19 147.19,96.62 147.19,95.8 146.78,95.39 144.68,95.39 143.71,96.37 132.72,96.37 130.41,98.68 126.39,98.68 125.22,99.85 120.81,99.85 120.05,99.09 117.27,99.09 116.81,99.55 114.72,99.55 113.42,100.85 112.97,100.85 v3(112.57,100.45)
  IN3 w0.114: v3(184.31,111.22) 182.78,109.69 174.4,109.69 173.72,110.37 172.35,110.37 170.51,108.54 163.9,108.54 160.54,105.17 151.8,105.17 148.9,102.27 v3(148.9,98.8)
  BOTTOM w0.076: UC1.J1 109.85,100.29 111.2,100.29 111.86,100.95 112.35,100.95 112.57,100.74 v3(112.57,100.45) 112.57,99.97 112.93,99.61 RC88.2
  BOTTOM w0.114: JHDD.10 v3(187.93,123.52)
HDMI_CLK: length 47.7
  TOP w0.114: v3(29.93,61.51) 30,61.51 30.36,61.86 v2(30.36,62.12) 30.28,62.19 29.93,62.19 29.6,61.86 29.11,61.86 28.83,62.15 UX1.48
  IN2 w0.14: JHDMI.15 10.09,65.15 10.09,66.13 10.65,66.69 11.77,66.69 12.54,65.91 13.18,65.91 13.52,65.57 13.52,63.54 v3(13.39,63.41)
  BOTTOM w0.114: R224.2 15.09,68.77 12.63,68.77 11.97,68.11 10.87,68.11 10.06,67.3 10.06,64.91 9.66,64.51 JHDMI.15 ; D12.5 D12.6 13.66,64.32 13.39,64.05 v3(13.39,63.41) 13.79,63.02 13.79,58.56 16.16,56.19 19.65,56.19 23.1,59.63 25.66,59.63 27.9,61.86 29.57,61.86 v3(29.93,61.51)
HDMI_DAT: length 38.7
  TOP w0.114: UX1.47 28.8,61.75 29.16,61.39 v5(29.3,61.39)
  IN2 w0.14: v3(12.5,63.41) 11,64.92 JHDMI.16
  BOTTOM w0.114: JHDMI.16 10.66,65.01 10.32,65.34 10.32,67.2 10.98,67.86 12.1,67.86 12.76,68.52 13.98,68.52 14.18,68.32 R225.2 ; v5(29.3,61.39) 27.76,61.39 25.76,59.39 23.2,59.39 19.75,55.95 16.06,55.95 13.54,58.46 13.54,61.84 12.5,62.88 v3(12.5,63.41) 13.06,63.97 13.06,64.48 13.4,64.82 D12.7 D12.4
HDMI_HPD: length 16.6
  TOP w0.229: UX1.17 20.25,64.55 20.25,64.54 v3(20.25,64.54)
  IN2 w0.254: JHDMI.19 9.99,67.05 12.3,67.05 12.63,66.71 v3(12.76,66.71) 16.44,66.71 18.62,64.53 20.25,64.53 v3(20.25,64.54)
  BOTTOM w0.114: v3(12.76,66.71) 12.76,66.59 13.53,65.82 D12.8 D12.2 14.75,65.85 15.8,65.85 v2(15.86,65.8)
HDMI_TX0+_CON: length 15.4
  TOP w0.114: v5(12.53,64.1) 12.88,64.45 13.31,64.45 13.39,64.37 D14.5 D14.6 14.88,64.37 15.02,64.51 15.37,64.51 15.56,64.31 16.37,64.31 16.54,64.15 L1.2
  IN1 w0.14: v5(12.53,64.1) 12.28,64.34 11.95,64.34 11.66,64.63 11.66,66.33 11.33,66.66 10.57,66.66 10.37,66.46 10.37,61.18 10.07,60.88 9.82,60.88 JHDMI.7
HDMI_TX0-_CON: length 15.4
  TOP w0.114: L1.3 16.54,64.75 16.33,64.54 v3(15.96,64.54) 15.66,64.54 15.47,64.73 15.04,64.73 14.91,64.87 D14.7 D14.4 13.5,64.87 13.29,64.66 12.76,64.66 v3(12.53,64.89)
  IN1 w0.14: v3(12.53,64.89) 12.24,64.6 12.06,64.6 11.92,64.74 11.92,66.44 11.44,66.92 10.47,66.92 10.12,66.57 10.12,61.28 9.96,61.13 9.82,61.13 JHDMI.9
HDMI_TX1+_CON: length 8.3
  TOP w0.114: L2.2 16.57,62.27 16.36,62.47 15.88,62.47 15.47,62.07 15.12,62.07 15.01,61.96 D13.8 D13.2 13.27,61.96 13.14,62.09 12.78,62.09 12.12,61.44 v3(12.12,60.67) 12.12,59.76 11.77,59.4 11.39,59.4 JHDMI.4
HDMI_TX1-_CON: length 8.3
  TOP w0.114: JHDMI.6 11,60 11.38,59.63 11.67,59.63 11.89,59.85 11.89,61.53 v3(12.36,62) 12.68,62.32 13.14,62.32 13.27,62.46 D13.1 D13.9 14.98,62.46 15.14,62.3 15.38,62.3 15.79,62.7 16.31,62.7 16.48,62.87 L2.3
HDMI_TX2+_CON: length 10.7
  TOP w0.114: L3.2 16.52,60.29 16.38,60.43 15.65,60.43 15.48,60.59 15.12,60.59 14.98,60.46 D13.6 D13.5 13.43,60.46 13.26,60.62 13.08,60.62 13.01,60.55 13.01,58.39 v3(12.47,57.85) 11.73,57.11 10.68,57.11 9.94,57.86 9.8,57.86 JHDMI.1
HDMI_TX2-_CON: length 10.7
  TOP w0.114: JHDMI.3 9.45,58.5 9.77,58.18 9.94,58.18 10.78,57.34 11.64,57.34 12.78,58.49 v3(12.78,59.37) 12.78,60.64 13.01,60.87 13.31,60.87 13.39,60.96 D13.4 D13.7 14.98,60.96 15.12,60.82 15.58,60.82 15.74,60.66 16.27,60.66 16.51,60.89 L3.3
HDMI_TXC+_CON: length 9.3
  TOP w0.114: JHDMI.10 11.42,62.42 11.69,62.42 12.02,62.75 12.02,65.22 12.78,65.98 13.16,65.98 13.27,65.87 D14.2 D14.8 14.93,65.87 15.06,66 15.29,66 v3(15.64,66.35) 15.78,66.49 16.47,66.49 16.64,66.31 L4.2
HDMI_TXC-_CON: length 9.3
  TOP w0.114: JHDMI.12 11,63 11.33,62.67 11.34,62.67 11.36,62.65 11.6,62.65 11.79,62.85 11.79,65.31 v3(12.47,65.99) 12.69,66.21 13.1,66.21 13.15,66.25 13.26,66.37 D14.1 D14.9 14.91,66.37 15.05,66.23 15.2,66.23 15.68,66.71 16.47,66.71 16.66,66.91 L4.3
HG_1PH: length 8.5
  TOP w0.254: v4(141.79,75.15) 141.79,75.78 v3(141.84,75.83)
  IN1 w0.762: 139.17,83.38 139.17,77.99 140.9,76.27
  vias: v3(139.93,83.78) v3(139.96,83.15) v3(141.81,76.47)
HG_A1: length 8.3
  IN3 w0.762: 137.52,101.59 136.35,100.42 129.7,100.42
  vias: v3(128.05,100.5) v3(128.68,100.5) v3(137.57,103.01) v3(137.57,102.38)
HG_B1: length 9.8
  TOP w0.114: v3(39.96,63.74) 39.99,63.77 v4(40.7,63.77)
  IN3 w0.762: 39.35,64.63 36.38,67.6 36.38,72.48
  vias: v3(36.56,74.03) v3(36.56,73.4) v3(39.22,63.74)
HGNDA: length 1.8
  TOP w0.203: UA1.25 208.98,16.55 208.95,16.52 v3(208.95,16.52)
  vias: v2(218.98,8.93) v3(208.92,15.84) v3(217.18,18.45) v3(217.81,18.45) v3(221.77,8.07) v3(221.77,7.41) v3(222.41,8.07) v3(222.43,7.38)
HGNDB: length 2.2
  TOP w0.203: v3(209.68,16.27) 209.68,16.65 209.37,16.96 UA1.26
  vias: v3(209.71,15.61) v3(217.15,17.54) v3(221.67,6.44) v3(221.67,5.78) v3(222.36,6.42) v3(222.36,5.75) v5(217.81,17.52)
HP_OUTL: length 26
  TOP w0.203: UA1.22 207.78,17.59 207.24,17.06 v3(207.14,17.06)
  TOP w0.254: v3(217.79,19.5) 217.76,19.47 CA31.2 ; RA17.1 RA16.1 217.25,12.16 v5(217.63,11.77)
  IN1 w0.254: v3(207.14,17.06) 207.27,17.06 208.06,17.85 213.26,17.85 214.92,19.5 v3(217.79,19.5)
  BOTTOM w0.254: v3(217.79,19.5) 216.57,19.5 215.94,18.87 215.94,13.29 217.46,11.77 v5(217.63,11.77)
HP_OUTL_CON: length 5.8
  TOP w0.254: v4(215.63,10.43) RA17.2 216.85,10.43 217.35,9.92 217.48,9.87 218.42,9.87 218.6,9.69 219,9.69 220.05,8.65 JAUF.7
HP_OUTR: length 29.1
  TOP w0.203: v5(207.17,16.32) 207.22,16.32 208.18,17.28 UA1.23
  TOP w0.254: v3(217.81,20.44) 217.58,20.66 CA32.2 ; v3(217.73,12.69) 218.27,12.16 RA22.1 RA23.1
  IN1 w0.254: v5(207.17,16.32) 207.32,16.32 208.23,17.23 213.59,17.23 215.35,18.99 218.09,18.99 218.4,19.29 218.4,19.85 v3(217.81,20.44)
  BOTTOM w0.254: v3(217.73,12.69) 216.52,13.91 216.52,18.63 216.85,18.96 218.04,18.96 218.42,19.34 218.42,20.03 218.01,20.44 v3(217.81,20.44)
