# Allegro board Lenovo ThinkPad E460 E560 BE560 NM-A561 boardview.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+0.675VS on BOTTOM (solid shape): 132.95,38.37 132.95,37.81 132.75,37.61 131.17,37.61 130.97,37.81 130.97,38.42 131.15,38.6 132.72,38.6
+0.675VS on TOP: 125.66,49.6 125.66,45.2 125.25,44.79 125.25,38.62 124.9,38.27 124.9,36.97 126.85,35.02 126.85,30.93 126.35,30.42 125.18,30.42 124.9,30.14 124.9,26.3 124.54,25.95 122.61,25.95 122.36,26.2 122.36,30.34 124.14,32.12 124.14,35.57 123.5,36.21 123.5,49.82 123.93,50.26 125,50.26
+0.675VS on IN1: 121.7,26.58 121.7,28.3 121.93,28.53 121.93,35.05 126.8,39.92 132.01,39.92 132.9,39.03 132.9,33.57 125.41,26.07 122.21,26.07
+0.675VSP on BOTTOM (solid shape): 134.96,36.9 134.96,36.21 133.66,34.91 131.07,34.91 130.99,34.99 130.99,36.79 131.07,36.87 133.2,36.87 133.31,36.77 134.58,36.77 134.73,36.92 134.73,36.95 134.91,36.95
+1.8VALW on TOP (solid shape): 148.08,95.8 148.08,95.04 147.95,94.91 147.69,94.91 146.87,94.08 146.87,93.45 146.68,93.26 146.17,93.26 145.98,93.45 145.98,94.72 147.25,95.99 147.88,95.99
+1.8VALW on BOTTOM (solid shape): 173.67,176.32 173.67,174.79 173.49,174.61 173.03,174.61 172.83,174.82 171.86,174.82 171.58,174.54 171.3,174.54 170.14,175.71 170.14,176.47 170.24,176.57 173.41,176.57
+1.8VALW on TOP: 173.46,176.05 173.65,175.86 174.25,175.86 174.45,175.66 174.45,173.93 174.06,173.53 172.81,173.53 172.7,173.65 172.7,174.92 172.19,175.43 172.19,175.93 172.31,176.05
+1.8VALW on TOP: 126.27,89.52 127.08,89.52 127.09,89.51 127.5,89.51 127.59,89.42 127.59,88.76 127.36,88.53 127.36,87.42 127.08,87.14 126.35,87.14 126.19,87.29 126.19,89.45
+1.8VALW on IN2: 145.5,89.78 137.8,89.78 137.47,90.11 137.47,91.18 138.44,92.14 143.9,92.14 144.43,92.67 144.43,93.87 145.19,94.63 146.81,94.63 147.08,94.36 147.08,91.35
+1.8VALW on IN2: 172.47,177.26 174.02,177.26 174.2,177.08 174.2,174.77 173.72,174.28 172.4,174.28 171.91,174.77 171.91,176.7
+1.8VALW on IN3: 126.27,89.65 131.53,89.65 132.93,91.05 138.44,91.05 138.63,90.87 138.63,89.93 135.79,87.09 127.51,87.09 126.17,88.43 126.17,89.55
+1.8VS_VGA on TOP: 172.73,172.38 173.56,172.38 173.72,172.23 173.72,167.98 173.36,167.63 172.83,167.63 172.68,167.78 172.68,172.33
+1.8VS_VGA on TOP: 149.41,142.71 150.16,141.96 150.16,141.15 149.54,140.53 149.54,139.89 149.41,139.77 148.62,139.77 148.52,139.87 148.52,140.15 148.53,140.16 148.52,140.17 148.52,140.68 148.42,140.78 148.42,142.15 148.27,142.31 147.91,142.31 147.76,142.46 147.76,143.4 147.88,143.52 149.26,143.52 149.41,143.37
+1.8VS_VGA on TOP: 149.89,151.7 149.83,151.64 149.58,151.64 149.56,151.66 149.26,151.66 149.23,151.69 149.23,152.31 149.13,152.41 149,152.41 148.88,152.54 148.32,152.54 148.19,152.67 148.19,153.23 148.01,153.41 147.94,153.41 147.78,153.56 147.78,153.71 147.92,153.85 150.01,153.85 150.12,153.74 150.12,152.97 149.89,152.74
+1.8VS_VGA on BOTTOM: 149.83,143.41 149.92,143.32 149.92,142.28 150.15,142.05 150.15,141.49 149.92,141.26 148.55,141.26 147.94,141.87 147.94,143.22 148.13,143.41
+1.8VS_VGA on BOTTOM: 148.42,155.54 149.89,155.54 150.04,155.39 150.04,152.14 149.74,151.83 148.49,151.83 147.4,152.92 147.4,154.12 148.22,154.93 148.22,155.34
+1.8VS_VGA on IN1: 160.75,125.07 156.46,125.07 153.4,128.13 147.81,128.13 146.67,129.28 146.67,132.83 145.47,134.02 145.47,137.91 146.37,138.81 155.58,138.81 161.94,132.46 161.94,131.72 163.25,130.41 163.25,127.57
+1.8VS_VGA on IN2: 157.93,141.66 157.93,129.16 157.59,128.82 147.33,128.82 146.67,129.48 146.67,132.83 145.47,134.02 145.47,151.55 147.88,153.96 154.79,153.96 154.79,153.99 156.83,156.02 159.77,156.02 159.87,155.92 159.87,155.06 159.19,154.37 159.19,152.06 152.85,145.72 151.53,145.72 150.78,144.97 149.43,144.97 148.6,144.13 148.6,143.45 148.95,143.09 149.54,143.09 149.89,142.74 156.85,142.74
+1.8VSP on BOTTOM (solid shape): outline of 205 points within 171.18,177.28 178.67,184.9
+1.35V on BOTTOM (solid shape): outline of 3091 points within 81.24,3.9 138.61,55.17
+1.35V on TOP: 173.44,182.16 172.9,181.62 168.69,181.62 168.33,181.98 168.33,186.7 168.79,187.16 175.44,187.16 176.51,186.09 176.51,183.99 176.5,183.97 176.5,182.58 176.08,182.16
+1.35V on TOP: 80.12,52.62 98.66,52.62 107.83,43.45 107.83,19.7 111.21,16.32 129.42,16.32 130.46,15.28 130.46,11.06 131.2,10.33 135.74,10.33 136.73,9.34 136.73,7.91 136.34,7.52 136.34,5.67 133.64,2.96 96.88,2.96 80.02,19.83 69.09,19.83 66.78,22.14 66.78,25.36 66.86,25.44 76.33,25.44 77.65,26.76 77.65,50.15 ; 2 cut-outs
+1.35V on VCC: outline of 143 points within 70,21.12 198.81,186.98 ; 1 cut-out
+1.35V on IN3: 92.06,88.84 94.06,88.84 94.46,88.44 94.46,86.62 95.03,86.04 95.62,86.04 95.83,85.84 95.83,85.64 95.69,85.5 95.69,84.03 98.15,81.57 98.15,80.94 97.85,80.63 90.33,80.63 89.13,81.83 88.12,81.83 85.73,84.22 85.73,85.23 85.22,85.74 85.22,85.94 85.38,86.1 86.49,86.1 86.62,86.22 86.62,87.54 86.86,87.78 86.86,88.34 87.14,88.62 87.47,88.62 88.17,87.92 91.14,87.92
+1.35VP on TOP (solid shape): 134.19,12.84 134.19,11.44 133.97,11.22 132.95,11.22 132.64,11.52 132.64,12.97 132.72,13.04 133.99,13.04
+1.35VP on TOP (solid shape): 134.68,32.58 134.68,31.56 134.47,31.36 133.53,31.36 133.31,31.59 133.31,32.55 133.48,32.73 134.52,32.73
+1.35VP on BOTTOM (solid shape): 134.55,38.85 134.55,38.77 134.47,38.7 133.48,38.7 133.36,38.83 133.36,39.54 133.46,39.64 133.76,39.64
+1.35VP on BOTTOM (solid shape): 135.34,36.92 135.34,35.35 134.58,34.58 134.58,31.66 134.42,31.51 133.56,31.51 133.43,31.64 133.43,34.25 135.08,35.9 135.08,36.92 135.13,36.97 135.29,36.97
+1.35VP on BOTTOM (solid shape): 140.29,20.06 140.29,11.01 139.58,10.3 137.9,10.3 137.88,10.33 137.88,10.83 137.85,10.86 137.12,10.86 137.09,10.83 137.09,10.33 137.06,10.3 136.71,10.3 136.68,10.33 136.68,10.81 136.63,10.86 135.95,10.86 135.9,10.81 135.9,10.38 135.82,10.3 134.04,10.3 133.97,10.38 133.97,10.81 133.91,10.86 133.23,10.86 133.2,10.83 133.2,10.4 133.13,10.33 132.8,10.33 132.75,10.38 132.75,10.83 132.72,10.86 132.04,10.86 131.98,10.81 131.98,10.35 131.93,10.3 131.27,10.3 131.17,10.4 131.17,11.04 131.86,11.72 131.86,12.69 131.17,13.37 131.17,20.08 131.48,20.39 139.96,20.39
+1.35VP on IN3 (solid shape): 133.91,13.71 133.91,11.93 133.71,11.72 132.82,11.72 132.49,12.05 132.49,13.78 132.62,13.91 133.71,13.91
+1.35VP on IN3 (solid shape): 134.58,32.5 134.58,31.43 134.37,31.23 132.49,31.23 132.17,31.55 132.17,32.39 132.47,32.68 134.4,32.68
+1.35VS_VGA on TOP (solid shape): 167.85,186.86 167.85,183.33 167.62,183.1 166.4,183.1 165.97,182.67 165.18,182.67 165.13,182.72 165.13,183.73 163.12,185.74 163.12,187.03 163.35,187.26 167.44,187.26
+1.35VS_VGA on BOTTOM: 135.77,155.31 136.45,155.31 137.01,154.75 137.01,154.19 136.33,153.51 135.59,153.51 135.41,153.68 135.41,154.95
+1.35VS_VGA on IN2: 110.06,127.14 106.79,130.42 103.99,130.42 102.55,131.87 102.55,136.39 101.68,137.25 101.68,168.52 105.16,172 107.07,172 114.08,179.01 116.01,179.01 124.03,187.03 137.6,187.03 137.72,187.16 153.22,187.16 153.23,187.15 162.12,187.15 162.13,187.14 166.66,187.14 167.57,186.22 168.81,186.22 171.05,183.99 171.05,181.52 168.43,178.91 168.43,170.37 166.05,167.98 166.05,167.3 157.82,159.07 157.82,157.6 154.62,154.4 145.24,154.4 145.17,154.32 141.66,154.32 138.46,151.12 138.46,150.51 137.88,149.93 136.76,149.93 136.43,149.6 136.43,136.49 135.08,135.14 132.67,135.14 131.96,134.43 131.96,133.72 130.26,132.02 130.26,131.05 130.61,130.7 133.66,130.7 134.09,131.13 136.56,131.13 136.94,130.75 136.94,128.84 136.4,128.31 127.49,128.31 126.32,127.14 ; 1 cut-out
+1.35VS_VGA on IN3: 136.86,159.04 147.25,159.04 149.89,156.4 149.89,154.88 149.26,154.24 137.8,154.24 137.27,153.71 137.27,147.77 138.23,146.8 138.23,144.13 136.25,142.15 132.75,142.15 132.21,142.69 132.21,150.76 133.28,151.83 133.61,151.83 135.34,153.56 135.34,154.57 136.05,155.28 136.05,158.23
+1.35VS_VGA_EN on TOP: 166.53,182.84 167.6,182.84 167.75,182.69 167.75,180.84 167.52,180.61 167.06,180.61 166.2,181.47 165.36,181.47 165.26,181.57 165.26,182.01 165.46,182.21 165.89,182.21
+1.35VS_VGA_EN# on TOP: 162.74,181.37 164.27,181.37 164.41,181.22 164.41,180.07 164.24,179.9 164.24,179.01 164.14,178.91 162.9,178.91 162.44,179.36 162.44,181.07
+1VALW on BOTTOM (solid shape): 132.67,73.8 133.43,73.8 133.43,74.36 133.86,74.36 133.86,73.8 137.24,73.8 137.38,73.66 137.38,72.67 138.35,71.7 138.35,71.2 138.37,71.19 138.37,71.1 138.28,71.01 131.63,71.01 131.63,71.03 130.77,71.9 130.77,73.34 131.22,73.8 132.21,73.8 132.21,74.36 132.67,74.36
+1VALW on BOTTOM (solid shape): outline of 122 points within 185.5,127.85 191.83,132.83
+1VALW on TOP: 102.14,51.63 99.37,54.4 71.43,54.4 70.39,55.44 70.39,63.08 71.51,64.2 99.85,64.2 105.85,58.21 124.14,58.21 125.72,59.79 127.25,59.79 127.69,60.24 127.69,62.27 126.55,63.41 126.55,64.05 125.6,65 125.6,65.19 125.66,65.25 126.49,65.25 128.01,63.73 130.87,63.73 131.63,64.49 131.63,70.91 130.49,72.05 130.49,74.92 130.08,75.33 128.3,75.33 123.02,80.61 123.02,84.72 121.75,85.99 121.75,88.37 121.53,88.59 121.53,89.64 121.85,89.96 124.83,89.96 124.9,89.89 124.9,87.22 126.45,85.68 126.45,82.03 131.2,77.28 133.89,77.28 137.39,73.78 137.39,67.25 137.36,67.21 137.36,62.49 126.5,51.63
+1VALW on TOP: 138.11,88.61 140.11,88.61 140.37,88.36 140.37,88.35 140.59,88.13 140.59,86.5 140.14,86.05 138.18,86.05 137.83,86.4 137.83,88.33
+1VALW on VCC: 129.47,71.97 129.47,76.52 133.29,80.34 133.29,86.87 130.74,89.42 130.74,99.89 131.91,101.06 131.91,117.31 139.73,125.13 179.13,125.13 181.92,122.34 185.1,122.34 185.76,123 185.76,125.11 185.73,125.13 185.73,131 186.98,132.25 188.65,132.25 190.05,130.85 190.05,122.59 187.51,120.05 163.61,120.05 161.35,117.79 156.52,117.79 154.88,119.43 154.87,119.42 141.92,119.42 137.6,115.1 137.6,96.9 139.88,94.62 139.88,88 140.53,87.36 140.53,86.46 139.97,85.91 138.88,85.91 137.47,84.49 137.47,71.67 136.84,71.03 130.41,71.03
+1VALW_PCH on BOTTOM (solid shape): 123.18,97.13 123.18,95.01 123.37,94.82 123.37,93.51 123.12,93.26 121.72,93.26 121.66,93.32 121.66,94.15 121.47,94.34 121.47,95.26 121.58,95.37 121.83,95.37 122.02,95.56 122.02,97.08 122.14,97.19 123.12,97.19
+1VALW_PCH on TOP: 138.21,88.86 141,88.86 141.61,89.47 141.61,91.66 140.21,93.05 140.21,94.5 139.2,95.52 131.37,95.52 129.22,97.68 125.94,97.68 125.74,97.88 124.34,97.88 124.29,97.93 122.1,97.93 120.81,96.64 120.81,94.97 121.55,94.23 123.16,94.23 124.01,93.38 125.08,93.38 125.65,92.81 126.26,92.81 128.2,90.87 136.4,90.87 136.81,90.46 137.47,90.46 137.95,89.98 137.95,89.12
+1VALW_PCH on TOP: 105.67,119.55 110.86,119.55 112.13,118.28 112.13,116.24 111.82,115.93 111.12,115.93 110.99,116.05 110.99,116.44 110.4,117.03 105.59,117.03 105.44,117.18 105.44,119.32
+1VALW_PCH on IN1: 99.59,92.88 99.65,92.94 102.66,92.94 103.04,92.56 111.31,92.56 111.82,93.07 115.69,93.07 116.2,92.56 122.74,92.56 123.41,93.23 123.41,95.42 122.79,96.04 118.37,96.04 118,96.41 117.23,96.41 117,96.64 113.21,96.64 113.01,96.43 113.01,96.33 112.53,96.33 111.69,95.49 103.41,95.49 101.71,97.19 100.08,97.19 100.08,98.64 100.13,98.69 100.13,99.25 99.85,99.53 97.57,99.53 96.86,98.82 96.86,97.65 98.08,96.43 98.08,93.33 98.53,92.88
+1VALW_PCH on IN2: 117.02,86.68 115.83,87.87 110.85,87.87 110.47,88.25 108.34,88.25 107.75,88.84 107.75,88.91 106.53,90.13 103.71,90.13 102.98,90.87 101.35,90.87 99.96,89.47 97.59,89.47 96.93,90.13 96.93,93.51 97.5,94.08 99.84,94.08 100.39,94.63 108.36,94.63 109.45,93.54 109.45,93.05 110.04,92.47 111.36,92.47 111.92,93.03 112.6,93.03 113.32,93.74 114.79,93.74 116.47,95.42 123.09,95.42 123.3,95.21 123.3,95.11 123.91,94.5 123.91,92.14 124.92,91.12 124.92,87.19 124.42,86.68
+1VALW_PCH on IN3: 100.97,92.47 100.97,90.46 100.53,90.02 98.42,90.02 98.04,89.64 97.77,89.64 97.39,90.02 97.39,92.09 98.18,92.88 98.18,93.82 98.91,94.55 100.08,94.55 100.21,94.43 100.21,93.23
+1VS_VGA on BOTTOM (solid shape): 184.42,131.42 184.57,131.26 184.78,131.21 184.88,131.17 184.92,131.08 184.92,130.83 184.86,130.82 184.54,130.44 184.86,130.07 184.92,130.06 184.92,129.33 184.86,129.32 184.54,128.94 184.86,128.57 184.92,128.56 184.92,127.88 184.83,127.71 184.83,127.51 184.84,127.47 184.69,127.32 182.78,127.32 180.98,129.12 180.98,129.43 181.54,129.99 181.54,131.23 181.77,131.46 184.4,131.46
+1VS_VGA on TOP: 182.66,130.29 182.66,129.71 184.54,127.83 184.54,126.53 184.31,126.3 180.73,126.3 180.45,126.58 180.45,127.6 179.89,127.6 179.89,128.08 180.45,128.08 180.45,128.79 179.89,128.79 179.89,129.28 180.42,129.28 180.45,129.3 180.45,130.34 180.65,130.55 182.4,130.55
+3V3_AUX on TOP (solid shape): 53.63,29.94 53.63,29.55 53.78,29.4 54.24,29.4 54.62,29.02 54.62,26.53 54.39,26.3 53.98,26.3 53.68,26.61 52.97,26.61 52.91,26.66 52.91,30.06 52.97,30.11 53.45,30.11
+3V_SPI on TOP: 117.86,122.98 120.02,120.82 120.02,118.76 119.94,118.68 119.94,113.17 120.68,112.43 120.68,111.6 120.43,111.34 119.67,111.34 117.81,113.2 117.81,113.45 115.82,115.44 114.98,115.44 113.65,116.78 113.65,119.65 113.24,120.05 112.91,120.05 112.71,119.85 111.44,119.85 111.17,120.12 111.17,121.62 110.67,122.11 110.67,122.39 110.8,122.52 111.64,122.52 112.1,122.98
+3V_VIN on BOTTOM (solid shape): 175.01,9.82 175.01,7.15 174.94,7.08 168.41,7.08 168.31,7.18 168.31,9.79 168.48,9.97 174.86,9.97
+3V_WLAN on BOTTOM (solid shape): 250.25,183.5 250.25,182.59 250.12,182.46 248.34,182.46 248.09,182.72 248.09,184.19 248.32,184.42 249.33,184.42
+3V_WLAN on BOTTOM (solid shape): outline of 103 points within 244.68,160.16 250.25,166.29
+3V_WLAN on TOP: 219.26,35.45 219.13,35.32 217.13,35.32 216.87,35.57 216.87,38.19 217.05,38.37 218.6,38.37 219.26,37.71
+3V_WLAN on IN1: 218.4,37.86 220.53,37.86 224.36,41.7 224.36,63.67 216.59,71.44 216.59,105.68 218.29,107.38 218.29,115.76 225.13,122.59 225.13,134.08 232.9,141.85 236.51,141.85 236.53,141.82 237.52,141.82 240.29,144.59 240.29,159.58 243.72,163.01 247.68,163.01 248.15,163.48 248.15,164.8 248.34,164.99 249.31,164.99 249.51,164.78 249.51,160.9 248.63,160.02 244.9,160.02 243.26,158.38 243.26,143.14 239.15,139.03 235.82,139.03 235.13,138.34 232.87,138.34 227.64,133.11 227.64,120.72 221.38,114.45 221.38,105.74 219.68,104.04 219.68,72.19 227.11,64.76 227.11,40.2 221.44,34.53 218.7,34.53 217.91,35.32 217.91,37.38
+3V_WLAN on IN2: 248.42,184.27 249.89,184.27 250.07,184.09 250.07,163.84 249.69,163.46 248.47,163.46 248.27,163.67 248.27,184.11
+3VALW on TOP (solid shape): 127.93,72.1 127.93,70.21 127.61,69.89 126.55,69.89 126.29,70.14 126.29,72.05 126.52,72.27 127.76,72.27
+3VALW on TOP (solid shape): 247.58,160.57 247.58,158.36 247.14,157.92 246.55,157.92 246.12,158.35 246.12,159.11 244.02,161.2 244.02,162.6 244.15,162.73 245.42,162.73
+3VALW on BOTTOM (solid shape): 148.47,9.59 148.47,4.64 148.16,4.33 146.18,4.33 145.62,4.89 145.62,9.56 145.95,9.9 148.16,9.9
+3VALW on BOTTOM (solid shape): 248.22,160.02 248.22,158.32 247.61,157.71 246.94,157.71 246.54,158.11 246.54,160.12 246.63,160.22 248.02,160.22
+3VALW on TOP: 110.41,63.01 112.96,63.01 113.26,62.7 113.26,62.32 112.83,61.89 110.05,61.89 109.21,62.73 109.21,63.25 109.29,63.33 110.08,63.33
+3VALW on TOP: 198.05,67.6 198.76,66.89 198.76,64.73 200.16,63.34 200.16,62.12 200.11,62.07 198.02,62.07 197.9,62.19 197.9,63.01 197.03,63.87 197.03,66.13 196.3,66.87 195.38,66.87 195.28,66.97 195.28,67.5 195.38,67.6
+3VALW on TOP: 203.76,60.62 202.62,60.62 202.24,60.24 202.24,59.09 202.62,58.71 204.04,58.71 205.95,60.62 207.83,60.62 208.21,61 208.21,62.84 207.89,63.16 205.61,63.16 205.35,62.9 205.35,62.21
+3VALW on TOP: 206.51,13.55 207.88,13.55 208.11,13.32 208.11,11.85 207.93,11.67 206.51,11.67 206.43,11.75 206.43,13.48
+3VALW on TOP: 221.27,22.14 221.54,21.86 221.54,15.66 221.49,15.61 220.12,15.61 219.34,16.4 219.34,16.88 218.98,17.24 218.98,21.68 219.44,22.14
+3VALW on TOP: 184.99,23.79 185.68,23.79 185.83,23.64 185.83,22.87 185.21,22.25 185.21,19.28 184.64,18.71 180.14,18.71 179.89,18.96 179.89,22.19 180.4,22.7 182.53,22.7 182.84,23 182.84,23.74 182.9,23.8 183.18,23.8 183.19,23.81 183.8,23.81 183.93,23.69 184.89,23.69
+3VALW on TOP: 145.73,4.79 145.17,5.35 145.17,16.68 158.35,29.86 170.24,29.86 170.82,29.28 170.82,26.1 149.51,4.79
+3VALW on TOP: 118.47,62.83 118.98,63.34 119.77,63.34 120.03,63.07 120.03,62.79 118.88,61.63 116.36,61.63 116.19,61.81 116.19,62.63 116.39,62.83
+3VALW on TOP: 217.63,35.12 219.34,35.12 219.44,35.02 219.44,32.42 219.13,32.12 217.86,32.12 217.51,32.48 217.51,34.99
+3VALW on BOTTOM: 187.61,27.29 189.54,27.29 189.85,26.99 189.85,15.99 189.41,15.56 186.47,15.56 186.06,15.97 186.06,25.74
+3VALW on IN1: 221.6,21.38 221.24,21.02 219.49,21.02 218.98,21.53 218.98,27.83 217.99,28.82 217.99,33.16 218.32,33.49 220.63,33.49 221.6,32.53
+3VALW on IN2: 238.83,163.39 238.98,163.39 239.23,163.64 243.46,163.64 243.66,163.83 246.01,163.83 246.05,163.79 246.68,163.79 248.38,162.1 248.38,158.23 248.06,157.91 247.15,157.91 246.85,158.21 246.85,159.35 245.05,161.16 239.69,161.16 238.7,162.15 238.7,163.26
+3VALW on IN2: 221.42,24.5 221.42,21.25 221.21,21.05 219.64,21.05 219.35,21.34 219.35,22.96 217.48,24.83 212.38,24.83 211.36,25.85 200.06,25.85 199.12,26.79 199.12,27.95 199.57,28.41 212.63,28.41 213.24,27.8 218.12,27.8
+3VALW on IN2: 188.07,16.02 188.07,14.11 186.8,12.84 182.45,12.84 172.29,23 172.19,23 166.99,28.21 166.99,29.5 167.67,30.19 173.89,30.19
+3VALW on VCC: 156.65,52.39 166.05,61.78 166.05,62.16 198.68,94.8 198.68,101.13 209.48,111.93 209.48,111.95 210.75,113.22 210.75,148.95 212.08,148.95 212.72,149.58 215.96,149.58 216.59,150.22 216.59,154.85 215.26,156.19 210.75,156.19 210.75,157.13 210.73,157.15 210.73,166.79 215.81,171.87 218.52,171.87 225.38,165.01 237.7,165.01 240.09,162.62 240.09,161.31 239.45,160.67 239.45,152.42 238.33,151.3 233.76,151.3 232.23,149.77 226.27,149.77 222.43,145.94 222.43,131.72 221.54,130.83 221.54,116.88 214.94,110.28 214.94,108.6 207.57,101.23 207.57,93.62 206.81,92.86 206.81,63.69 207.32,63.18 207.32,52.98 206.69,52.34 206.69,52.34 206.05,51.7 206.05,50.71 201.73,46.39 201.73,44.11 202.72,43.12 202.72,38.83 203.89,37.66 203.89,36.97 202.75,35.83 202.75,27.2 201.88,26.33 191.68,26.33 189.65,28.36 185.71,28.36 184.33,29.74 184.33,33.67 172.88,45.12 165.05,45.12 164.27,44.34 164.27,33.95 166.81,31.41 169.37,31.41 171,29.78 171,27.34 169.27,25.61 156.88,25.61 156.65,25.85
+3VALW on IN3: 207.32,13.81 207.85,13.27 207.85,12.08 207.63,11.85 193.83,11.85 190.25,15.43 186.34,15.43 186.11,15.66 186.11,16.52 186.21,16.63 191.24,16.63 194.06,13.81
+3VALW_GS on TOP: 198.79,70.73 200.26,70.73 200.51,70.47 200.51,69.33 200.34,69.15 200.34,67.98 201.22,67.1 201.91,67.1 202.04,66.97 202.04,65.42 202.11,65.34 202.11,64.33 201.99,64.2 200.54,64.2 200.03,64.71 199.88,64.71 199.85,64.68 199.17,64.68 199.02,64.84 199.02,69.23 198.74,69.51 198.74,70.68
+3VALW_LAN on TOP: 48.27,119.98 48.19,120.05 48.19,121.34 48.85,122 48.85,123.28 49.18,123.61 50.25,123.61 50.78,124.14 50.78,125.26 51.26,125.74 52.28,125.74 52.63,125.39 52.63,123.51 52.94,123.2 53.8,123.2 54.21,122.8 54.21,120.89 53.96,120.64 53.63,120.64 53.5,120.77 53.5,121.55 53.02,122.04 52.15,122.04 51.92,121.81 51.36,121.81 50.98,122.19 49.66,122.19 48.82,121.35 48.82,120.08 48.72,119.98 48.57,119.98 48.57,121.07 48.44,121.07 48.44,119.98
+3VALW_LAN on IN1: 43.9,121.88 50.76,121.88 51.26,122.39 53.52,122.39 53.8,122.11 53.8,121.07 53.5,120.77 53.5,120.51 52.13,119.14 50.7,119.14 47.28,115.71 47.28,111.55 46.13,110.4 44.96,110.4 44.38,110.99 41.08,110.99 40.52,111.55 40.52,113.04 41.89,114.42 41.89,119.88
+3VALW_P on BOTTOM (solid shape): 159.72,10.83 159.72,4.92 159.24,4.43 155.58,4.43 154.77,5.25 149.66,5.25 149.18,5.73 149.18,9.62 149.43,9.87 154.77,9.87 156.01,11.11 159.44,11.11
+3VALW_PCH on TOP (solid shape): outline of 105 points within 119.84,69.97 125.76,72.63
+3VALW_PCH on BOTTOM (solid shape): 111.94,116.52 111.94,114.78 111.72,114.56 111.72,113.93 111.56,113.78 111.12,113.78 111,113.9 111,114.54 111.12,114.66 111.12,116.56 111.19,116.64 111.83,116.64
+3VALW_PCH on TOP: 128.96,82.13 128.96,81.83 128.76,81.62 127.23,81.62 126.68,82.18 126.68,86.27 127.55,87.15 127.55,88.47 128.4,89.32 128.63,89.32 129.1,88.85 129.1,88.52 128.48,87.9 128.48,86.83 127.56,85.92 127.56,82.62 127.67,82.51 128.58,82.51
+3VALW_PCH on IN3: 102.75,91.18 101.96,90.39 101.1,90.39 101,90.49 101,90.77 101.02,90.79 101.02,93.16 100.34,93.84 100.34,94.38 100.59,94.63 102.37,94.63 102.75,94.25
+3VALW_RTCPRIM on TOP: 100.19,89.27 100.09,89.17 100.09,88.61 100.27,88.43 100.27,84.44 100.73,83.97 101.21,83.97 101.54,84.3 102.1,84.3 102.23,84.18 103.75,84.18 104.01,84.43 104.13,84.43 104.59,83.97 105.9,83.97 106.36,84.43 106.67,84.43 106.8,84.3 106.8,84.29 107.12,83.97 107.55,83.97 107.88,84.3 108.2,84.3 108.36,84.15 108.48,84.15 108.77,84.43 108.77,85.19 108.32,85.64 106.61,85.64 106.03,85.06 101.47,85.06 100.9,85.63 100.9,86.98 100.9,86.98 100.9,87.73 100.9,89.25 100.88,89.27
+3VL on BOTTOM (solid shape): 172.12,3.8 172.12,3.29 171.74,2.91 170.41,2.91 170.11,3.21 170.11,3.84 170.3,4.03 171.89,4.03
+3VL on IN2: 191.74,35.68 191.65,35.63 186.08,35.63 186.07,35.63 184.68,35.63 184.68,35.64 181.76,35.64 179.88,37.52 179.88,44.58 180.42,45.12 181.69,45.12 181.77,45.08 181.79,44.99 182.17,44.46 182.56,44.99 182.58,45.08 182.66,45.12 183.92,45.12 187.72,41.32 193.5,41.32 193.65,41.47 198.18,41.47 199.6,40.04 202.62,40.04 202.88,39.79 202.88,38.59 199.91,35.63 192.56,35.63 192.47,35.68 192.47,35.78 192.1,36.36 191.74,35.78
+3VLX on TOP (solid shape): 162.64,10.35 162.64,7.38 162.54,7.28 161.04,7.28 160.94,7.38 160.94,10.33 161.14,10.53 162.46,10.53
+3VLX on BOTTOM (solid shape): 165.39,10.5 165.39,9.31 165.97,8.73 166.99,8.73 167.11,8.6 167.11,7.74 166.99,7.61 165.89,7.61 165.46,7.18 165.46,5.88 164.01,4.43 160.81,4.43 160.46,4.79 160.46,10.96 160.79,11.29 164.6,11.29
+3VS on TOP (solid shape): 24.95,78.59 24.95,77.89 20.76,73.7 20.76,71.16 20.63,71.03 18.6,71.03 18.47,71.16 18.47,74.31 19.06,74.89 19.06,76.9 20.78,78.63 20.83,78.63 21.01,78.81 24.73,78.81
+3VS on TOP (solid shape): 38.54,89.19 38.54,86.59 38.28,86.34 36.76,86.34 36.32,86.78 36.32,88.24 36,88.56 36,89.64 36.25,89.89 37.84,89.89
+3VS on TOP (solid shape): 130.23,74.92 130.23,73.27 129.93,72.96 128.91,72.96 128.73,73.14 128.73,73.96 128.78,74.05 128.88,74.08 128.93,74.08 129.33,74.08 129.59,74.33 129.33,74.59 128.93,74.59 128.88,74.58 128.78,74.61 128.73,74.71 128.73,74.97 128.85,75.08 128.91,75.12 128.97,75.17 129.98,75.17
+3VS on BOTTOM (solid shape): 120.15,180.48 120.15,179.06 119.94,178.86 118.04,178.86 118.04,180.63 118.12,180.71 119.92,180.71
+3VS on BOTTOM (solid shape): 37.71,89.96 37.71,89.45 36.95,88.69 36.38,88.69 36.06,89 36.06,89.96 36.51,90.4 37.27,90.4
+3VS on BOTTOM (solid shape): 43.62,110.21 43.62,108.82 43.17,108.37 42.28,108.37 42.16,108.5 42.16,110.34 42.22,110.4 43.43,110.4
+3VS on BOTTOM (solid shape): 246.37,160.15 246.37,158.11 245.96,157.71 245.27,157.71 245.2,157.78 245.25,157.83 245.34,158.3 244.9,158.49 244.79,158.51 244.74,158.61 244.74,159.1 244.74,159.11 244.77,159.26 244.74,159.41 244.74,159.42 244.74,159.82 244.74,159.83 244.78,159.97 244.77,160.12 244.76,160.16 244.83,160.23 246.29,160.23
+3VS on BOTTOM (solid shape): 187,127.04 187,123.05 187,123.04 186.99,123.01 186.98,122.98 186.96,122.96 186.93,122.94 186.9,122.93 186.87,122.93 186.84,122.93 186.81,122.94 186.78,122.97 186.73,122.99 186.68,123.01 186.62,123.02 186.57,123.03 186.51,123.02 186.46,123.01 186.41,122.99 186.36,122.97 186.32,122.93 186.28,122.9 186.25,122.85 186.22,122.8 186.2,122.75 186.19,122.7 186.19,122.65 186.19,122.59 186.2,122.54 186.22,122.49 186.25,122.44 186.28,122.4 186.32,122.36 186.36,122.32 186.41,122.3 186.46,122.28 186.51,122.27 186.57,122.26 186.62,122.27 186.68,122.28 186.73,122.3 186.78,122.32 186.81,122.35 186.84,122.36 186.87,122.37 186.9,122.36 186.93,122.35 186.96,122.34 186.98,122.31 186.99,122.28 187,122.25 187,122.24 187,119.8 186.75,119.55 182.78,119.55 182.33,120 182.33,124.2 186.24,124.2 186.24,126.51 185.81,126.51 185.81,124.2 182.33,124.2 182.33,126.05 183.44,127.17 186.87,127.17
+3VS on BOTTOM (solid shape): 114.31,185.56 114.31,184.7 110.09,180.48 110.09,178.6 99.8,168.31 99.8,148.97 99.28,148.44 99.24,148.46 98.8,148.39 98.73,147.95 98.75,147.91 95.37,144.53 94.88,144.53 91.57,141.22 91.14,141.22 90.4,140.48 90.4,140.48 90.4,137.33 89.45,136.37 89.15,136.37 88.91,136.62 87.59,136.62 86.95,135.98 86.95,135.68 87.41,135.22 87.41,134.61 85.12,132.32 85.1,132.32 85.03,132.29 84.96,132.26 84.94,132.25 84.89,132.25 84.73,132.08 84.63,132.05 84.54,132.1 84.16,132.24 83.86,131.96 83.85,131.92 80.55,131.92 80.24,132.22 80.24,133.4 80.4,133.59 80.4,133.84 80.38,133.88 91.67,145.18 92.92,145.18 97.59,149.85 97.59,169.31 107.75,179.47 107.75,182.01 111.49,185.74 114.13,185.74
+3VS on BOTTOM (solid shape): outline of 100 points within 118.17,122.21 121.29,124.55
+3VS on IN2 (solid shape): outline of 6251 points within 180.19,18.15 247.09,159.99
+3VS on TOP: 150.15,93.16 151.92,93.16 152.28,92.8 152.28,90.82 151.95,90.49 150.3,90.49 149.89,90.9 149.89,92.9
+3VS on TOP: 204.73,13.68 206.05,13.68 206.2,13.53 206.2,12.08 206,11.88 204.83,11.88 204.68,12.03 204.68,13.63
+3VS on TOP: 183.95,125.36 185.48,125.36 185.93,124.91 185.93,122.72 185.76,122.54 183.85,122.54 183.44,122.95 183.44,124.86
+3VS on TOP: 194.62,26.23 194.62,27.57 194.77,27.73 195.59,27.73 195.69,27.83 195.69,28.31 195.84,28.46 196.17,28.46 196.4,28.23 196.4,26.1 196.35,26.05 194.8,26.05
+3VS on TOP: 174.02,65.67 175.34,65.67 175.49,65.52 175.49,64.58 175.24,64.33 174.33,64.33 174.15,64.51 174.15,65.55
+3VS on TOP: 238.36,146.85 238.49,146.72 238.49,145.89 237.55,144.95 237.55,143.04 237.42,142.91 235.64,142.91 235.51,143.04 235.51,143.93 235.59,143.93 235.54,143.98 235.54,145.38 235.67,145.51 236.23,145.51 236.23,146.67 236.4,146.85
+3VS on TOP: 44.08,32.78 46.06,32.78 46.79,32.04 46.79,31.76 46.74,31.76 46.44,31.46 45.5,31.46 45.24,31.21 44.56,31.21 43.99,31.78 43.99,32.69
+3VS on TOP: 185.81,20.74 188.78,20.74 189.26,21.22 189.26,22.21 189.62,22.57 190.56,22.57 190.82,22.3 190.82,19 190.66,18.84 186.04,18.84 185.6,19.27 185.6,20.54
+3VS on TOP: 113.7,62.68 115.4,62.68 115.68,62.4 115.68,61.81 115.58,61.71 113.09,61.71 113.06,61.74 113.06,61.91 113.42,62.27 113.42,62.4
+3VS on TOP: 199.45,15.91 199.45,13.63 199.32,13.5 198.18,13.5 198.02,13.65 198.02,15.79 198.29,16.05 199.31,16.05
+3VS on IN1: 198,28.44 198.32,28.12 198.32,17.55 201.99,13.88 205.47,13.88 206.23,13.12 206.23,12.05 206.03,11.85 204.93,11.85 204.67,12.12 200.07,12.12 192.72,19.47 192.72,28.03 193.12,28.44
+3VS on IN1: 28.69,34.65 28.64,34.75 28.55,34.84 28.17,35.22 28.17,35.96 29.75,37.53 30.41,37.53 33.81,34.13 44.56,34.13 45.19,33.49 45.19,31.59 44.63,31.03 32.31,31.03
+3VS on IN2: 18.09,94.63 18.09,104.99 19.32,106.22 37.53,106.22 41.94,110.63 44.81,110.63 45.32,110.12 45.32,108.68 39.96,103.32 31.63,103.32 30.41,102.1 30.41,79.47 27.46,76.52 21.04,76.52 13.26,84.29 13.26,89.8 ; 1 cut-out
+3VS on IN2: 53.19,25.21 53.19,25.94 54.13,26.89 54.13,32.37 53.8,32.7 46.18,32.7 45.29,31.82 44.13,31.82 43.81,32.13 43.81,33.58 44.74,34.51 51.24,34.51 51.26,34.48 51.83,34.48 51.92,34.43 51.92,34.33 52.25,33.77 52.59,34.33 52.59,34.43 52.68,34.48 55.71,34.48 56.43,33.76 56.43,30.51 57.05,29.88 57.05,29.3 56.9,29.15 56.27,29.15 56.04,29.38 55.66,29.38 55.48,29.2 55.48,26.13 54.21,24.86 53.55,24.86 53.19,25.21
+3VS on VCC: 114.36,97.7 114.36,99.18 114.64,99.46 115.53,99.46 116.57,100.5 117.28,100.5 119.08,98.69 125.48,98.69 128.2,101.41 128.2,102.94 129.47,104.21 129.47,123.41 129.19,123.69 110.29,123.69 109.3,124.68 89.13,124.68 83.5,119.04 76.96,119.04 75.4,117.48 75.4,111.96 75.18,111.74 73.07,111.74 73.06,111.75 48.97,111.75 44.59,107.37 44.09,107.37 41.97,109.49 41.97,112.46 49.31,119.8 54.9,119.8 55.92,120.82 61,120.82 62.27,122.09 64.68,122.09 69.89,127.29 71.54,127.29 72.95,128.71 72.95,130.11 73.57,130.72 77.25,130.72 83.09,136.56 84.53,136.56 89.87,131.23 159.08,131.23 160.99,129.33 169.6,129.33 171.7,131.42 180.02,131.42 180.65,130.79 184.59,130.79 185.22,130.15 185.22,128.59 185.2,128.56 185.2,123.18 184.87,122.85 182.17,122.85 179.36,125.67 139.53,125.67 131.37,117.51 131.37,101.23 130.23,100.09 130.23,91.73 129.83,91.33 117.53,91.33 115.88,92.98 115.88,96.18
+3VS on IN3: 23.63,53.48 17.68,59.43 17.68,67.2 19.03,68.54 19.03,73.6 19.28,73.85 20.83,73.85 21.24,73.45 21.24,60.06 26.57,54.73 26.57,54.71 28.53,52.76 28.53,52.74 29.27,52.01 29.27,37.05 30.54,35.78 30.54,34.89 29.98,34.33 27.69,34.33 25.58,36.44 25.58,44.72 24.81,45.49 24.81,49.38 23.63,50.56
+3VS_DDIMUX on TOP (solid shape): 21.7,60.19 21.7,60.03 21.56,59.89 21.13,59.89 21.01,59.78 21.01,58.46 19.18,56.63 18.37,56.63 18.24,56.76 18.24,57.77 18.01,58 18.01,58.61 18.07,58.66 19.13,58.66 20.71,60.24 21.65,60.24
+3VS_DDIMUX on TOP (solid shape): 18.52,70.4 20.17,70.4 20.25,70.32 20.25,68.06 21.57,66.74 22.08,66.74 22.13,66.69 22.13,65.78 22.08,65.72 21.24,65.72 19.55,67.42 19.53,67.61 19.41,67.77 19.41,69 19.15,69.26 19.14,69.26 19.1,69.31 17.99,69.31 17.89,69.41 17.89,70.47 17.91,70.5 18.42,70.5
+3VS_DDIMUX on TOP (solid shape): 30.38,67.22 30.38,65.7 30.18,65.5 29.79,65.5 29.62,65.67 29.19,66.13 28.91,65.57 28.91,65.34 28.82,65.25 27.73,65.25 27.69,65.29 27.69,66.49 29.1,67.9 29.71,67.9
+3VS_DDIMUX on BOTTOM (solid shape): outline of 429 points within 17.86,55.87 31.83,70.86
+3VS_DP on TOP (solid shape): 29.12,86.11 29.12,85.68 29.12,85.63 29.14,85.58 29.14,85.46 30.46,84.14 30.66,84.14 30.77,84.04 30.77,83.48 30.61,83.33 29.34,83.33 29.24,83.43 29.24,84.57 29.12,84.7 29.12,84.87 29.11,84.93 29.09,85 29.09,85.1 28.89,85.31 28.89,86.1 28.96,86.17 29.06,86.17
+3VS_DP on BOTTOM (solid shape): outline of 459 points within 20.66,83.05 36.4,95.65
+3VS_DP on TOP: 30.44,86.91 31.83,86.91 32.82,85.92 35.39,85.92 35.54,86.07 35.67,86.07 35.68,86.08 38.22,86.08 38.44,85.86 38.44,84.46 38.16,84.18 35.52,84.18 35.17,84.52 33.33,84.52 31.48,86.37 30.54,86.37 30.36,86.55 30.36,86.83
+3VS_DVDD on TOP: 201.81,16.55 201.81,15.58 201.66,15.43 201.61,15.43 201.61,13.88 201.22,13.5 200.08,13.5 199.83,13.76 199.83,15.48 199.78,15.53 199.78,16.6 199.85,16.68 201.68,16.68
+3VS_DVDD on IN3: 200.31,17.03 202.09,17.03 203.82,18.76 205.42,18.76 205.49,18.68 205.49,17.72 203.36,15.58 200.08,15.58 199.93,15.74 199.93,16.65
+3VS_LS on TOP: 187.28,23.84 188.3,23.84 188.31,23.83 188.36,23.83 189.16,23.03 189.16,21.76 188.84,21.44 185.74,21.44 185.65,21.53 185.65,22.19 186.04,22.57 186.87,22.57 187.1,22.8 187.1,23.66
+3VS_VDDIO on TOP: 195.89,25.77 197.19,25.77 197.26,25.69 197.26,24.45 197.08,24.27 195.81,24.27 195.69,24.4 195.69,25.57
+3VS_VDDIO on IN3: 195.94,24.02 197.06,24.02 197.16,24.12 197.16,25.01 197.39,25.24 197.9,25.24 199.32,26.66 205.8,26.66 207.73,24.73 208.9,24.73 209.28,25.11 209.28,29.91 208.51,30.67 196.81,30.67 195.66,29.53 195.66,24.3
+3VS_VGA on TOP: 163.63,125.01 164.78,125.01 164.9,124.88 164.9,124.12 165.54,123.48 165.54,121.83 165.16,121.45 163.89,121.45 163.51,121.83 163.51,124.88
+3VS_VGA on BOTTOM: 148.34,145.56 149.87,145.56 150.07,145.35 150.07,144.16 149.9,143.99 149.9,143.77 149.74,143.6 148.37,143.6 148.09,143.88 148.09,145.3
+3VS_VGA on IN2: 162.69,134.58 162.69,130.77 162.85,130.77 163.48,130.14 163.48,125.26 165.21,123.53 165.21,122.93 162.67,120.39 158.1,120.39 155.48,123 155.48,125.77 158.2,128.49 158.2,141.77 157.11,142.86 149.92,142.86 149.89,142.89 149.33,142.89 148.75,143.47 148.75,144.06 149.49,144.79 151.01,144.79 151.75,145.53 153.07,145.53 157.99,150.46 157.99,150.51 159.45,151.97 159.45,154.33 159.98,154.85 159.98,157.32 160.08,157.42 160.61,157.42 160.74,157.29 160.74,154.09 162.64,152.19 162.64,145.76 161.3,144.41 161.42,144.29 161.42,142.97 162.26,142.13 162.26,135.02
+5V_VIN on BOTTOM (solid shape): 183.93,6.57 186.04,6.57 186.16,6.44 186.16,4.21 185.98,4.03 182.66,4.03 182.28,4.41 182.28,5.04 182.15,5.17 178.75,5.17 178.64,5.27 178.64,7.61 178.8,7.76 182.73,7.76
+5VALW on TOP (solid shape): 211.54,11.04 211.54,6.26 211.16,5.88 208.54,5.88 207.91,6.52 207.91,11.04 208.08,11.22 211.36,11.22
+5VALW on TOP (solid shape): 32.06,24.75 34.83,24.75 35.29,24.3 35.29,22.57 35.13,22.42 31.81,22.42 31.22,23 29.93,23 29.62,23.31 28,23.31 27.9,23.41 27.9,24.2 27.92,24.22 27.92,25.21 28.2,25.49 31.32,25.49
+5VALW on TOP (solid shape): 39.48,18.23 39.48,16.8 39.1,16.42 38.54,16.42 38.16,16.04 35.74,16.04 35.64,16.14 35.64,17.9 35.69,17.95 36.63,17.95 36.76,17.82 37.29,17.82 37.88,18.4 39.3,18.4
+5VALW on BOTTOM (solid shape): 190.96,180.41 190.96,178.7 190.79,178.53 189.87,178.53 189.72,178.68 189.72,180.43 189.79,180.51 190.86,180.51
+5VALW on BOTTOM (solid shape): 211.44,11.01 211.44,6.16 211.13,5.86 207.91,5.86 207.7,6.06 207.7,11.01 207.96,11.27 211.18,11.27
+5VALW on BOTTOM (solid shape): 41.64,76.75 41.64,76.16 41.48,76.01 40.72,76.01 40.67,76.06 39.43,76.06 38.82,75.45 38.66,75.45 38.56,75.55 38.56,76.54 38.87,76.85 41.54,76.85
+5VALW on BOTTOM (solid shape): 125.84,104.61 125.84,103.39 126.17,103.06 126.47,103.06 126.63,102.91 126.63,102.61 126.47,102.45 125.69,102.45 125.08,103.06 125.08,104.59 125.15,104.66 125.79,104.66
+5VALW on BOTTOM (solid shape): 146.13,50.36 146.13,48.96 145.98,48.81 144.86,48.81 144.71,48.96 144.71,49.42 144.15,49.98 141.94,49.98 141.89,50.03 141.89,50.18 141.94,50.23 144.18,50.23 144.48,50.54 145.95,50.54
+5VALW on BOTTOM (solid shape): 142.68,86.5 142.91,86.42 143.14,86.5 143.82,86.5 144.07,86.25 144.07,85.41 143.95,85.28 142.09,85.28 141.99,85.38 141.99,86.17 142.32,86.5
+5VALW on TOP: 159.7,73.95 160.58,74.84 162.18,74.84 162.57,74.46 162.57,64.66 168.99,58.23 168.99,42.42 166.69,40.12 161.12,40.12 159.7,41.54
+5VALW on TOP: 185.98,25.47 185.78,25.26 181.08,25.26 180.4,25.95 180.4,30.08 180.9,30.58 183.13,30.58 185.98,27.73
+5VALW on TOP: 243.67,175.54 243.82,175.69 244.74,175.69 245.14,176.1 245.14,180.13 244.61,180.67 242.83,180.67 242.25,181.25 242.25,182.54 242.35,182.64 244.69,182.64 246.94,180.39 246.94,174.17 246.11,173.33 243.82,173.33 243.67,173.48 ; 4 cut-outs
+5VALW on IN2: 246.69,175.05 245.29,175.05 245,175.34 245,176.18 244.63,176.54 243.8,176.54 243.26,177.08 240.09,177.08 237.55,174.54 213.8,174.54 210.88,177.46 189.92,177.46 189.03,178.35 189.03,180.25 189.79,181.01 214.43,181.01 217.46,177.99 234.45,177.99 238.05,181.6 246.21,181.6 246.94,180.86 246.94,175.3
+5VALW on VCC: outline of 107 points within 28.61,5.88 249.61,178.73 ; 1 cut-out
+5VALW_CHGUSB on TOP: 33.31,17.87 33.31,17.06 32.77,16.52 32.77,15.05 34.27,13.55 34.27,9.67 34.13,9.53 31.06,9.53 30.16,10.43 30.16,16.55 31.53,17.92 33.25,17.92
+5VALW_CHGUSB on BOTTOM: 33.2,10.12 32.62,9.54 25.91,9.54 17.74,17.72 17.74,19.72 17.43,20.03 15.42,20.03 13.21,22.24 13.21,24.3 14.28,25.36 16.67,25.36 25.12,16.91 25.12,14.47 26.78,12.82 32.49,12.82 33.2,12.1
+5VALW_P on BOTTOM (solid shape): 199.27,9.79 206.71,9.79 206.97,9.54 206.97,5.55 206.64,5.22 199.5,5.22 198.48,4.21 195.38,4.21 194.93,4.66 194.93,10.76 195.23,11.06 198,11.06
+5VLP on BOTTOM (solid shape): 215.91,132.5 215.91,131.38 215.65,131.13 214.81,131.13 214.43,130.75 213.16,130.75 212.99,130.93 212.99,132.5 213.14,132.65 215.75,132.65
+5VLP on BOTTOM (solid shape): 184.13,9.79 184.13,7.46 184.49,7.1 186.21,7.1 186.24,7.08 186.24,6.8 186.21,6.77 184.05,6.77 182.96,7.86 182.96,9.77 183.06,9.87 184.05,9.87
+5VLX on TOP (solid shape): 194.04,6.47 194.04,3.75 193.94,3.65 192.82,3.65 192.74,3.72 192.74,6.47 192.87,6.59 193.91,6.59
+5VLX on BOTTOM (solid shape): 194.24,10.76 194.24,4.74 193.88,4.38 189.34,4.38 188.3,5.42 187.33,5.42 187.31,5.45 187.31,6.57 187.33,6.59 188.32,6.59 189.67,7.94 189.67,10.45 190.2,10.99 194.01,10.99
+5VS on BOTTOM (solid shape): 17.25,101.72 17.25,100.62 16.64,100.01 12.33,100.01 11.61,100.73 11.61,102.05 11.77,102.2 16.77,102.2
+5VS on BOTTOM (solid shape): 60,127.73 60,124.37 60.56,123.81 60.56,121.76 60.46,121.66 59.21,121.66 58.6,122.26 58.6,127.73 58.68,127.8 59.92,127.8
+5VS on BOTTOM (solid shape): 20.76,67.4 20.76,65.95 20.38,65.57 19.34,65.57 18.27,66.64 18.27,68.01 18.7,68.44 19.72,68.44
+5VS on BOTTOM (solid shape): 98.48,142.48 98.48,141.67 97.29,140.48 97.06,140.48 95.08,142.46 95.08,143.22 94.49,143.8 94.49,143.93 94.95,144.39 96.58,144.39
+5VS on BOTTOM (solid shape): outline of 117 points within 189.93,121.47 199.75,129.2
+5VS on IN2 (solid shape): outline of 1534 points within 175.32,105.02 224.16,129.12
+5VS on TOP: 213.54,11.72 213.87,12.06 213.87,13.25 214,13.37 215.75,13.37 215.93,13.2 215.93,10.68 213.34,8.09 212.53,8.09 211.89,8.73 211.89,11.5 212.12,11.72
+5VS on TOP: 191.73,28.04 190.64,28.04 190.16,28.51 187.36,28.51 187.28,28.44 187.28,28.27 186.05,28.27 185.48,28.84 185.48,28.87 184.33,30.01 184.33,31.15 184.59,31.41 189.79,31.41 192.08,29.12 192.08,28.39
+5VS on TOP: 194.57,19.09 194.27,18.79 191.5,18.79 191.17,19.12 191.17,22.19 191.37,22.39 193.94,22.39 194.57,21.76
+5VS on BOTTOM: 224.88,49.91 225.03,49.77 225.03,48.85 224.74,48.56 224.61,48.56 224.6,48.57 218.6,48.57 218.39,48.77 218.39,50.88 218.47,50.95 219.85,50.95 220.04,50.77 220.04,50.45 220.14,50.36 221.47,50.36 221.65,50.54 221.65,51.12 221.77,51.25 222.66,51.25 222.81,51.09 222.81,50.43 223.34,49.91
+5VS on IN1: 200.13,11.55 206.89,11.55 207.7,12.36 214.43,12.36 214.86,11.93 214.86,10.5 214.94,10.43 214.94,3.85 213.92,2.83 195.76,2.83 184.08,14.52 184.08,26.76 184.03,26.81 184.03,31.23 184.59,31.79 190.86,31.79 192.49,30.16 192.49,19.19
+5VS on IN1: 53.37,122.62 50.6,122.62 46.67,126.56 43.21,126.56 40.3,123.65 40.3,110.11 38.92,108.73 36.91,108.73 32.01,103.82 19.86,103.82 16.14,100.09 11.89,100.09 11.77,100.22 11.77,102.07 12.12,102.43 15.4,102.43 19.11,106.14 31.38,106.14 35.9,110.66 35.9,123.59 40.21,127.9 54.03,127.9 54.08,127.85 60.05,127.85 60.59,127.32 60.59,126.79 59.8,126 55.66,126 54.67,125.01 54.67,123.92
+5VS on IN2: 12.38,76.9 10.12,79.16 10.12,85.89 8.31,87.7 8.31,94.07 11.46,97.22 11.46,101.97 11.56,102.07 13.57,102.07 13.85,101.79 13.85,94.63 12.99,93.77 12.99,80.74 14.46,79.26 17.46,79.26 20.99,75.73 20.99,65.67 20.88,65.57 19.21,65.57 17.33,67.45 17.33,75 17.35,75.02 15.47,76.9
+5VS on IN2: 76.19,130.41 72.88,127.09 62.74,127.09 61.49,125.85 58.58,125.85 58.22,126.2 58.22,127.19 58.24,127.2 58.24,128.02 58.5,128.28 60.74,128.28 62.95,128.59 65.86,129.06 70.82,130.16 75.98,132.77 76.08,132.77 76.12,132.72 76.13,132.66 76.13,132.65 76.29,132.31 76.67,132.28 76.89,132.61 76.71,132.96 76.66,133.05 76.71,133.13 77.32,133.44 78.01,133.88 78.1,133.89 78.16,133.84 78.23,133.72 78.34,133.64 78.76,133.68 78.89,134.08 78.85,134.17 78.79,134.25 78.76,134.33 78.8,134.4 87.18,140.1 92.54,145.12 96.91,145.15 97.34,144.72 97.34,140.5 97.32,140.47 97.29,140.45 97.09,140.39 96.95,140.24 91.24,140.24 90.99,140.91 90.74,140.24 90.32,140.24 82.29,132.21 80.48,130.41 ; 1 cut-out
+5VS on IN2: 206.84,13.68 208.95,13.68 210.32,12.31 211,12.31 211.03,12.33 214.1,12.33 215.22,11.22 215.22,10.07 214.08,8.93 212.58,8.93 210.88,10.63 204.01,10.63 201.96,12.68 194.05,12.68 191.09,15.64 191.09,21.68 191.4,21.99 198.53,21.99
+5VS on VCC: outline of 94 points within 16.57,1.69 230.94,108.88
+5VS on IN3: 211.33,11.55 215.22,11.55 215.42,11.34 215.42,9.39 213.54,7.51 213.54,4.84 214.76,3.62 218.78,3.62 219.87,4.71 222.97,4.71 223.96,5.7 223.96,22.98 219.51,27.42 219.51,47 218.47,48.05 218.47,50.87 218.9,51.3 220.33,51.3 227.54,44.08 227.54,5.35 223.68,1.49 211.94,1.49 210.9,2.53 210.9,11.11
+5VS_CLASSD on TOP: 197.47,19.45 197.16,19.14 195.38,19.14 195.18,19.34 195.18,21.99 195.13,22.04 195.13,23.53 195.38,23.79 196.91,23.79 197.47,23.23
+5VS_CLASSD on BOTTOM: 195,27.12 196.86,27.12 198.3,28.56 204.88,28.56 206,27.45 206,20.21 203.41,17.62 196.42,17.62 194.77,19.27 194.77,26.89
+5VS_CLASSD on IN3: 205.52,20.41 204.83,19.72 204.43,19.72 202.9,18.2 195.18,18.2 194.52,18.86 194.52,22.47 195.1,23.05 200.13,23.05 200.87,23.79 200.87,25.59 201.5,26.23 204.6,26.23 205.52,25.31
+5VS_CMOS on TOP: 84.07,132.12 85.83,132.12 87.71,130.24 87.71,130.11 86.9,129.3 85.15,129.3 83.94,130.51 83.94,131.99
+5VS_CMOS on BOTTOM: 95.15,139.79 95.51,139.79 98.15,137.15 98.15,135.42 97.85,135.12 97.29,135.12 97.03,135.37 97.03,136.16 96.17,137.02 95.61,137.02 95.21,136.62 95.03,136.62 92.89,138.75 92.89,138.98 93.35,139.44 93.81,139.44 94.21,139.03 94.39,139.03
+5VS_CMOS on IN2: 98.41,135.83 98.02,135.45 93.88,135.45 93.73,135.3 90.65,135.3 90.65,135.29 89.01,135.29 84.44,130.72 83.67,130.72 83.17,131.23 83.17,131.5 90.33,138.67 91.17,138.67 91.26,138.62 91.26,138.52 91.6,137.96 91.94,138.52 91.94,138.62 92.02,138.67 96.7,138.67 98.41,136.97
+5VS_HDMI on BOTTOM (solid shape): 17.62,69.33 17.62,68.45 17.96,68.11 17.96,66.46 17.58,66.08 13.53,66.08 13.09,66.52 13.1,66.56 12.56,67.04 12.73,66.33 12.75,66.33 13.01,66.08 12.5,65.57 10.72,65.57 10.5,65.79 10.5,67.12 11.06,67.67 12.17,67.67 12.74,68.24 13.6,68.24 14.1,67.73 15.8,67.73 16.17,68.1 16.17,69.34 16.38,69.55 17.41,69.55
+5VS_HDMI on BOTTOM (solid shape): 16.36,96.36 16.36,94.45 14.92,93 14.92,92.6 14.64,92.32 13.52,92.32 12.71,93.13 10.78,93.13 9.81,92.16 9.61,92.14 9.46,92.02 9.44,91.99 9.42,91.99 8.9,91.48 8,91.48 7.74,91.61 7.45,91.6 7.17,91.61 6.92,91.49 6.9,91.48 6.69,91.48 6.68,91.49 6.51,91.58 6.32,91.61 5.74,91.61 5.39,91.96 5.39,92.37 5.72,92.7 5.82,92.68 5.88,92.68 6.32,92.68 6.39,92.68 6.47,92.7 7.4,92.7 7.41,92.7 7.6,92.67 7.79,92.7 7.8,92.7 8.11,92.93 8.22,93.3 8.22,93.32 9.99,95.09 13.98,95.09 14.56,95.67 14.56,96.36 14.66,96.46 16.26,96.46
+5VS_HDMI on VCC: 14.51,67.73 13.01,69.23 13.01,78.76 12.5,79.27 12.5,82.23 13.14,82.87 13.14,94.55 14.77,96.18 18.11,96.18 19.74,94.55 19.74,89.3 19.49,89.05 19.49,86.42 20,85.91 20,69.51 19.26,69.51 17.48,67.73
+5VS_HDMI on IN3: 6.32,91.61 5.64,91.61 5.52,91.73 5.52,92.5 5.64,92.62 6.15,92.62 6.21,92.68 6.32,92.68 6.49,92.7 6.64,92.77 6.66,92.78 6.94,92.78 7.18,92.68 7.45,92.69 8.06,92.86 8.19,93.48 8.18,93.51 9.48,94.81 14.31,94.81 14.89,94.22 14.89,92.98 13.8,91.89 13.8,91.37 13.8,91.36 13.77,91.23 13.8,91.1 13.8,91.09 13.8,84.22 13.19,83.61 11.23,83.61 10.83,84.01 10.83,89.22 8.44,91.61 7.74,91.61 7.6,91.62 7.3,91.62 7.16,91.61 6.38,91.61
+5VS_LS on TOP: 186.72,28.06 187.23,28.06 187.56,28.39 189.79,28.39 189.9,28.28 189.9,26.89 188.19,25.19 187.31,25.19 187.2,25.29 187.2,26.79 186.57,27.42 186.57,27.9
+5VS_ODD on BOTTOM: 222.18,46.01 225.74,46.01 228.66,48.93 228.66,48.96 230.31,50.61 230.31,56.05 229.16,57.19 227.64,57.19 226.24,55.79 226.24,53.57 224.77,52.1 224.77,50.2 224.96,50.01 225.16,50.01 225.35,49.83 225.35,48.82 224.82,48.3 222.81,48.3 222.18,47.66
+V1.00AP on BOTTOM (solid shape): 131.98,70.78 131.98,70.3 132.01,70.27 137.83,70.27 137.93,70.37 137.93,70.75 137.98,70.8 138.82,70.8 139.07,70.55 139.07,69.41 137.72,68.06 137.72,64.3 137.66,64.18 137.53,64.19 136.94,63.87 137.53,63.55 137.66,63.56 137.72,63.45 137.72,56.3 137.22,55.79 131.5,55.79 131.07,56.22 131.07,59.27 132.39,60.59 132.39,64.38 131.93,64.84 131.93,68.44 131.25,69.13 131.25,70.68 131.4,70.83 131.93,70.83
+VCC_CORE on BOTTOM (solid shape): 131.35,112.77 131.35,111.85 131.55,111.65 132.09,111.65 132.21,111.52 132.21,109.03 131.48,108.29 130.16,108.29 129.95,108.09 129.95,107.56 130.08,107.43 132.01,107.43 132.21,107.23 132.21,106.16 130.9,104.85 126.1,104.85 124.72,106.24 124.72,107.05 122.84,108.93 122.84,112.71 123.22,113.1 131.02,113.1
+VCC_CORE on BOTTOM (solid shape): 91.4,113.48 91.4,109.36 91.24,109.2 89.91,109.2 89.15,108.43 89.15,108.2 89.08,108.13 89.08,106.42 89.2,106.31 89.19,106.28 89.28,105.96 89.59,105.83 89.62,105.83 89.74,105.71 89.74,105.38 89.61,105.24 89.61,104.47 89.54,104.41 89.3,104.41 89.15,104.56 88.97,104.56 88.93,104.58 88.9,104.64 88.93,104.7 89.03,104.79 89.07,104.92 89.07,105.01 88.82,105.26 88.56,105.01 88.56,104.92 88.6,104.79 88.7,104.7 88.73,104.64 88.7,104.58 88.66,104.56 87.84,104.56 87.81,104.58 87.77,104.64 87.81,104.7 87.91,104.79 87.94,104.92 87.94,105.01 87.69,105.26 87.43,105.01 87.43,104.94 87.39,104.88 87.33,104.9 87.19,105.03 87.19,105.19 87.16,105.35 87.07,105.48 87.04,105.51 87.04,106.57 87.05,106.59 87.05,106.65 87.07,106.72 87.07,106.8 87.21,106.94 87.21,109.75 86.35,110.61 86.35,115 86.73,115.38 89.5,115.38
+VCC_CORE on BOTTOM (solid shape): 91.76,90.93 91.76,90.73 91.71,90.62 91.6,90.6 91.17,90.42 91.23,89.96 91.27,89.88 91.25,89.8 91.24,89.49 91.52,89.36 91.62,89.33 91.66,89.22 91.67,89.08 91.76,88.96 91.76,88.65 91.65,88.56 91.58,88.45 91.58,88.43 91.48,88.33 91.45,88.33 91.27,88.24 91.2,88.06 91.17,88.03 91,88.03 90.83,88.15 90.82,88.16 90.69,88.3 90.5,88.32 90.39,88.35 90.34,88.45 90.34,89.01 90.35,89.03 90.11,89.46 89.87,89.03 89.88,89.01 89.88,88.45 89.83,88.35 89.72,88.32 89.49,88.28 89.37,88.08 89.37,88.03 89.17,88.03 89,88.15 88.99,88.16 88.92,88.26 88.81,88.32 88.8,88.33 88.51,88.65 88.51,89.01 88.52,89.03 88.28,89.46 88.04,89.03 88.05,89.01 88.05,88.65 87.9,88.48 87.79,88.44 87.69,88.5 87.53,88.65 87.32,88.69 87.29,88.69 87.17,88.79 87.17,88.8 87.06,88.94 86.89,88.98 86.86,88.98 86.72,89.11 86.73,89.14 86.67,89.35 86.48,89.45 86.42,89.46 86.42,91.03 86.49,91.09 91.59,91.09
+VCC_CORE on BOTTOM (solid shape): outline of 131 points within 84.95,98.56 92.56,102.17
+VCC_CORE on IN2 (solid shape): outline of 9721 points within 79.32,88.05 128.99,114.31
+VCC_CORE on TOP: outline of 103 points within 80.88,88.06 96.57,118.02 ; 1 cut-out
+VCC_CORE on TOP: 103.74,114.29 107.73,114.29 110.14,111.88 110.14,107.46 108.31,105.63 103.18,105.63 102.52,106.29 102.52,108.62 101.56,109.59 101.56,112.1
+VCC_CORE on IN1: 82.12,88.94 80.63,90.44 80.63,92.06 80.83,92.27 82.05,92.27 83.18,93.4 83.18,98.68 83.51,99.01 83.51,105.36 85.85,107.7 85.85,111.23 87.46,112.85 93.12,112.85 95.43,110.53 95.43,105.89 93.47,103.93 93.47,101.55 95.33,99.68 95.33,98.9 95.74,98.49 95.74,93.56 95.51,93.33 94.21,93.33 93.53,92.65 93.53,89.6 92.87,88.94 91.78,88.94 91.42,88.58 91.42,87.92 91.12,87.62 87.64,87.62 87.03,88.23 87.03,88.48 86.57,88.94
+VCC_CORE on VCC: 88.02,88.06 87.92,88.17 87.92,88.66 87.26,89.32 80.3,89.32 80.3,109.11 77.66,111.75 75.94,111.75 75.94,117.32 77.15,118.53 83.75,118.53 89.34,124.12 109.09,124.12 110.04,123.17 128.58,123.17 128.96,122.79 128.96,104.41 127.69,103.14 127.69,101.61 125.3,99.23 119.28,99.23 117.51,101 116.36,101 115.32,99.96 114.43,99.96 113.85,99.38 113.85,98.52 113.8,98.46 97.21,98.46 96.3,99.38 96.3,99.79 95.89,100.19 94.77,100.19 93.2,98.62 93.2,88.58 92.68,88.06
+VCC_CORE on IN3: 130.03,106.28 128.77,105.01 128.4,105.01 127.95,104.56 127.95,104.05 125.18,101.28 118.47,101.28 116.41,103.34 113.34,103.34 112.46,104.22 112.46,104.23 112.21,104.48 103.26,104.48 102.65,103.88 99.8,103.88 99.16,104.52 99.16,106.55 100.41,107.8 103.63,107.8 106.23,110.4 108.9,110.4 110.55,112.05 120.83,112.05 121.34,112.56 128.83,112.56 130.03,111.37
+VCC_CORE on IN3: 80.37,89.22 78.92,90.67 78.92,97.14 79.48,97.7 81.84,97.7 82.15,98.01 84.59,98.01 85.3,98.72 85.3,99.81 85.68,100.19 88.65,100.19 89.41,99.43 91.32,99.43 91.52,99.23 93.25,99.23 94.44,98.03 94.8,98.03 95.48,97.35 95.48,96.33 96.35,95.47 96.35,89.88 95.69,89.22 92.13,89.22 90.96,88.05 88.32,88.05 87.15,89.22
+VCC_DSW3P3 on IN1: 101.12,89.54 99.87,89.54 99.65,89.75 99.65,92.72 99.83,92.89 101.12,92.89
+VCC_DSW3P3 on IN3: 97.21,88.3 97.72,88.81 97.72,89.13 98.35,89.13 98.8,89.57 100.07,89.57 100.2,89.7 100.2,90.02 100.07,90.15 98.93,90.15 98.42,89.64 96.32,89.64 95.81,89.13 95.81,84.18 98.35,81.64 98.35,81 99.43,79.92 101.66,79.92 102.36,79.22 106.1,79.22 106.48,79.61 106.48,79.99 106.29,80.18 103.75,80.18 103.05,80.88 100.77,80.88 97.72,83.92 97.72,84.56 97.21,85.07
+VCC_FAN1 on BOTTOM (solid shape): 60.71,121.02 60.71,121.01 60.69,120.87 60.71,120.74 60.71,120.73 60.71,116.3 60.46,116.04 59.92,116.04 59.72,116.24 59.72,117.59 59.16,118.15 59.16,120.83 59.19,120.89 59.21,120.97 59.54,121.3 60.43,121.3
+VCC_GT on BOTTOM (solid shape): outline of 104 points within 74.5,98.51 84.75,100.2
+VCC_GT on BOTTOM (solid shape): outline of 1738 points within 42.45,72.79 74.45,99.1
+VCC_GT on TOP: 44.01,93.02 46.01,95.02 46.01,95.02 49.97,98.97 57.18,98.97 57.22,98.93 64.34,98.93 64.8,99.39 64.8,102.99 65.21,103.39 66.78,103.39 67.42,104.03 67.42,105.15 67.99,105.72 71.46,105.72 72.11,106.36 80.07,106.36 80.3,106.13 81.83,106.13 82.05,105.97 82.32,106.05 82.36,106.08 82.48,105.96 82.48,104.31 83.11,103.67 83.11,102.4 82.99,102.27 82.99,100.12 81.83,98.95 78.96,98.95 78.95,98.95 78.54,98.95 78.34,98.74 78.34,91.58 78.33,91.57 78.33,90.25 76.69,88.61 75.8,88.61 75.49,88.91 75.49,91.96 75.11,92.34 74.43,92.34 74.17,92.6 71.05,92.6 70.02,91.57 70.02,85.45 68.86,84.28 61.55,84.28 61.54,84.49 61.52,84.64 54.51,77.64 44.66,77.64 44.01,78.29 ; 3 cut-outs
+VCC_GT on IN1: 74.36,98.98 75.48,100.1 79.16,100.1 79.36,99.89 79.36,99.72 79.79,99.28 80.12,99.28 80.89,100.05 82.84,100.05 82.92,99.97 82.92,99.31 82.69,99.08 82.69,93.62 81.8,92.73 66.14,92.73 65.59,93.28 56.42,93.28 50.15,87.01 50.15,77.94 49.46,77.26 42.47,77.26 40.65,79.08 40.65,89.96 49.67,98.98
+VCC_GT on IN2: 43.29,77.15 48.62,77.15 50.73,79.26 50.73,81.7 60.18,91.15 78.8,91.15 79.53,91.89 79.53,99.86 79,100.4 78.97,100.4 78.97,105.02 77.83,106.16 56.9,106.16 52.75,102.01 52.75,99.34 42.09,88.69 42.09,78.35
+VCC_GT on VCC: 40.7,82.64 39.22,84.12 39.22,101.28 49.18,111.24 77.45,111.24 77.45,111.24 80.04,108.65 80.04,89.32 74.58,89.32 74.58,91.38 74.3,91.66 72.73,91.66 72.73,91.84 72.58,91.99 69.68,91.99 68.92,92.75 58.14,92.75 50.86,85.46 50.86,79.44 49.05,77.64 42.32,77.64 40.7,79.26
+VCC_GT on IN3: 78.03,97.7 78.87,98.54 84.38,98.54 84.69,98.85 84.69,99.63 84.51,99.81 83.17,99.81 82.89,100.09 72.83,100.09 71.99,99.25 56.98,99.25 56.85,99.13 53.19,99.13 41.15,87.09 41.15,78.7 42.42,77.43 50.73,77.43 51.72,78.42 51.72,86.37 55.73,90.39 77.25,90.39 78.03,91.18
+VCC_IO on TOP: 81.48,72.43 81.48,78.85 83.51,80.88 83.51,82.14 83.9,82.53 83.9,86.68 84.77,87.54 84.79,87.54 84.79,88.58 84.54,88.84 84.54,89.42 84.64,89.52 85.5,89.52 85.83,89.85 86.82,89.85 86.9,89.78 86.9,89.42 86.82,89.35 86.62,89.35 86.52,89.24 86.52,88.81 86.64,88.69 87.05,88.69 87.75,87.99 90.54,87.99 90.73,88.18 90.76,88.18 90.76,88.66 91.01,88.91 92.46,88.91 92.64,89.09 92.64,89.7 92.49,89.85 92.49,90.21 92.65,90.36 93.05,90.36 93.92,89.49 94.89,89.49 95.01,89.36 95.01,88.85 95.43,88.43 95.43,85.29 96.05,84.68 96.05,72.28 94.67,70.91 83,70.91 ; 1 cut-out
