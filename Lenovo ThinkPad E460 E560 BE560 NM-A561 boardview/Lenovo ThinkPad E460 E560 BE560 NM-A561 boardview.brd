# Allegro board Lenovo ThinkPad E460 E560 BE560 NM-A561 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SYS_RESET#: length 111.1
  TOP w0.114: RC108.2 174.38,131.27 175.84,129.81 175.84,126.42 173.31,123.89 v2(173.31,123.79) 174.12,123.79 v3(174.17,123.74)
  IN1 w0.14: v3(173.13,109.62) 173.13,119.78 174.17,120.82 v3(174.17,123.74) ; v3(112.35,107.63) 113.57,108.85 119.36,108.85 121.63,111.13 121.63,112.57 121.41,112.8 121.41,115.09 121.95,115.64 130.94,115.64 131.92,116.61 135.33,116.61 138.5,113.44 150.3,113.44 151.5,112.24 151.5,112.24 151.66,112.09 151.66,106.73 v3(154.39,104)
  IN3 w0.114: v3(154.39,104) 154.69,103.7 159.75,103.7 164.1,108.05 170.76,108.05 172.32,109.62 v3(173.13,109.62)
  BOTTOM w0.076: UC1.B5 107.71,104.61 107.71,105.02 107.94,105.25 108.06,105.25 108.69,105.88 109.15,105.88 110.42,107.16 111.88,107.16 v3(112.35,107.63)
SYSON: length 116.4
  TOP w0.114: RE52.1 183.89,16.43 183.89,17.12 v4(184.14,17.38) 184.27,17.5 U7.4 185.98,17.5 186.18,17.69 186.18,18.26 185.35,19.09 v1(184.59,19.09) ; v3(145.51,39.93) 145.51,39.6 152.43,32.68 157.03,32.68 157.32,32.97 157.89,32.97 159.24,34.32 168.9,34.32 171.6,37.01 172.93,37.01 174.73,35.22 v1(182.71,35.22) 183.75,36.27 D64.2 186.79,36.27 188.07,37.54 188.92,37.54 190.49,39.12 D62.2
  TOP w0.254: v1(127.5,65.06) 126.24,66.32 R9492.1
  IN1 w0.14: v1(184.59,19.09) 184.02,19.66 184.02,25.44 185.32,26.74 185.32,28.14 184.02,29.44 184.02,33.69 182.71,35 v1(182.71,35.22)
  BOTTOM w0.114: PR312.1 137.55,43.55 138.13,42.97 140.47,42.97 142.35,41.09 144.35,41.09 v3(145.51,39.93)
  BOTTOM w0.254: v1(127.5,65.06) 127.5,63.81 130.16,61.16 130.16,51.47 133.51,48.12 133.51,47.64 133.99,47.16 136.15,47.16 136.48,46.83 136.48,45.94 136,45.46 PR312.1
SYSON_EC: length 42.6
  TOP w0.114: RPE4.5 209.21,59.25 CE14.1 210,58.45 211.7,56.75 212.78,56.75 213.77,55.75 213.77,50.51 212.71,49.45 v1(212.37,49.45) ; UE1.107 191.31,41.63 v1(190.87,41.19) 190.49,40.81 D62.1
  IN3 w0.114: v1(190.87,41.19) 190.87,42.22 v3(193.73,45.07)
  BOTTOM w0.114: v3(193.73,45.07) 195.17,46.52 204.72,46.52 204.92,46.32 207.09,46.32 208.64,47.87 208.64,48.73 209.36,49.45 v1(212.37,49.45)
THRMTRIP#: length 8.5
  BOTTOM w0.076: 72.65,108.93 73.29,108.29 73.29,106.72 73.99,106.01 73.99,105.34 74.21,105.12 74.21,104.86 74.16,104.74 74.16,104.59 74.21,104.4 74.21,104.23 74.13,103.97 UC1.C63
  BOTTOM w0.114: RC54.2 RC53.2 71.28,109.34 71.68,108.93 72.65,108.93
TON_1.35V: length 2.6
  BOTTOM w0.203: PR309.2 136.86,41.11 136.02,40.27 PU301.9
TP_CLK2: length 202
  TOP w0.114: R63.2 v3(33.31,97.14) 33.36,97.2 34.54,97.2 JCP.5 ; v3(160.1,108.6) 161.97,110.47 170.24,110.47 170.55,110.15 171.62,110.15 172.43,110.96 176.36,110.96 177,110.33 182.43,110.33 183.72,111.62 183.72,115.76 188.17,120.21 JTP.6 188.17,122.62 v4(187.97,122.82)
  IN1 w0.14: v3(33.31,97.14) 33.69,97.14 42.94,106.4 45.18,106.4 49.1,110.33 49.1,111.01 52.63,114.54 52.63,117.03 56.27,120.66 56.27,122.52 57.66,123.92 60.43,123.92 63.27,126.75 67.19,126.75 67.81,127.38 70.71,127.38 71.06,127.73 72.43,127.73 73.21,128.5 73.65,128.5 74.1,128.06 75.64,128.06 76.29,128.7 81.63,128.7 82.48,129.55 100.29,129.55 104.72,125.12 104.72,124.03 105.01,123.75 105.01,123.01 108.62,119.39 113.75,119.39 116.85,122.49 126.07,122.49 127.08,123.51 128.05,123.51 128.94,122.62 134.36,122.62 134.91,122.07 152.8,122.07 160.22,114.66 160.22,108.71 v3(160.1,108.6)
TP_DATA2: length 395.5
  TOP w0.114: v3(171.46,111.04) 171.86,111.44 176.56,111.44 176.97,111.04 v4(179.61,111.04) 182.4,111.04 183.17,111.8 JTP.1 ; JCP.4 34.54,96.7 33.95,96.7 33.64,96.38 31.93,96.38 R65.2 31.29,95.75 29.83,95.75 28.28,97.3 v3(28.28,101.31)
  IN1 w0.14: v3(174.17,14.42) 175.77,16.02 175.77,40.71 176.03,40.96 176.03,52.21 177.2,53.38 177.2,56.28 177.6,56.68 177.6,60.54 175.8,62.35 175.8,63.84 163.76,75.88 163.76,92.57 171.46,100.27 v3(171.46,111.04)
  IN3 w0.114: v3(174.17,14.42) 173.96,14.2 152.03,14.2 148.03,10.21 141.05,10.21 136.41,5.56 122.46,5.56 116.72,11.3 35.37,11.3 24.79,21.88 22.05,21.88 15.79,28.14 15.79,37.42 20.5,42.14 20.5,50.45 14.62,56.33 14.62,68.5 17.86,71.74 17.86,85.28 18.89,86.31 18.89,92.41 23.29,96.81 24.69,96.81 28.28,100.4 v3(28.28,101.31)
TP_RESET: length 401.3
  TOP w0.114: v3(33.25,103.77) 33.14,103.89 33.14,105.51 32.95,105.7 30.49,105.7 30.31,105.53 30.31,103.32 30.46,103.16 R64.2 ; v3(170.8,111.01) 171.23,110.58 171.71,110.58 172.33,111.2 176.46,111.2 177.08,110.58 182.3,110.58 183.44,111.72 183.44,119.65 184.17,120.37 JTP.2 184.17,121.74 183.93,121.99 183.52,121.99 182.94,122.57 R59.2 R60.2 v4(180.9,123.03)
  IN1 w0.14: v3(173.74,15.86) 175.37,17.49 175.37,41.29 175.66,41.58 175.66,52.3 176.92,53.56 176.92,56.53 177.27,56.89 177.27,60.42 175.39,62.3 175.39,63.62 163.49,75.52 163.49,92.68 171.13,100.32 171.13,110.68 v3(170.8,111.01)
  IN3 w0.114: v3(33.25,103.77) 33.24,103.77 31.74,102.27 31.74,99.24 30.64,98.13 27.09,98.13 24.95,95.99 23.69,95.99 22.1,94.39 22.1,93.14 21.74,92.78 20.89,92.78 20.32,92.21 20.32,86.59 18.59,84.85 18.59,71.44 17.76,70.61 17.76,68.02 16.52,66.78 16.52,57.33 21.23,52.62 21.23,41.84 16.51,37.12 16.51,28.44 22.35,22.61 25.09,22.61 34.92,12.78 37.99,12.78 38.72,12.05 117.24,12.05 122.86,6.43 136.24,6.43 141.5,11.69 148.49,11.69 152.77,15.97 173.64,15.97 v3(173.74,15.86)
TP_REST: length 334.4
  TOP w0.114: R64.1 R66.1 32.92,101.17 32.92,100.93 v3(33.48,100.37) 33.65,100.2 34.54,100.2 JCP.11 ; v4(154.01,15.48) v3(154.64,15.48) ; v1(176.59,45.89) 176.97,46.27 RC432.2 ; v1(145.54,93.89) 145.73,94.08 145.73,95.05 RC429.1
  IN2 w0.14: v3(154.64,15.48) 150.73,15.48 144.85,9.6 140.43,9.6 136.7,5.87 124.35,5.87 118.82,11.41 48.89,11.41 48.77,11.52 48.77,11.52 33.72,26.57 33.72,30.63 32.93,31.42 32.93,34.49 29.66,37.76 29.66,53.74 27.46,55.93 27.46,65.19 25.36,67.3 25.36,73.14 27.46,75.25 29.24,75.25 29.83,75.84 29.83,77.7 31.34,79.2 31.34,91.92 32.53,93.12 32.53,95.28 34.09,96.84 34.09,99.13 33.48,99.73 v3(33.48,100.37)
  IN3 w0.114: v1(176.59,45.89) 175.95,45.25 156.46,45.25 155.35,46.36 v1(155.35,46.55)
  BOTTOM w0.114: v1(145.54,93.89) 145.72,93.71 145.72,90.66 146.35,90.03 147.38,90.03 147.76,89.65 147.76,89.19 148.01,88.94 148.01,84.99 148.55,84.46 148.55,82.84 147.61,81.9 147.61,77.89 148.67,76.83 148.67,72.4 149.1,71.97 149.1,67.35 154.12,62.33 154.12,60.33 155.53,58.92 155.53,46.99 155.35,46.81 v1(155.35,46.55) 155.53,46.37 155.53,39.73 154.69,38.89 154.69,17.87 155.2,17.36 155.2,16.04 v3(154.64,15.48)
TP_REST_EC: length 16.8
  TOP w0.114: v1(179.44,54.97) 178.81,54.97 178.36,54.52 177.86,54.52 177.29,53.95 177.29,53.32 176.97,53 v2(176.97,52.55) RC432.1 ; UE1.72 187.62,54.07 v1(188.08,54.52)
  IN3 w0.114: v1(188.08,54.52) 187.64,54.08 180.33,54.08 v1(179.44,54.97)
TP_REST_R: length 43.8
  TOP w0.114: RC429.2 144.63,95.53 145.03,95.92 v1(145.28,95.92)
  IN1 w0.14: v1(145.28,95.92) 144.53,96.67 127.6,96.67 124.97,99.3 123.96,99.3 123.82,99.16 120.67,99.16 120.22,98.71 116.98,98.71 115.93,99.76 114.38,99.76 113.02,98.4 111.37,98.4 v3(110.85,97.88)
  BOTTOM w0.076: v3(110.85,97.88) 110.67,97.88 110.24,97.45 110.17,97.45 109.78,97.07 109.15,97.07 109.02,96.94 109.02,96.69 108.71,96.37 108.71,95.99 108.51,95.8 107.75,95.8 107.63,95.67 107.63,95.42 107.73,95.31 UC1.W4
TS_OFF#: length 5.8
  TOP w0.114: R217.2 235.9,146.23 D11.2 D60.2 235.84,148.22 v4(235.97,148.35) 236.48,148.35 236.66,148.17 236.66,147.38 236.94,147.1 JTOUCH.2
UART2_RX: length 32.9
  TOP w0.114: v3(130.03,78.2) 130.41,78.2 131.1,77.51 132.45,77.51 TP941.1
  IN3 w0.114: v3(112.6,91.12) 113.22,91.74 114.09,91.74 114.55,91.29 119.28,91.29 120.81,89.77 120.81,89.47 121.04,89.24 121.04,88.04 121.16,87.91 121.79,87.91 124.81,84.89 124.81,82.07 128.68,78.2 v3(130.03,78.2)
  BOTTOM w0.076: v3(112.6,91.12) 112.1,91.63 111.23,91.63 110.69,92.17 UC1.AD1
UART2_TX: length 31.6
  TOP w0.114: v3(129.34,78.98) 129.98,78.98 130.75,78.21 TP942.1
  IN3 w0.114: v3(129.34,78.98) 128.24,78.98 125.05,82.17 125.05,85.98 122.13,88.9 122.13,89.22 121.63,89.73 121.19,89.73 119.37,91.54 114.67,91.54 114.25,91.97 112.6,91.97 112.2,91.57 112.2,91.33 v3(111.97,91.1)
  BOTTOM w0.076: UC1.AD2 109.18,92.17 109.33,92.02 109.64,91.88 110.77,91.88 111.17,91.48 111.59,91.48 v3(111.97,91.1)
USB2_ID: length 2.4
  TOP w0.114: RC407.2 108.21,89.83 v1(108.21,91.31)
  BOTTOM w0.076: UC1.AG3 108.38,91.14 v1(108.21,91.31)
USB2_VBUSSENSE: length 1.8
  TOP w0.114: RC406.2 107.44,90.46 107.56,90.34 107.56,90.21 v1(107.5,90.15)
  BOTTOM w0.076: v1(107.5,90.15) 107.73,90.38 UC1.AG4
USB3P1_RXN: length 166
  TOP w0.114: L10.1 21.86,41.94 v3(22.84,41.94) 24.44,41.94 24.59,41.78 24.59,41.57 v3(24.36,41.34)
  IN1 w0.076: 105.32,103.41 105.28,103.37 105.28,100.98 105.1,100.8 104.83,100.8 104.74,100.71 v3(104.74,100.56)
  IN1 w0.14: v3(24.36,41.34) 24.54,41.52 24.54,42.05 25.46,42.97 25.46,45.78 24.95,46.29 24.95,53.87 26.06,54.97 28.91,54.97 32.06,58.12 32.06,60.36 31.48,60.95 31.48,62.4 30.74,63.13 30.74,78.35 32.59,80.2 32.59,82.44 34.5,84.34 36.73,84.34 38.03,85.64 38.03,91.12 45.27,98.36 45.27,99.43 53.45,107.61 53.45,109.82 55.63,112 56.47,112 59.13,114.67 59.67,114.67 60.58,115.58 63.68,115.58 64.8,116.7 65.57,116.7 65.96,116.31 75.05,116.31 75.69,116.94 79.5,116.94 80.88,118.33 84.01,118.33 88.63,122.95 95.01,122.95 95.87,122.09 100.04,122.09 101.89,120.25 101.89,116.93 103.31,115.51 103.31,113.07 103.56,112.82 103.56,107.84 105.32,106.08 105.32,103.41
  BOTTOM w0.076: UC1.H8 104.98,100.29 v3(104.74,100.56)
USB3P1_RXN_CON: length 9.9
  TOP w0.114: JUSB1.5 12.71,38.65 12.93,38.88 13.28,38.88 14,39.59 14.68,39.59 v3(15.61,40.52) 17.04,41.95 17.38,41.95 17.49,41.84 D8.5 D8.6 18.97,41.84 19.08,41.95 20.22,41.95 L10.2
USB3P1_RXP: length 166
  TOP w0.114: L10.4 21.85,42.17 v3(24.16,42.17) 24.53,42.17 24.82,41.87 24.82,41.57 v3(25.03,41.37)
  IN1 w0.076: 105.07,103.42 105.12,103.37 105.12,101.05 105.03,100.96 104.85,100.96 104.74,101.07 v3(104.74,101.2)
  IN1 w0.14: v3(25.03,41.37) 24.8,41.59 24.8,41.95 25.71,42.86 25.71,44.02 25.9,44.21 25.9,44.58 25.71,44.77 25.71,45.14 25.9,45.33 25.9,45.7 25.2,46.39 25.2,46.71 25.39,46.9 25.39,47.26 25.2,47.45 25.2,47.82 25.39,48.01 25.39,48.38 25.2,48.57 25.2,48.94 25.39,49.13 25.39,49.5 25.2,49.69 25.2,53.76 26.16,54.72 29.02,54.72 32.31,58.02 32.31,60.47 31.73,61.05 31.73,62.5 30.99,63.24 30.99,78.24 32.85,80.1 32.85,82.33 34.6,84.09 36.84,84.09 38.28,85.54 38.28,91.02 45.52,98.26 45.52,99.33 53.7,107.51 53.7,109.71 55.74,111.75 56.57,111.75 59.24,114.42 59.77,114.42 60.69,115.33 63.79,115.33 64.91,116.45 65.46,116.45 65.86,116.05 75.16,116.05 75.79,116.69 79.6,116.69 80.99,118.07 84.11,118.07 88.74,122.7 94.9,122.7 95.76,121.83 99.94,121.83 101.63,120.14 101.63,116.83 103.05,115.41 103.05,112.97 103.31,112.71 103.31,107.74 105.07,105.97 105.07,103.42
  BOTTOM w0.076: v3(104.74,101.2) 104.98,100.94 UC1.G8
USB3P1_RXP_CON: length 9.9
  TOP w0.114: L10.3 20.25,42.18 19.16,42.18 19,42.34 D8.7 D8.4 17.49,42.34 17.33,42.18 16.95,42.18 v3(16.5,41.73) 14.59,39.82 13.9,39.82 13.19,39.11 13.01,39.11 12.71,39.41 JUSB1.6
USB3P1_TXN: length 164.8
  TOP w0.114: v3(24.82,43.35) 24.62,43.55 24.34,43.55 C124.1
  IN1 w0.14: v3(24.82,43.35) 24.69,43.47 24.25,43.47 23.74,43.98 23.74,46.27 24.12,46.65 24.12,54.4 25.58,55.86 28.63,55.86 30.38,57.61 30.38,62.29 29.85,62.82 29.85,78.7 31.49,80.34 31.49,85.73 33.56,87.8 33.56,91.61 35.92,93.97 39.73,93.97 44.25,98.49 44.25,100.96 52.63,109.34 52.63,110.1 56.31,113.78 57.08,113.78 59.8,116.5 62.54,116.5 63.79,117.74 64.57,117.74 66,119.17 67.75,119.17 69.09,117.82 78.02,117.82 78.48,118.28 79.18,118.28 80,119.1 83.69,119.1 88.35,123.76 96.11,123.76 96.95,122.93 100.35,122.93 102.7,120.58 102.7,117.68 104.51,115.86 104.51,114.57 105.57,113.51 106.36,113.51 106.8,113.07 106.8,112.42 v1(107.02,112.21)
  BOTTOM w0.076: UC1.C13 102.64,103.66 102.75,103.77 102.75,103.88 102.65,103.98 102.44,103.98 102.34,104.08 102.29,104.23 102.29,104.4 102.35,104.59 102.35,104.74 102.29,104.86 102.29,105.27 102.47,105.45 102.47,105.84 102.57,105.94 102.57,106.12 102.47,106.23 102.47,106.34 102.75,106.61 102.87,106.61 103.02,106.77 103.02,106.89 103.16,107.02 103.21,107.02 103.22,107.04
  BOTTOM w0.114: 103.22,107.04 105.62,109.44 105.62,110.56 106.66,111.6 106.66,111.85 v1(107.02,112.21)
USB3P1_TXN_C: length 1.6
  TOP w0.114: C124.2 22.74,43.58 21.9,43.58 L9.1
USB3P1_TXN_CON: length 9.4
  TOP w0.114: JUSB1.8 12.71,44.75 12.86,44.9 13.13,44.9 13.74,44.29 14.94,44.29 v3(15.3,43.93) 15.78,43.45 17.28,43.45 17.39,43.34 D8.2 D8.8 19.07,43.34 19.19,43.45 19.52,43.45 19.69,43.63 20.24,43.63 L9.2
USB3P1_TXP: length 164.8
  TOP w0.114: C121.1 24.34,43.78 24.62,43.78 v3(24.82,43.98)
  IN1 w0.14: v1(106.36,112.23) 106.55,112.42 106.55,112.96 106.25,113.26 105.47,113.26 104.26,114.47 104.26,115.76 103.98,116.04 103.77,116.04 103.48,116.33 103.48,116.54 103.19,116.83 102.98,116.83 102.69,117.12 102.69,117.33 102.44,117.57 102.44,120.47 100.24,122.67 96.84,122.67 96,123.51 88.45,123.51 83.79,118.85 80.11,118.85 79.28,118.02 78.58,118.02 78.13,117.57 68.99,117.57 67.64,118.91 66.1,118.91 64.68,117.49 63.89,117.49 62.65,116.24 59.9,116.24 57.19,113.53 56.42,113.53 52.89,110 52.89,109.23 44.51,100.85 44.51,98.38 39.84,93.72 36.02,93.72 33.81,91.51 33.81,87.69 31.74,85.62 31.74,85.29 31.93,85.1 31.93,84.73 31.74,84.54 31.74,84.17 31.93,83.98 31.93,83.61 31.74,83.42 31.74,83.05 31.93,82.86 31.93,82.49 31.74,82.3 31.74,80.24 30.11,78.6 30.11,62.93 30.64,62.4 30.64,62.27 30.79,62.11 30.79,61.71 30.64,61.56 30.64,61.15 30.79,61 30.79,60.59 30.64,60.44 30.64,60.03 30.79,59.88 30.79,59.47 30.64,59.32 30.64,58.91 30.79,58.76 30.79,58.36 30.64,58.2 30.64,57.5 28.74,55.6 25.69,55.6 24.38,54.29 24.38,46.54 24,46.16 24,44.09 24.36,43.73 24.57,43.73 v3(24.82,43.98)
  BOTTOM w0.076: 103.06,107.2 103.04,107.19 103.04,107.14 102.31,106.4 102.31,105.51 102.12,105.33 102.12,104.83 102.16,104.73 102.16,104.54 102.12,104.45 102.12,104.2 102.26,103.72 102.26,103.61 102.34,103.34 UC1.D13
  BOTTOM w0.114: v1(106.36,112.23) 106.43,112.16 106.43,111.69 105.39,110.65 105.39,109.53 103.06,107.2
USB3P1_TXP_C: length 1.6
  TOP w0.114: C121.2 22.79,43.8 21.92,43.8 L9.4
USB3P1_TXP_CON: length 9.4
  TOP w0.114: JUSB1.9 12.71,45.29 12.88,45.12 13.23,45.12 13.84,44.52 15.04,44.52 15.87,43.68 v3(16.64,43.68) 17.25,43.68 17.41,43.84 D8.1 D8.9 19.02,43.84 19.21,43.65 19.44,43.65 19.61,43.82 20.3,43.82 L9.3
USB3P2_RXN: length 207.4
  TOP w0.114: L18.1 24.35,14.48 v3(25,14.48) 26.41,14.48 26.59,14.3 26.59,14 v3(26.41,13.82)
  IN1 w0.076: v3(105.65,99.93) 105.89,100.16 106.09,100.16 106.33,100.4 106.33,100.76 106.19,100.9 106.19,103.27 106.25,103.33
  IN1 w0.14: v3(26.41,13.82) 26.6,14.01 26.6,14.24 27,14.64 28.2,14.64 28.84,15.28 28.84,22.85 21.6,30.08 21.6,34 20.22,35.37 20.22,45.2 20.48,45.46 20.48,55.62 21.75,56.89 21.75,65.29 22.36,65.9 22.36,74.01 28.17,79.83 28.17,83.53 31.93,87.29 31.93,91.53 36.15,95.75 37.78,95.75 51.39,109.36 51.39,109.97 56.8,115.38 57.56,115.38 59.67,117.49 62.26,117.49 64.95,120.18 67.83,120.18 69.4,118.61 77.65,118.61 78.92,119.88 83.32,119.88 84.41,120.97 84.41,121.38 87.58,124.55 92.41,124.55 92.92,125.06 97.29,125.06 98.64,123.71 101.53,123.71 103.82,121.43 103.82,118.2 106.74,115.28 107.11,114.91 107.69,114.91 108.39,114.21 108.39,111.44 107.48,110.53 105.98,110.53 105.46,110.01 105.46,107.92 106.25,107.13 106.25,103.33
  BOTTOM w0.076: UC1.J6 105.89,99.64 v3(105.65,99.93)
USB3P2_RXN_CON: length 12.7
  TOP w0.114: JUSB2.5 12.71,16.13 12.88,16.3 13.36,16.3 13.84,16.78 15.04,16.78 15.76,16.06 17.51,14.31 v3(17.96,14.31) 18.42,14.31 18.88,14.77 19.16,14.77 19.32,14.61 D16.5 D16.6 21.14,14.61 21.27,14.74 21.4,14.74 21.76,14.39 22.76,14.39 L18.2
USB3P2_RXP: length 207.4
  TOP w0.114: L18.4 24.3,14.7 26.51,14.7 v3(26.66,14.55) 26.82,14.39 26.82,14.05 v3(27.05,13.82)
  IN1 w0.076: 105.99,103.33 105.99,103.32 106.03,103.28 106.03,100.83 106.17,100.7 106.17,100.47 106.02,100.32 105.89,100.32 v3(105.65,100.56)
  IN1 w0.14: v3(27.05,13.82) 26.85,14.02 26.85,14.14 27.11,14.39 28.31,14.39 29.09,15.17 29.09,22.95 21.85,30.19 21.85,34.1 20.48,35.47 20.48,45.1 20.73,45.35 20.73,46.03 20.88,46.19 20.88,46.59 20.73,46.74 20.73,47.15 20.88,47.3 20.88,47.71 20.73,47.86 20.73,48.27 20.88,48.42 20.88,48.83 20.73,48.98 20.73,49.39 20.88,49.54 20.88,49.94 20.73,50.1 20.73,55.51 22,56.78 22,65.19 22.61,65.8 22.61,73.9 28.43,79.72 28.43,83.42 32.19,87.18 32.19,91.43 36.26,95.49 37.88,95.49 51.64,109.26 51.64,109.87 56.9,115.13 57.66,115.13 59.77,117.24 62.36,117.24 65.06,119.93 67.72,119.93 69.3,118.35 77.76,118.35 79.03,119.62 83.42,119.62 84.66,120.86 84.66,121.27 87.69,124.3 92.51,124.3 93.02,124.8 97.19,124.8 98.53,123.46 101.42,123.46 103.56,121.32 103.56,118.1 105.32,116.35 105.32,116.14 105.61,115.85 105.81,115.85 107,114.66 107.58,114.66 108.13,114.11 108.13,111.55 107.37,110.78 105.87,110.78 105.21,110.12 105.21,109.11 105.13,109.04 105.06,108.96 105.06,108.55 105.13,108.47 105.21,108.4 105.21,107.82 105.99,107.03 105.99,103.33
  BOTTOM w0.076: v3(105.65,100.56) 105.89,100.29 UC1.H6
USB3P2_RXP_CON: length 12.7
  TOP w0.114: L18.3 22.64,14.62 21.85,14.62 21.5,14.97 21.27,14.97 21.14,15.11 D16.7 D16.4 19.34,15.11 19.23,15 18.78,15 18.32,14.54 17.6,14.54 17.49,14.65 17.49,14.65 v3(15.92,16.22) 15.13,17.01 13.75,17.01 13.27,16.52 12.93,16.52 12.71,16.74 JUSB2.6
USB3P2_TXN: length 203.9
  TOP w0.114: C8530.1 26.73,16.22 27.54,16.22 27.74,16.02 27.74,15.54 v3(27.62,15.42)
  IN1 w0.14: v3(27.62,15.42) 27.82,15.62 27.82,22.44 19.84,30.41 19.84,33.87 18.65,35.06 18.65,47.54 19.11,48 19.11,55.42 20.94,57.24 20.94,65.78 21.57,66.41 21.57,82.87 24.69,85.99 29.11,85.99 31.04,87.92 31.04,91.78 35.79,96.53 37.22,96.53 50.53,109.84 50.53,110.33 56.61,116.41 57.34,116.41 60.42,119.48 63.11,119.48 65,121.38 66.28,121.38 69.08,124.18 73.46,124.18 73.92,124.64 76.22,124.64 77.12,123.74 77.2,123.74 79.13,123.74 80.77,125.39 92.08,125.39 92.56,125.87 97.6,125.87 98.97,124.5 101.94,124.5 105.33,121.11 105.33,118.67 109.38,114.62 109.38,110.96 107.88,109.47 106.87,109.47 v3(106.66,109.26)
  BOTTOM w0.076: 103.56,106.67 103.55,106.66 103.5,106.66 103.03,106.19 103.03,105.51 102.82,105.3 102.82,104.58 UC1.B13
  BOTTOM w0.114: 103.56,106.67 106.15,109.26 106.15,109.35 106.27,109.46 106.46,109.46 v3(106.66,109.26)
USB3P2_TXN_C: length 1.8
  TOP w0.114: L19.1 24.19,16.4 25.13,16.4 C8530.2
USB3P2_TXN_CON: length 14.6
  TOP w0.114: L19.2 22.58,16.45 21.82,16.45 21.7,16.32 21.29,16.32 21.08,16.11 D16.8 D16.2 v3(18.57,16.11) 18.41,16.11 18.25,16.26 18.13,16.26 15.37,19.02 15.37,20.71 14.55,21.53 14.05,21.53 13.34,22.24 12.91,22.24 12.71,22.04 JUSB2.8
USB3P2_TXP: length 203.9
  TOP w0.114: C8529.1 26.47,16.7 26.73,16.45 27.63,16.45 27.97,16.11 27.97,15.69 v1(28.25,15.42)
  IN1 w0.14: v1(28.25,15.42) 28.07,15.59 28.07,22.54 20.1,30.52 20.1,33.97 18.9,35.17 18.9,47.44 19.36,47.89 19.36,55.31 21.19,57.14 21.19,65.67 21.82,66.3 21.82,82.76 24.8,85.74 29.22,85.74 31.3,87.82 31.3,91.68 35.9,96.28 37.32,96.28 50.78,109.74 50.78,110.23 56.71,116.16 57.45,116.16 60.52,119.23 63.22,119.23 65.11,121.12 66.39,121.12 69.19,123.92 73.56,123.92 74.03,124.39 76.12,124.39 77.01,123.49 77.13,123.49 79.23,123.49 80.88,125.13 92.18,125.13 92.67,125.62 97.49,125.62 98.86,124.25 101.83,124.25 105.07,121.01 105.07,118.57 105.8,117.84 105.8,117.74 105.8,117.64 106.09,117.35 106.19,117.35 106.2,117.35 106.3,117.35 106.59,117.05 106.59,116.95 106.59,116.95 106.59,116.85 106.89,116.55 106.99,116.55 106.99,116.55 107.09,116.55 107.39,116.25 107.39,116.15 107.39,116.05 107.68,115.75 107.79,115.75 107.89,115.75 108.18,115.46 108.18,115.36 108.18,115.36 108.18,115.26 108.48,114.96 108.58,114.96 108.58,114.96 108.68,114.96 109.12,114.52 109.12,114.18 108.97,114.02 108.97,113.6 109.12,113.45 109.12,113.03 108.97,112.88 108.97,112.46 109.12,112.31 109.12,111.89 108.97,111.74 108.97,111.32 109.12,111.17 109.12,111.07 108.38,110.32 108.18,110.32 107.88,110.02 107.88,109.83 107.78,109.72 106.89,109.72 v3(106.69,109.92)
  BOTTOM w0.076: 103.4,106.83 103.39,106.82 103.39,106.77 102.87,106.26 102.87,105.58 102.56,105.27 UC1.A13
  BOTTOM w0.114: v3(106.69,109.92) 106.46,109.69 106.17,109.69 105.92,109.44 105.92,109.35 103.4,106.83
USB3P2_TXP_C: length 1.7
  TOP w0.114: L19.4 24.25,16.63 25.25,16.63 C8529.2
USB3P2_TXP_CON: length 14.6
  TOP w0.114: JUSB2.9 12.71,22.72 12.71,22.66 12.9,22.47 13.44,22.47 14.15,21.76 14.65,21.76 15.6,20.8 15.6,19.11 v3(17.17,17.54) 18.22,16.49 18.39,16.49 18.5,16.61 D16.1 D16.9 21.08,16.61 21.13,16.55 21.6,16.55 21.73,16.68 22.62,16.68 L19.3
USB3P3_RXN: length 162.1
  TOP w0.114: R169.1 232.31,143.14 232.31,142.69 232.04,142.41 232.04,141.59 231.78,141.34 231.78,141.17 231.54,140.92 231.36,140.92 231.12,140.68 231.12,140.5 230.88,140.26 230.7,140.26 224.67,134.23 214.83,134.23 v3(212.41,131.81) 204.91,124.3 204.91,119.01 192.49,106.59 173.92,106.59 170.97,103.65 165.98,103.65 165.87,103.53 165.87,103.22 v3(166.15,102.94)
  IN3 w0.076: 107.28,99.48 107.26,99.47 106.71,99.47 106.33,99.09 104.08,99.09 103.44,99.73 103.44,100.1 103.5,100.16 103.59,100.16 v3(103.82,99.93)
  IN3 w0.114: v3(166.15,102.94) 165.85,103.24 165.85,103.48 165.61,103.72 164.81,103.72 164.09,102.99 164.09,101.72 157.25,94.88 152.46,94.88 151.42,93.84 147.45,93.84 146.28,92.67 131.02,92.67 130.16,93.54 126.57,93.54 125.41,94.71 125.41,96.03 123.97,97.47 123.48,97.47 122.15,98.8 118.24,98.8 117.51,99.53 116.39,99.53 115.88,100.04 109.29,100.04 109.2,99.96 107.98,99.96 107.51,99.48 107.28,99.48
  BOTTOM w0.076: v3(103.82,99.93) 104.11,99.64 UC1.J10
USB3P3_RXN_COAX_CON: length 12.6
  TOP w0.114: v3(236.15,150.69) 235.74,150.28 235.74,150 234.73,148.99 232.46,148.99 231.68,148.21 v3(231.68,147.64) 231.68,145.63 232.03,145.28 232.03,144.39 R169.2
  BOTTOM w0.114: v3(236.15,150.69) 235.9,150.43 235.9,149.97 236.45,149.42 236.64,149.42 JU3LC.14
USB3P3_RXP: length 162.1
  TOP w0.114: R170.1 231.51,143.11 231.51,142.75 231.81,142.46 231.81,141.69 224.57,134.46 214.74,134.46 v3(214.03,133.75) 204.68,124.4 204.68,119.11 192.39,106.82 173.83,106.82 170.88,103.88 165.89,103.88 165.64,103.63 165.64,103.22 v3(165.36,102.94)
  IN3 w0.076: 107.28,99.28 107.26,99.3 106.78,99.3 106.4,98.92 104.01,98.92 103.28,99.66 103.28,100.17 103.43,100.33 103.59,100.33 v3(103.82,100.56)
  IN3 w0.114: v3(165.36,102.94) 165.65,103.24 165.65,103.39 165.53,103.51 164.9,103.51 164.29,102.91 164.29,101.64 157.33,94.68 152.54,94.68 151.5,93.64 147.54,93.64 146.37,92.47 130.93,92.47 130.07,93.33 126.49,93.33 125.2,94.62 125.2,95.95 123.88,97.27 123.39,97.27 122.07,98.59 118.16,98.59 117.42,99.33 116.3,99.33 115.8,99.84 109.37,99.84 109.29,99.76 108.07,99.76 107.59,99.28 107.28,99.28
  BOTTOM w0.076: v3(103.82,100.56) 104.09,100.29 UC1.H10
USB3P3_RXP_COAX_CON: length 12.6
  TOP w0.114: R170.2 231.8,144.43 231.8,145.19 231.45,145.54 v3(231.45,146.19) 231.45,148.3 232.37,149.21 234.63,149.21 235.51,150.09 v3(235.51,150.69)
  BOTTOM w0.114: JU3LC.13 236.28,149.08 236.28,149.27 235.67,149.88 235.67,150.53 v3(235.51,150.69)
USB3P3_TXN: length 159.5
  TOP w0.114: v3(218.77,136.18) 218.98,135.98 218.98,135.51 219.34,135.14 224.54,135.14 v3(227.21,137.81) 229.11,139.71 229.11,142.97 229.39,143.25 229.39,143.52 R176.1
  IN3 w0.114: v3(218.77,136.18) 219,135.95 219,135.4 200.23,116.63 197.26,116.63 196.04,115.41 196.04,114.53 195.68,114.16 184.38,114.16 183.17,115.38 178.95,115.38 178.34,115.99 170.84,115.99 168.62,113.77 168.61,113.77 168.36,113.51 162.43,113.51 160.51,111.6 154.95,111.6 151.4,115.15 141.36,115.15 140.95,114.75 131.3,114.75 129.7,116.35 120.66,116.35 120.02,115.71 108.41,115.71 107.74,115.05 105.03,115.05 104.07,114.09 104.07,113.22 v3(103.94,113.1)
  BOTTOM w0.076: UC1.B15 101.02,104.5 100.92,104.5 100.74,104.68 100.74,107.36 101.06,107.67 101.06,107.72 101.07,107.74
  BOTTOM w0.114: 101.07,107.74 103.28,109.95 103.28,112 104.07,112.79 104.07,112.97 v3(103.94,113.1)
USB3P3_TXN_COAX_CON: length 13.7
  TOP w0.114: R176.2 229.39,144.74 229.39,144.97 229.11,145.26 229.11,146.74 231.63,149.26 232.09,149.72 v3(233.69,149.72) 234.17,149.72 234.52,150.08 234.52,150.46 234.74,150.68 v3(234.86,150.68)
  BOTTOM w0.114: v3(234.86,150.68) 234.55,150.37 234.55,149.2 235.35,148.4 235.54,148.4 JU3LC.11
USB3P3_TXP: length 159.5
  TOP w0.114: R175.1 228.59,143.61 228.59,143.23 228.89,142.94 228.89,142.65 228.76,142.52 228.76,142.18 228.89,142.05 228.89,141.71 228.76,141.58 228.76,141.24 228.89,141.11 228.89,140.77 228.77,140.65 228.77,140.31 228.89,140.2 228.89,139.81 v3(228.71,139.63) 224.45,135.37 219.44,135.37 219.21,135.6 219.21,136.06 219.34,136.18 v3(219.57,136.18)
  IN3 w0.114: v3(104.58,113.1) 104.27,113.4 104.27,114.01 105.11,114.85 107.83,114.85 108.49,115.51 120.11,115.51 120.74,116.14 129.61,116.14 131.21,114.54 141.04,114.54 141.44,114.95 151.31,114.95 154.87,111.39 160.59,111.39 162.51,113.31 168.44,113.31 168.7,113.57 168.7,113.57 170.92,115.79 178.26,115.79 178.86,115.18 183.08,115.18 184.3,113.96 195.76,113.96 196.25,114.44 196.25,115.32 197.35,116.42 200.31,116.42 219.21,135.32 219.21,136.06 219.34,136.18 v3(219.57,136.18)
  BOTTOM w0.076: UC1.A15 101.21,104.74 101.12,104.66 100.99,104.66 100.9,104.75 100.9,107.29 101.17,107.56 101.22,107.56 101.23,107.57
  BOTTOM w0.114: v3(104.58,113.1) 104.3,112.81 104.3,112.69 103.51,111.91 103.51,109.85 101.23,107.57
USB3P3_TXP_COAX_CON: length 13.7
  TOP w0.114: v3(234.07,150.68) 234.3,150.45 234.3,150.17 234.07,149.95 231.99,149.95 v3(231.47,149.43) 228.88,146.84 228.88,145.17 228.59,144.88 228.59,144.65 R175.2
  BOTTOM w0.114: JU3LC.10 235.18,148.05 235.18,148.24 234.32,149.1 234.32,150.42 v3(234.07,150.68)
USB3P4_RXN: length 201.2
  IN3 w0.076: v3(103.82,102.47) 103.82,102.34 104,102.16 104.2,102.16 104.37,101.99 104.37,99.77 104.64,99.51 105.88,99.51 106.79,100.42 107.57,100.42 107.59,100.44 107.6,100.44
  IN3 w0.114: 107.6,100.44 107.96,100.44 109.22,101.69 113.47,101.69 114.51,100.65 116.46,100.65 116.61,100.8 117.41,100.8 118.68,99.53 125.13,99.53 126.12,98.54 126.12,94.99 126.85,94.25 130.49,94.25 131.35,93.38 143.86,93.38 144.53,94.05 144.53,94.81 144.94,95.21 151.75,95.21 152.15,95.62 157,95.62 163.3,101.93 163.3,103.39 164.39,104.48 169.73,104.48 172.6,107.35 215.5,107.35 217.53,109.39 217.53,126.97 223.04,132.48 223.48,132.48 230.31,139.31 233.58,139.31 235.9,141.62 235.9,142.86 237.04,144.01 237.04,144.82 244.85,152.63 244.85,152.81 245.09,153.05 245.27,153.05 245.51,153.29 245.51,153.73 245.4,153.85 245.4,154.19 245.51,154.31 245.51,154.65 245.4,154.77 245.4,155.11 245.51,155.23 245.51,155.57 245.4,155.69 245.4,156.03 245.51,156.15 245.51,156.77 245.4,156.88 245.24,156.88 245,157.12 245,157.29 244.81,157.48 244.47,157.48 244.33,157.34 v3(244.33,157.11)
  BOTTOM w0.076: v3(103.82,102.47) 104.05,102.24 UC1.E10
  BOTTOM w0.114: L7.4 239.63,155.4 239.63,155.64 v3(240.94,156.95) 241.38,157.39 244.2,157.39 244.33,157.26 v3(244.33,157.11)
USB3P4_RXN_COAX_CON: length 5.1
  BOTTOM w0.114: R172.2 238.41,154.06 238.05,153.71 237.56,153.71 237.44,153.6 237.44,153.43 237.65,153.23 237.89,153.23 v3(238.01,153.11) 238.11,153 238.11,152.76 238.37,152.51 238.37,151.53 238.52,151.38 238.92,151.38 JU3LC.20
USB3P4_RXP: length 201.2
  IN3 w0.076: v3(103.82,101.83) 103.99,102 104.13,102 104.2,101.92 104.2,99.7 104.57,99.34 105.95,99.34 106.86,100.25 107.57,100.25 107.6,100.23
  IN3 w0.114: 107.6,100.23 108.05,100.23 109.3,101.49 113.38,101.49 114.42,100.45 116.54,100.45 116.69,100.6 117.33,100.6 118.6,99.33 125.04,99.33 125.91,98.46 125.91,94.9 126.77,94.05 130.4,94.05 131.27,93.18 143.95,93.18 144.74,93.97 144.74,94.72 145.02,95.01 151.83,95.01 152.24,95.42 157.08,95.42 163.51,101.84 163.51,103.31 164.48,104.28 169.81,104.28 172.68,107.15 215.58,107.15 217.73,109.3 217.73,126.89 223.12,132.27 223.56,132.27 230.39,139.1 233.67,139.1 236.1,141.54 236.1,142.78 237.24,143.92 237.24,144.74 245.72,153.21 245.72,156.85 245.48,157.09 245.48,157.1 244.89,157.68 244.55,157.68 v3(244.33,157.9)
  BOTTOM w0.076: v3(103.82,101.83) 104.06,101.59 UC1.F10
  BOTTOM w0.114: L7.1 239.2,155.82 239.48,155.82 v3(239.76,156.09) 241.29,157.62 244.05,157.62 v3(244.33,157.9)
USB3P4_RXP_COAX_CON: length 5.2
  BOTTOM w0.114: JU3LC.19 238.14,151.46 238.14,152.38 237.2,153.32 237.2,153.77 237.47,154.04 237.47,154.26 237.87,154.66 R171.2
USB3P4_TXN: length 183.1
  TOP w0.114: v3(235.82,155.18) 235.99,155.18 236.38,154.79 236.38,154.55 236.25,154.42 235.34,154.42 235,154.75 235,154.93 234.76,155.17 234.58,155.17 234.34,155.42 234.34,155.59 234.1,155.84 234.01,155.84 233.92,155.84 233.61,156.15 233.61,156.24 233.61,156.24 233.61,156.33 233.37,156.57 233.19,156.57 232.75,157.01 v3(232.37,157.39) 232.22,157.53 232.22,157.71 232.34,157.83 232.34,158.17 232.21,158.3 232.21,158.84 232.73,159.36 233.08,159.36 233.29,159.16 233.29,159.05 233.55,158.79 233.61,158.79 R174.1
  IN3 w0.114: v3(104.02,111.55) 104.25,111.77 104.25,112.02 105.73,113.5 107.87,113.5 109.32,114.95 120.28,114.95 120.96,115.64 129.22,115.64 130.84,114.01 141.66,114.01 142.09,114.44 150.92,114.44 154.47,110.89 160.88,110.89 162.81,112.82 168.68,112.82 171.14,115.28 177.93,115.28 179.15,114.06 183.25,114.06 183.96,113.35 196.09,113.35 196.81,114.07 196.81,114.97 197.75,115.91 201.39,115.91 203.54,118.06 203.54,118.94 219.21,134.61 222.69,134.61 237.67,149.6 237.67,152.76 236.12,154.31 236.12,154.88 v3(235.82,155.18)
  BOTTOM w0.076: 102.2,108.05 102.19,108.04 102.19,107.99 102.04,107.84 102.04,107.61 101.88,107.45 101.76,107.45 101.6,107.28 101.6,107.16 101.38,106.95 101.38,106.72 101.29,106.63 101.29,106.4 101.38,106.32 101.38,106.09 101.29,106.01 101.29,105.78 101.38,105.7 101.38,105.33 101.49,105.22 101.5,105.15 101.5,104.97 101.49,104.94 101.42,104.71 101.42,104.71 101.42,104.6 101.47,104.42 101.47,104.25 101.46,104.18 101.45,104.15 101.28,104.03 101.12,104.03 101,103.9 101,103.74 101.07,103.66 UC1.C15
  BOTTOM w0.114: v3(104.02,111.55) 104.25,111.32 104.25,111 104.13,110.89 104.13,110.54 104.25,110.43 104.25,110.1 102.2,108.05
USB3P4_TXN_COAX_CON: length 15.2
  TOP w0.114: L8.3 235.04,158.88 235.41,159.25 235.7,159.25 235.83,159.12 236.16,159.12 236.28,159.25 236.49,159.25 v3(236.78,158.96) 237.05,158.69 237.05,158.5 237.28,158.27 237.46,158.27 237.67,158.06 237.67,157.86 237.55,157.73 237.55,157.39 237.67,157.26 237.67,156.92 237.55,156.79 237.55,156.45 237.67,156.32 237.67,155.98 237.55,155.85 237.55,155.51 237.67,155.38 237.67,154.41 235.86,152.6 235.7,152.6 235.56,152.74 v3(235.56,153)
  BOTTOM w0.114: v3(235.56,153) 235.56,152.73 235.66,152.62 236.89,151.39 236.89,151.1 237.71,150.28 237.9,150.28 JU3LC.17
USB3P4_TXP: length 183.2
  TOP w0.114: R173.1 233.65,159.59 233.5,159.59 232.64,159.59 231.98,158.94 231.98,157.45 232.58,156.85 v3(233.64,155.8) 235.24,154.19 236.35,154.19 236.61,154.45 v3(236.61,155.18)
  IN3 w0.114: v3(104.65,111.55) 104.45,111.75 104.45,111.94 105.81,113.3 107.96,113.3 109.4,114.75 120.36,114.75 121.05,115.43 129.13,115.43 130.76,113.81 141.75,113.81 142.18,114.24 150.83,114.24 154.39,110.68 160.96,110.68 162.89,112.61 168.76,112.61 171.23,115.08 177.85,115.08 179.07,113.86 183.17,113.86 183.88,113.15 196.17,113.15 197.01,113.98 197.01,114.89 197.83,115.71 201.48,115.71 203.74,117.97 203.74,118.85 219.29,134.41 222.77,134.41 237.88,149.51 237.88,152.85 236.33,154.4 236.33,154.9 v3(236.61,155.18)
  BOTTOM w0.076: 102.36,107.89 102.35,107.88 102.3,107.88 102.2,107.77 102.2,107.54 101.54,106.88 101.54,105.39 101.66,105.26 101.66,104.94 101.59,104.7 101.59,104.62 101.64,104.44 101.64,104.24 101.63,104.16 101.6,104.09 101.5,103.61 101.39,103.35 UC1.D15
  BOTTOM w0.114: 102.36,107.89 104.48,110 104.48,111.37 v3(104.65,111.55)
USB3P4_TXP_COAX_CON: length 15.2
  TOP w0.114: v3(235.2,152.46) 235.51,152.46 235.6,152.37 235.95,152.37 237.9,154.32 v3(237.9,157.22) 237.9,158.15 236.58,159.48 L8.2
  BOTTOM w0.114: JU3LC.16 237.5,149.98 237.5,150.17 236.66,151 236.66,151.3 236.08,151.88 235.5,152.46 v3(235.2,152.46)
USB3P5_RXN: length 37.5
  TOP w0.114: v3(92.04,122.04) 91.95,122.04 91.73,122.26 91.73,122.58 91.48,122.82 90.67,122.82 90.02,122.17 v3(89.39,122.17) 89.14,122.17 88.96,122.36 88.96,122.62 89.16,122.83 89.61,122.83 89.83,123.05 R165.1
  IN1 w0.076: 103.21,103.74 103.21,103.72 103.16,103.68 103.16,103.5 102.44,102.78 102.44,102.22 102.76,101.9 102.76,101.07 102.42,100.73 102.16,100.73 v3(101.99,100.56)
  IN1 w0.14: 103.21,103.74 103.21,104.44 103.08,104.57 103.05,104.57 103.05,104.58 103.05,104.99 102.77,105.27 102.77,112.51 102.34,112.94 102.34,114.9 101.07,116.17 101.07,119.85 99.78,121.15 92.16,121.15 91.95,121.35 91.95,121.95 v3(92.04,122.04)
  BOTTOM w0.076: UC1.H13 v3(101.99,100.56)
USB3P5_RXN_CON: length 8.3
  TOP w0.114: 90.6,123.69 90.81,123.9 90.81,124.3 91.14,124.63 v3(91.14,125.19) 91.14,130.45 90.61,130.98 90.61,131.13 JLCD.32
USB3P5_RXP: length 37.4
  TOP w0.114: R166.1 89.29,123.64 89.05,123.39 89.05,123.03 88.73,122.72 88.73,122.26 89.05,121.94 90.11,121.94 90.76,122.59 v3(91.09,122.59) 91.38,122.59 91.5,122.48 91.5,122.23 v3(91.33,122.06)
  IN1 w0.076: 102.95,103.74 102.95,103.72 102.97,103.71 102.97,103.53 102.28,102.85 102.28,102.16 102.6,101.84 102.6,101.14 102.35,100.89 102.18,100.89 101.99,101.07 v3(101.99,101.2)
  IN1 w0.14: v3(91.33,122.06) 91.7,121.69 91.7,121.24 92.05,120.89 99.67,120.89 100.82,119.75 100.82,116.06 102.09,114.79 102.09,112.84 102.52,112.41 102.52,105.16 102.79,104.89 102.79,104.47 102.87,104.39 102.95,104.31 102.95,103.74
  BOTTOM w0.076: UC1.G13 v3(101.99,101.2)
USB3P5_RXP_CON: length 8.3
  TOP w0.114: R166.2 90.18,124.6 90.79,124.6 90.91,124.72 v3(90.91,126.76) 90.91,127.61 90.79,127.74 90.79,128.07 90.91,128.19 90.91,128.52 90.79,128.65 90.79,128.98 90.91,129.11 90.91,129.44 90.79,129.56 90.79,129.89 90.91,130.02 90.91,130.32 90.38,130.85 90.32,130.85 JLCD.33
USB3P5_TXN: length 32.1
  TOP w0.114: C28.1 87.51,121.38 87.51,120.69 v3(87.66,120.54) 87.75,120.45 87.75,119.8 v1(87.96,119.59)
  IN1 w0.14: v3(101.99,111.55) 101.86,111.42 101.67,111.42 101.53,111.56 101.53,114.42 100.08,115.87 100.08,117.63 99.31,118.4 88.51,118.4 87.67,119.24 87.67,119.31 v1(87.96,119.59)
  BOTTOM w0.076: 101.02,108.09 101.01,108.07 100.96,108.07 100.59,107.7 100.59,104.79 100.34,104.54 100.21,104.54 100.08,104.4 UC1.B17
  BOTTOM w0.114: v3(101.99,111.55) 102.19,111.34 102.42,111.34 102.75,111.01 102.75,109.81 101.02,108.09
USB3P5_TXN_C: length 2.6
  TOP w0.114: R167.1 88.29,124.01 87.67,124.01 87.43,123.77 87.43,123.06 C28.2
USB3P5_TXN_CON: length 6.5
  TOP w0.084: 90.18,126.38 90.18,126.39
  TOP w0.114: R167.2 89.4,125.12 89.4,125.61 89.91,126.12 89.91,126.11 ; 89.91,126.11 90.18,126.38 ; 89.91,126.11 v3(89.87,126.07) ; 90.18,126.39 90.18,129.78 89.72,130.24 89.72,130.32 JLCD.35
USB3P5_TXP: length 32.1
  TOP w0.114: v1(87.16,119.59) 87.37,119.59 87.52,119.75 87.52,120.35 87.28,120.6 87.28,121.4 C29.1
  IN1 w0.14: v3(101.99,110.91) 101.73,111.16 101.56,111.16 101.28,111.45 101.28,114.31 99.82,115.77 99.82,117.53 99.2,118.15 88.41,118.15 87.42,119.14 87.42,119.34 v1(87.16,119.59)
  BOTTOM w0.076: UC1.A17 100.08,104.81 100.2,104.7 100.27,104.7 100.43,104.86 100.43,107.77 100.85,108.18 100.85,108.23 100.86,108.25
  BOTTOM w0.114: v3(101.99,110.91) 102.19,111.11 102.32,111.11 102.52,110.92 102.52,109.91 100.86,108.25
USB3P5_TXP_C: length 2.6
  TOP w0.114: C29.2 87.2,122.88 v3(87.2,123.66) 87.2,123.87 87.63,124.29 87.63,124.65 R168.1
USB3P5_TXP_CON: length 6.4
  TOP w0.114: R168.2 88.76,125.78 89.24,125.78 89.95,126.48 89.95,126.8 89.82,126.93 89.82,127.26 89.95,127.39 89.95,127.72 89.82,127.85 v3(89.82,127.98) 89.82,128.18 89.95,128.3 89.95,128.63 89.82,128.76 89.82,129.09 89.95,129.22 89.95,129.69 89.65,129.99 89.49,129.99 JLCD.36
USB20_N1: length 231.1
  TOP w0.114: v3(23.56,49.74) 23.37,49.55 23.37,48.93 22.49,48.05 v3(22.28,48.05) 21.67,48.05 L11.1
  IN3 w0.076: 111.1,86.51 111.12,86.53 111.12,87.47 110.5,88.09 108.01,88.09 106.36,89.74 105.32,89.74 104.35,90.71 104.35,91.8 104.06,92.1 104.06,93.59 104.38,93.91 104.9,93.91 105.07,93.74 105.07,93.56 v3(105.31,93.33)
  IN3 w0.114: 111.1,86.51 111.1,82.04 117.68,75.45 120.06,75.45 120.57,74.94 122.48,74.94 122.94,74.49 123.21,74.49 123.6,74.1 123.6,73.32 123.27,72.99 123.27,71.26 121.55,69.53 120.37,69.53 119.23,68.4 119.23,65.08 119.84,64.47 119.84,63.51 121.44,61.91 123.88,61.91 125.75,60.05 125.75,55.73 129.28,52.2 129.28,49.23 129.95,48.55 129.95,45.3 128.45,43.8 128.45,38.01 126.35,35.9 126.35,33.14 122.56,29.35 122.56,26.07 121.24,24.75 113.67,24.75 108.97,20.06 81.94,20.06 80.27,21.73 39.12,21.73 34.7,26.15 22.97,26.15 17.45,31.66 17.45,36.73 24.34,43.62 24.34,47.55 23.37,48.51 23.37,49.55 v3(23.56,49.74)
  BOTTOM w0.076: UC1.AB9 v3(105.31,93.33)
USB20_N1_CON: length 18.1
  TOP w0.114: v3(14.31,48.78) 14.51,48.99 14.75,48.99 14.89,48.84 14.89,48.43 v3(15.2,48.13) 15.48,47.84 16.13,47.84 16.7,47.28 16.7,46.86 D7.1 17.93,48.07 20.04,48.07 L11.2
  IN3 w0.114: JUSB1.2 14.21,42.02 14.33,41.9 14.82,41.9 15.45,42.53 15.45,48.75 15.19,49.01 14.53,49.01 v3(14.31,48.78)
USB20_N2: length 183.9
  TOP w0.114: AOU1.2 36.4,18.35 36.45,18.4 36.95,18.4 v3(37.08,18.28)
  IN3 w0.076: v3(107.23,92.26) 107.03,92.06 107.03,91.88 106.78,91.63 106.43,91.63 106.2,91.4 106.2,90.87 107.83,89.24 108.6,89.24 109.05,88.8 109.27,88.8 109.29,88.82
  IN3 w0.114: v3(37.08,18.28) 37.23,18.43 38.36,18.43 40.53,20.6 80.08,20.6 81.9,18.79 109.01,18.79 113.98,23.76 121.93,23.76 123.98,25.82 123.98,29.33 127.51,32.86 127.51,35.47 129.37,37.33 129.37,43.08 130.87,44.58 130.87,49.34 130.37,49.83 130.37,52.94 128.34,54.98 128.34,60.26 125.29,63.31 123.76,63.31 123.41,63.67 122.69,63.67 121.55,64.82 121.55,65.58 120.4,66.72 120.4,67.75 120.79,68.14 122.16,68.14 123.09,69.07 123.09,69.81 124.26,70.97 124.26,72.68 124.54,72.96 124.54,75.13 123.76,75.91 121.1,75.91 120.36,76.65 117.81,76.65 113.61,80.85 113.61,82.04 113.19,82.46 112.59,82.46 112.07,82.98 112.07,87.57 110.82,88.82 109.29,88.82
  BOTTOM w0.076: UC1.AD6 v3(107.23,92.26)
USB20_N2_CON: length 14.3
  TOP w0.114: 18.97,18.41 18.97,18.5 19.72,19.24 21.38,19.24 21.49,19.36 v3(22.23,19.36) 23.28,19.36 L20.2 ; 18.97,18.41 D17.1 ; 18.97,18.41 18.37,19.01 17.61,19.01 v3(17.33,18.73)
  IN1 w0.114: JUSB2.2 15.09,19.52 15.27,19.52 16.16,20.41 17.81,20.41 18.29,19.93 18.29,19.05 17.98,18.73 v3(17.33,18.73)
USB20_N3: length 223.9
  TOP w0.114: v3(175.69,103.67) 175.52,103.84 175.52,104.07 175.64,104.18 194.5,104.18 208.97,118.66 213.09,118.66 215.69,121.26 215.69,124.99 221.75,131.05 224.92,131.05 231.12,137.25 234.24,137.25 236.17,139.18 238.79,139.18 239.6,139.99 240.89,139.99 243.47,142.57 243.47,148.5 243.16,148.81 v3(243.16,158.99) 243.16,159.98 238.23,164.91 238.23,169.53 239.45,170.75 239.45,174.28 239.66,174.49 239.66,174.98 R163.1
  IN3 w0.114: v3(175.69,103.67) 175.49,103.87 175.49,104.16 175.13,104.52 173.75,104.52 162.02,92.8 161.16,92.8 159.9,91.54 159.9,86.06 152.19,78.35 150.34,78.35 148.95,76.96 148.95,72.77 146.2,70.01 136.81,70.01 136.3,70.52 128.16,70.52 127.16,71.52 127.16,72.84 126.45,73.56 126.45,75.41 122.92,78.93 117.57,78.93 115.73,80.77 115.73,84.95 114.74,85.94 114.26,85.94 v3(114.08,86.12)
  BOTTOM w0.076: UC1.AH3 108.06,89.97 108.24,89.79 108.33,89.79 108.46,89.91 108.79,89.91 108.95,89.97 109.09,89.97 109.31,89.91 109.43,89.91 109.54,89.95 109.9,89.95 110.04,89.82 111.39,89.82 113.63,87.57 113.63,86.1 113.77,85.97 113.92,85.97 v3(114.08,86.12)
USB20_N3_FFC_CON: length 7.9
  TOP w0.114: JU3LF.22 243.97,178.05 243.82,178.2 243.01,178.2 242.74,178.47 242.22,178.47 242.1,178.36 241.75,178.36 241.64,178.47 241.29,178.47 241.17,178.36 240.83,178.36 240.71,178.47 240.04,178.47 239.83,178.27 239.83,178.09 239.58,177.85 239.5,177.85 239.41,177.85 239.07,177.51 239.07,177.33 v3(239.21,177.19) 239.35,177.05 239.35,176.37 R163.2
USB20_N4: length 234.5
  TOP w0.114: R177.1 239.27,179.74 238.89,179.74 238.64,180 238.26,180 238.13,179.87 v3(238.13,179.57) 238.13,179.03 238.26,178.9 238.26,178.56 238.13,178.43 238.13,177.53 237.96,177.36 237.96,177.19 237.72,176.94 237.63,176.94 237.54,176.94 237.34,176.75 237.34,163.36 239.17,161.53 240.38,161.53 241.99,159.93 241.99,148.58 242.5,148.07 242.5,142.79 240.57,140.86 239.43,140.86 238.49,139.92 235.62,139.92 233.89,138.19 230.83,138.19 225.32,132.68 217.38,132.68 207.32,122.62 207.32,118.78 193.6,105.07 174.8,105.07 162.46,92.73 162.46,91 161.95,90.49 157.12,90.49 156.85,90.22 156.85,89.69 v3(157.2,89.35)
  IN3 w0.076: v3(105.31,92.26) 105.2,92.26 105.07,92.39 105.07,92.57 105.15,92.65 107.44,92.65 107.45,92.63
  IN3 w0.114: 107.45,92.63 107.74,92.34 107.94,92.34 109.23,91.05 109.23,90.3 109.62,89.91 111,89.91 112.67,88.23 115.41,88.23 116.54,89.36 116.54,90.18 116.94,90.58 118.98,90.58 119.82,89.74 119.82,87.92 120.52,87.21 121.33,87.21 124.01,84.54 124.01,81.82 128.35,77.48 129.02,77.48 131.98,74.51 137.18,74.51 138.59,73.11 138.59,72.38 139.05,71.92 145.37,71.92 146.44,72.99 146.44,80.65 149.44,83.66 153.93,83.66 155.63,85.36 155.63,87.33 156.9,88.6 156.9,89.05 v3(157.2,89.35)
  BOTTOM w0.076: UC1.AD9 v3(105.31,92.26)
USB20_N4_FFC_CON: length 4.1
  TOP w0.114: L13.3 240.67,180.03 v3(241.51,180.03) 243.03,180.03 243.4,179.67 243.8,179.67 243.92,179.55 JU3LF.25
USB20_N5: length 180
  TOP w0.114: v3(160.71,91.4) 160.89,91.58 160.89,92.62 174.33,106.06 192.98,106.06 206.18,119.26 206.18,123 216.87,133.69 224.87,133.69 230.36,139.18 233.34,139.18 v3(234.27,140.12) 235.57,141.42 236.1,141.42 L22.1
  IN3 w0.114: v3(113.72,84.39) 113.72,84.34 114.03,84.04 114.54,84.04 114.89,83.69 114.89,80.59 117.5,77.98 117.67,77.98 117.91,77.74 117.91,77.57 118.07,77.41 118.46,77.41 118.59,77.54 118.93,77.54 119.06,77.41 119.4,77.41 119.53,77.54 119.87,77.54 120,77.41 120.34,77.41 120.47,77.54 120.81,77.54 120.94,77.41 121.28,77.41 121.41,77.54 121.75,77.54 121.88,77.41 122.24,77.41 122.37,77.54 122.71,77.54 122.84,77.41 123.41,77.41 125.74,75.08 125.74,73.02 126.42,72.34 126.42,71.27 127.95,69.74 136.08,69.74 136.51,69.31 146.51,69.31 149.74,72.54 149.74,76.53 150.85,77.64 152.71,77.64 161.07,85.99 161.07,91.28 160.94,91.4 v3(160.71,91.4)
  BOTTOM w0.076: v3(113.72,84.39) 113.57,84.24 113.46,84.24 113.18,84.52 113.18,87.3 112.73,87.74 112.38,87.74 111.54,88.58 110.7,89.42 109.76,89.42 109.68,89.5 UC1.AJ1
USB20_N5_CON: length 11.9
  TOP w0.084: L22.2 237.58,141.59
  TOP w0.114: 237.58,141.59 237.83,141.34 238.21,141.34 v3(238.46,141.59) 238.74,141.87 239.53,141.87 239.81,142.15 239.81,142.31 240.05,142.55 240.21,142.55 240.46,142.79 240.46,142.96 240.7,143.2 240.86,143.2 241.07,143.41 241.07,144.11 240.95,144.23 240.95,144.57 241.07,144.68 241.07,145.03 240.95,145.14 240.95,145.48 241.07,145.6 241.07,145.79 240.69,146.16 240.53,146.16 240.29,146.4 240.29,146.57 240.05,146.81 239.88,146.81 239.64,147.05 239.64,147.21 239.4,147.46 239.24,147.46 238.99,147.7 238.99,147.86 238.87,147.98 238.27,147.98 238.19,147.9 JTOUCH.4
USB20_N6: length 242
  IN3 w0.076: 108.15,90.69 108.15,90.71 108.01,90.86 107.34,90.86 107.24,90.76 107,90.76 106.94,90.81 106.94,91.1 107.03,91.19 v1(107.23,91.19)
  IN3 w0.114: v3(240.04,182.24) 240.04,182.43 240.25,182.64 242.04,182.64 247.53,177.15 247.53,171.15 248.8,169.88 248.8,165.5 248.44,165.15 248.44,162.27 247.99,161.81 247.99,151.7 234.12,137.83 230.82,137.83 225.86,132.88 225.86,131.1 218.95,124.2 218.95,108.73 216.16,105.93 173.18,105.93 161.67,94.43 160.75,94.43 157.89,91.56 157.89,89.08 157.46,88.64 157.46,86.04 154.51,83.1 149.91,83.1 147.53,80.72 147.53,73.37 145.57,71.41 138.44,71.41 137.51,72.34 137.51,73.28 136.79,74 131.79,74 128.82,76.97 128.13,76.97 123.5,81.6 123.5,84.34 121.19,86.65 116.68,86.65 115.58,87.75 115.43,87.75 115.31,87.87 114.96,87.87 114.84,87.75 114.49,87.75 114.37,87.87 114.02,87.87 113.9,87.75 113.55,87.75 113.43,87.87 113.08,87.87 112.96,87.75 112.78,87.75 111.08,89.45 110.26,89.45 110.13,89.57 109.79,89.57 109.66,89.45 109.39,89.45 108.15,90.69
  BOTTOM w0.076: UC1.AF6 v1(107.23,91.19)
  BOTTOM w0.114: JWLBT.5 241.19,182.4 241.03,182.56 240.18,182.56 240.04,182.42 v3(240.04,182.24)
USB20_N7: length 76.7
  TOP w0.114: v1(92.49,119.85) 92.26,120.08 92.26,120.66 92.54,120.94 93,120.94 93.48,120.46 v3(94.27,120.46) 95.3,120.46 98.41,123.57 98.41,128.97 98,129.38 L15.4
  IN3 w0.076: 88.85,102.29 88.85,102.27 88.82,102.25 88.82,101.01 89.46,100.37 93.76,100.37 94.28,99.85 94.28,98.69 94.52,98.44 95.21,98.44 95.94,97.7 95.94,96.86 96.52,96.29 99.54,96.29 100.88,94.95 106.89,94.95 107.42,94.43 107.42,93.79 110.66,90.55 113.61,90.55 114.17,90 114.17,89.23 113.79,88.85 112.74,88.85 112.47,89.12 112.47,89.32 v3(112.26,89.52)
  IN3 w0.114: 88.85,102.29 88.85,103.66 90.38,105.2 90.38,105.92 92,107.55 92,108.75 93.02,109.77 93.02,116.97 94.04,117.99 94.04,118.38 93.61,118.81 92.69,118.81 92.31,119.19 92.31,119.67 v1(92.49,119.85)
  BOTTOM w0.076: v3(112.26,89.52) 112.38,89.52 112.53,89.68 112.53,89.86 112.17,90.23 111.84,90.23 111.74,90.13 111.53,90.13 111.44,90.23 111.23,90.23 111.13,90.13 110.92,90.13 110.83,90.23 110.62,90.23 110.53,90.13 110.31,90.13 110.22,90.23 109.98,90.23 109.77,90.44 109.13,90.44 109.06,90.37 109.06,90.26 109.13,90.18 UC1.AH1
USB20_N7_CMOS: length 6.7
  TOP w0.114: L15.3 96.92,130.39 96.05,131.26 95.77,131.26 95.33,131.7 95.33,132.37 95.48,132.53 v3(95.48,132.93) 95.48,134.55 94.85,135.19 94.85,135.37 JLCD.17
USB20_N9: length 167
  TOP w0.114: v5(205.4,96.74) 205.65,96.99 205.65,97.62 205.98,97.95 205.98,98.97 206.46,99.46 206.94,99.46 207.16,99.67 D4.3 207.87,99.61 209.17,99.61 211.86,96.92 214.53,96.92 217.14,94.31 217.14,91.7 216.12,90.68 214.21,90.68 213.86,91.04 213.64,91.04 213.25,90.65 JFPB.3
  IN1 w0.14: v3(115.42,86.7) 115.18,86.95 115.18,87.47 114.28,88.37 109.98,88.37 109.54,88.8 109.54,90.26 109.02,90.78 105.47,90.78 105.4,90.84 105.4,90.98 v1(105.59,91.17)
  IN3 w0.114: v3(115.42,86.7) 115.27,86.55 115.27,86.34 115.72,85.89 120.94,85.89 122.74,84.1 122.74,80.3 123.37,79.67 124.3,79.67 127.59,76.38 127.59,74.24 128.3,73.53 128.3,72.3 129.22,71.39 136.77,71.39 137.45,70.71 145.9,70.71 148.24,73.05 148.24,79.42 150.65,81.83 154.51,81.83 158.17,85.49 158.17,88.34 159.11,89.28 159.11,91.79 160.93,93.61 161.85,93.61 173.45,105.22 197.43,105.22 198.78,103.87 198.78,102.23 204.84,96.17 205.46,96.17 205.63,96.35 205.63,96.51 v5(205.4,96.74)
  BOTTOM w0.114: v1(105.59,91.17) 105.42,91.34 105.42,91.52 105.55,91.65 UC1.AF8
USB20_P1: length 231.1
  TOP w0.114: L11.4 21.69,48.27 22.39,48.27 23.15,49.03 23.15,49.41 22.82,49.74 v5(22.77,49.74)
  IN3 w0.076: 111.3,86.51 111.28,86.53 111.28,87.54 110.57,88.25 108.08,88.25 106.43,89.91 105.39,89.91 104.51,90.78 104.51,91.87 104.22,92.17 104.22,93.52 104.45,93.75 104.83,93.75 104.91,93.67 104.91,93.56 v3(104.67,93.33) ; 114.49,78.94 114.47,78.95
  IN3 w0.114: 114.47,78.95 111.3,82.12 111.3,86.51 ; v5(22.77,49.74) 22.82,49.74 23.17,49.38 23.17,48.43 24.14,47.46 24.14,43.7 17.25,36.82 17.25,31.58 22.88,25.95 34.62,25.95 39.04,21.53 80.18,21.53 81.86,19.85 109.06,19.85 113.76,24.55 121.32,24.55 122.76,25.99 122.76,29.27 126.55,33.05 126.55,35.82 128.66,37.93 128.66,43.72 130.16,45.22 130.16,48.64 129.48,49.31 129.48,52.29 125.95,55.82 125.95,60.13 123.97,62.12 121.52,62.12 120.05,63.59 120.05,64.56 119.44,65.17 119.44,68.32 120.45,69.33 121.63,69.33 123.48,71.18 123.48,72.9 123.81,73.23 123.81,74.18 123.3,74.69 123.03,74.69 122.57,75.15 120.66,75.15 120.15,75.66 117.77,75.66 114.49,78.94
  BOTTOM w0.076: UC1.AB10 v3(104.67,93.33)
USB20_P1_CON: length 18.1
  TOP w0.114: v5(14.31,49.45) 14.54,49.21 14.84,49.21 15.12,48.94 15.12,48.53 15.58,48.07 16.14,48.07 16.71,48.65 D7.6 17.66,48.3 20.08,48.3 L11.3
  IN3 w0.114: JUSB1.3 15.65,42.44 15.65,48.83 15.27,49.21 14.54,49.21 v5(14.31,49.45)
USB20_P2: length 183.8
  TOP w0.114: v3(37.08,18.91) 37.08,18.85 36.86,18.63 36.56,18.63 36.34,18.85 AOU1.3
  IN3 w0.076: 109.29,88.62 109.28,88.62 109.27,88.63 108.98,88.63 108.53,89.08 107.76,89.08 106.04,90.8 106.04,91.47 106.36,91.8 106.71,91.8 106.86,91.95 106.86,92.14 106.74,92.26 v3(106.58,92.26)
  IN3 w0.114: 109.29,88.62 110.73,88.62 111.86,87.49 111.86,82.9 112.5,82.26 113.1,82.26 113.41,81.96 113.41,80.76 117.73,76.44 120.28,76.44 121.01,75.71 123.68,75.71 124.34,75.05 124.34,73.05 124.06,72.77 124.06,71.06 122.89,69.89 122.89,69.15 122.08,68.34 120.71,68.34 120.2,67.83 120.2,66.64 121.34,65.5 121.34,64.73 122.61,63.46 123.32,63.46 123.68,63.11 125.21,63.11 128.14,60.18 128.14,54.89 130.17,52.86 130.17,49.75 130.66,49.25 130.66,44.67 129.17,43.17 129.17,37.41 127.31,35.56 127.31,32.94 123.78,29.41 123.78,25.91 121.84,23.97 113.9,23.97 108.92,18.99 81.98,18.99 80.16,20.8 40.45,20.8 38.28,18.63 37.36,18.63 v3(37.08,18.91)
  BOTTOM w0.076: UC1.AD7 v3(106.58,92.26)
USB20_P2_CON: length 14.3
  TOP w0.114: v5(17.33,19.43) 17.33,19.42 17.51,19.24 17.96,19.24 18.97,20.25 ; D17.6 18.97,20.25 ; 18.97,20.25 18.97,20.24 19.74,19.47 21.29,19.47 21.4,19.59 23.34,19.59 L20.3
  IN1 w0.114: JUSB2.3 14.21,19.13 14.4,19.32 15.36,19.32 16.24,20.21 17.73,20.21 18.09,19.85 18.09,19.13 17.94,18.98 17.76,18.98 17.33,19.42 v5(17.33,19.43)
USB20_P3: length 223.8
  TOP w0.114: R164.1 238.86,174.99 238.86,174.59 239.15,174.31 239.15,174.31 239.22,174.23 239.22,170.85 238,169.63 238,164.82 242.93,159.89 v3(242.93,156.94) 242.93,148.71 243.24,148.41 243.24,142.66 240.8,140.22 239.51,140.22 238.7,139.41 236.07,139.41 234.14,137.48 231.03,137.48 224.82,131.28 221.65,131.28 215.46,125.09 215.46,121.35 212.99,118.89 208.88,118.89 194.4,104.41 175.54,104.41 175.29,104.16 175.29,103.9 175.06,103.67 v3(174.9,103.67)
  IN3 w0.114: v3(174.9,103.67) 175.11,103.67 175.28,103.85 175.28,104.08 175.05,104.32 173.83,104.32 162.11,92.6 161.25,92.6 160.1,91.45 160.1,85.98 152.27,78.14 150.42,78.14 149.15,76.87 149.15,72.68 146.28,69.81 136.73,69.81 136.22,70.32 128.07,70.32 126.96,71.44 126.96,72.76 126.24,73.47 126.24,75.33 122.84,78.73 117.48,78.73 115.53,80.68 115.53,84.87 114.65,85.74 114.23,85.74 114.08,85.59 v3(114.08,85.41)
  BOTTOM w0.076: UC1.AJ3 108.61,89.75 108.82,89.75 108.98,89.8 109.07,89.8 109.29,89.74 109.46,89.74 109.58,89.79 109.84,89.79 109.97,89.66 111.28,89.66 113.44,87.49 113.44,86.03 113.69,85.78 113.94,85.78 114.08,85.64 v3(114.08,85.41)
USB20_P3_FFC_CON: length 7.9
  TOP w0.114: JU3LF.23 243.92,178.55 243.8,178.42 243.11,178.42 242.83,178.7 239.94,178.7 v3(239.79,178.55) 238.84,177.6 238.84,177.2 239.12,176.93 239.12,176.31 R164.2
