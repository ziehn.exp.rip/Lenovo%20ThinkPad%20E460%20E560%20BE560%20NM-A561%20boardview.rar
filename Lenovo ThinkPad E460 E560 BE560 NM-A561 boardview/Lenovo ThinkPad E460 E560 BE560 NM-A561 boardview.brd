# Allegro board Lenovo ThinkPad E460 E560 BE560 NM-A561 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N31397070: length 2.6
  BOTTOM w0.203: PU401.5 69.96,125.26 69.22,126 PR432.1
N31397078: length 97.5
  TOP w0.254: v3(36.62,106.64) 37.11,106.14 37.55,106.14 37.83,106.42 39.68,106.42 45.52,100.57 45.52,96.95 42.5,93.93 42.5,91.61 41.95,91.05 41.95,76.98 41.14,76.18 41.14,75.26 v3(40.95,75.07)
  IN3 w0.254: v3(69.25,128.87) 69.31,128.8 69.31,128.44 67.85,126.98 61.79,126.98 59.98,125.18 57.75,125.18 56.72,126.2 48.64,126.2 47.61,127.23 43.51,127.23 40.77,124.49 40.77,113.98 39.89,113.1 39.89,111.15 36.79,108.05 36.79,106.81 v3(36.62,106.64)
  BOTTOM w0.203: PC418.1 70.08,125.77 v2(70.36,125.5) PU401.6
  BOTTOM w0.254: v3(69.25,128.87) 69.2,128.82 PR427.1 69.22,128.18 PR432.2 69.25,127.34 PC419.1 PC418.1 ; v3(40.95,75.07) 41.05,74.97 PRT403.1
N31397084: length 8.5
  TOP w0.114: v4(69.02,127.8) 69.5,127.32 PR430.2
  TOP w0.203: v3(71.23,128.84) 71,128.61 PR426.1 70.8,127.32 PR430.2
  BOTTOM w0.203: PC418.2 70.76,126.21 PU401.7
  BOTTOM w0.254: v3(71.23,128.84) 71,128.61 PC419.2 PC418.2
N31397096: length 94.7
  TOP w0.203: v3(70.11,128.87) 70.08,128.84 PR430.1
  TOP w0.254: v3(37.34,106.64) 37.5,106.8 39.83,106.8 45.9,100.73 45.9,96.8 42.88,93.77 42.88,91.45 42.33,90.9 42.33,76.82 41.52,76.02 41.52,74.91 v3(40.95,74.33)
  IN3 w0.254: v3(37.34,106.64) 37.17,106.82 37.17,107.89 40.27,111 40.27,112.94 41.15,113.82 41.15,124.34 43.67,126.85 47.45,126.85 48.48,125.82 56.57,125.82 57.59,124.8 60.14,124.8 61.95,126.6 68.01,126.6 69.85,128.44 69.85,128.61 v3(70.11,128.87)
  BOTTOM w0.114: v2(70.24,129.55) 70.11,129.43 v3(70.11,128.87)
  BOTTOM w0.254: PRT403.2 41.3,73.98 v3(40.95,74.33) ; PR427.2 v3(70.11,128.87)
N31397121: length 4.3
  BOTTOM w0.203: PU401.8 71.16,125.67 71.84,126.35 PC414.2
  BOTTOM w0.254: PR423.1 PC417.1 71.91,126.53 PC414.2
N31397144: length 3.5
  BOTTOM w0.203: PU401.10 71.96,124.82 v2(72.62,125.49) 72.62,126.33 PC414.1
  BOTTOM w0.254: PR422.1 73.62,126.46 PC414.1
N31397166: length 4.3
  BOTTOM w0.203: PC408.1 76.56,120.54 PR417.1 76.51,119.72 76.05,119.27 v2(75.57,119.27) 74.73,119.27 74.49,119.51 PU401.23
N31397172: length 76.5
  TOP w0.254: v1(119.67,123.79) 120.34,123.12 120.34,121.39 120.66,121.07 120.66,118.48 120.43,118.25 v4(120.43,117.92) 120.43,117.87 120.58,117.72 120.58,113.15 122.71,111.01 122.71,108.95 124.6,107.07 124.6,106.79 124.82,106.57 124.82,105.93 126.4,104.36 v3(128.38,104.36)
  IN2 w0.254: v1(78.23,120.37) 78.09,120.51 78.09,124.31 80.68,126.9 84.69,126.9 85.37,126.21 87.74,126.21 88.69,125.26 97.91,125.26 98.59,124.59 102.2,124.59 103.13,123.66 103.95,123.66 106.12,125.83 115.76,125.83 117.09,124.5 118.95,124.5 v1(119.67,123.79)
  BOTTOM w0.203: PR418.2 77.45,119.75 PR417.2
  BOTTOM w0.254: v1(78.23,120.37) 78.03,120.56 PR418.2
  BOTTOM w0.381: PRT402.1 v3(128.38,104.36)
N31397188: length 3.8
  BOTTOM w0.254: PR401.2 PC401.1 74.48,125.62 73.62,124.75
N31397190: length 3.4
  BOTTOM w0.508: 73.95,124.09 74.61,124.75 v2(75.11,124.75) PC402.1 PR402.2
N31397230: length 4.1
  BOTTOM w0.254: PC441.1 67.57,116.12 PR407.2 67.6,116.46 66.88,117.17 v2(66.88,117.26) 66.88,117.57 67.16,117.85 67.16,118.48 67.49,118.81
N31397238: length 2.7
  BOTTOM w0.114: PR410.2 68.97,116.65 68.97,117.18 v2(68.79,117.36) 68.79,117.49 69.16,117.86 PU401.34
N31397260: length 5.8
  BOTTOM w0.203: PR412.1 71.18,113.7 PR405.1 PC440.1 PC405.1 71.94,116.73 71.16,117.51 PU401.29
N31397268: length 69.5
  IN2 w0.254: v3(132.44,115.4) 132.44,115.62 132.14,115.93 116.52,115.93 115.69,116.75 115.69,117.51 115.25,117.96 112.58,117.96 111.69,118.85 110.48,118.85 108.2,116.56 101.15,116.56 99.88,115.29 82.29,115.29 80.42,113.42 78.96,113.42 77.46,111.93 75.49,111.93 74.51,112.91 v3(72.4,112.91)
  BOTTOM w0.254: v3(72.4,112.91) 72.4,112.89 71.94,113.35 PR405.2 ; v3(132.44,115.4) v2(132.44,113.32) 132.01,112.89 PRT401.1
N31397346: length 5.2
  TOP w0.254: v3(65.92,120.66) 65.92,121.5 v4(66.12,121.71) 67.14,121.71 PC431.2 PR441.2
  BOTTOM w0.203: PU401.42 66.36,121.11 v3(65.92,120.66)
N31397348: length 4.6
  BOTTOM w0.203: PR428.1 66.63,126 v2(67.37,125.26) 68.28,125.26 68.76,124.79 PU401.2
  BOTTOM w0.254: PR431.1 PR428.1
N31397350: length 7
  BOTTOM w0.114: v2(66.76,129.2) 66.66,129.1 PC421.2
  BOTTOM w0.203: PU401.3 69.16,124.94 68.46,125.64 67.72,125.64 67.47,125.9 PC422.1
  BOTTOM w0.254: PC421.2 66.63,128.21 PR428.2 66.71,127.32 PR429.1 67.49,126.51 PC422.1
N31397402: length 3.6
  BOTTOM w0.203: PC420.2 68.38,127.29 PC422.2 68.38,126.25 69.56,125.08 PU401.4
N31397404: length 6
  TOP w0.254: 67.01,117.85 66.38,117.85 v3(66.16,118.06) ; 67.01,117.85 v4(67.01,117.85) ; 67.01,117.85 67.01,118.48 67.32,118.78 PC430.2 PR442.2
  BOTTOM w0.203: PU401.39 66.92,119.91 66.43,119.42 66.43,118.33 v3(66.16,118.06)
N31397538: length 4.8
  TOP w0.114: v4(73.77,125.64) 73.77,124.63 PR443.2
  TOP w0.203: PR443.2 74.48,124.6 v3(75.16,123.92)
  BOTTOM w0.203: v3(75.16,123.92) 74.81,123.92 74,123.11 PU401.14
N31397546: length 2.9
  TOP w0.254: PR444.2 74.4,123.66 v3(74.85,123.22)
  BOTTOM w0.203: PU401.15 74.11,122.71 74.62,123.22 v3(74.85,123.22)
N31397550: length 5
  TOP w0.114: v4(75.93,122.44) 75.83,122.44 v3(75.39,122.01)
  TOP w0.254: PR446.2 74.2,121.91 74.53,121.58 74.96,121.58 v3(75.39,122.01)
  BOTTOM w0.203: v3(75.39,122.01) 74.49,121.11 PU401.19
N31397552: length 2.9
  TOP w0.254: PR445.2 74.28,122.77 74.73,122.32 v3(74.73,122.11)
  BOTTOM w0.203: PU401.18 74.13,121.51 v3(74.73,122.11)
N31397554: length 3.9
  TOP w0.254: v3(75.39,121.27) 75.16,121.05 PR447.2
  BOTTOM w0.203: v3(75.39,121.27) 75.22,121.27 v2(74.81,120.87) 74.65,120.71 PU401.20
N31397556: length 5.4
  TOP w0.114: v4(75.85,120.51) 75.85,120.03 v3(75.67,119.85)
  TOP w0.254: v3(75.67,119.85) 75.16,120.36 73.97,120.36 PR448.2
  BOTTOM w0.203: PU401.21 75.27,120.31 75.67,119.9 v3(75.67,119.85)
N31397566: length 2.4
  BOTTOM w0.114: PU401.33 69.56,116.38 PR408.2
N31397696: length 4.1
  BOTTOM w0.203: PU401.45 v2(65.84,122.31) 65.82,122.31 65.39,122.75 64.7,122.75 PR434.2
  BOTTOM w0.254: PR433.2 PR434.2
N31397710: length 2.4
  BOTTOM w0.114: PR411.2 69.96,116.37 PU401.32
N31397718: length 2
  BOTTOM w0.114: PC423.2 62.77,123.56 v2(61.75,123.56)
  BOTTOM w0.254: PR433.1 62.92,123.66 PC423.2
N31398277: length 3.9
  BOTTOM w0.203: PU401.44 64.67,121.91 PR437.2
  BOTTOM w0.254: PC426.2 PR437.2
N31398315: length 2
  BOTTOM w0.114: PC420.1 68.36,129.15 v2(68.48,129.28)
  BOTTOM w0.254: PC420.1 PR429.2
N31398319: length 2.1
  BOTTOM w0.114: v2(64.6,128.49) 64.85,128.23 PC421.1
  BOTTOM w0.254: PC421.1 65.74,127.42 PR431.2
N36436059: length 1.4
  TOP w0.254: PR304.1 v4(138.61,23.03)
N42212278: length 2.6
  TOP w0.305: v4(33.13,98.2) 34.54,98.2 JCP.7
  TOP w0.508: v4(33.13,98.2) 32.14,98.2 RL20.1
N43769362: length 1.9
  TOP w0.114: RE38.1 CE15.2 206.3,50.04 v2(206.3,50.38)
N48440511: length 4.2
  BOTTOM w0.114: v4(140.93,43.5) 140.93,44.62 PC702.2
  BOTTOM w0.203: PU701.26 140.71,46.36 140.9,46.17 PR702.2
  BOTTOM w0.254: PR702.2 PC702.2
N48440559: length 1.9
  BOTTOM w0.203: PR706.2 144.09,49.3 PU701.20
N48440565: length 3.3
  BOTTOM w0.114: PC703.1 144.15,48.33 v4(144.15,47.21)
  BOTTOM w0.203: PC703.1 143.63,48.9 PU701.21
N48440766: length 1.8
  BOTTOM w0.114: v2(133.09,49.13) 134.11,48.11 PC704.1
N48440774: length 2.3
  BOTTOM w0.203: PR701.2 139.17,46.98
  BOTTOM w0.254: PC701.1 PR701.2
N48440814: length 1.1
  TOP w0.254: v4(136.99,55.51) 136.99,54.6 PC718.1
N50697329: length 4.6
  TOP w0.114: RC316.2 121.37,34.25 122.3,34.25 v5(122.4,34.15)
  BOTTOM w0.114: JDIMM1.197 121.12,37.15 121.12,35.43 122.39,34.15 v5(122.4,34.15)
N50697343: length 2.5
  TOP w0.305: CD2.2 57.97,37.84 57.74,37.61 v4(57.61,37.61) 57.44,37.61 57.08,37.96 RD4.1
N50697618: length 2.9
  TOP w0.114: RC315.2 122.93,35.36 122.61,35.68 v5(122.4,35.68)
  BOTTOM w0.114: v5(122.4,35.68) 122.32,35.76 122.32,37.15 122.32,37.15 JDIMM1.201
N50697658: length 1.9
  TOP w0.114: v4(106.03,25.36) 105.75,25.64 RD12.1
  TOP w0.381: CD12.2 RD12.1
N50702365: length 2.4
  TOP w0.305: RD18.1 56.5,51.17 v4(56.85,50.81) 57.03,50.81 57.38,51.17 CD31.2
N50702825: length 4.5
  TOP w0.114: v5(122.62,47.62) 121.6,47.62 RC317.2
  BOTTOM w0.114: JDIMM2.197 121.12,48.95 122.46,47.62 v5(122.62,47.62)
N54603879: length 4.5
  BOTTOM w0.114: v4(143.85,45.48) 142.7,45.48 PR703.2
  BOTTOM w0.203: PR702.1 141.81,45.99 141.11,46.7 PU701.25
  BOTTOM w0.254: PR702.1 142.63,45.51 PR703.2
N54887023: length 4
  TOP w0.114: v3(122.62,48.89) 122.13,49.39 RD19.2 120.96,49.39 v4(120.58,49.77)
  BOTTOM w0.114: v3(122.62,48.89) 122.32,49.2 122.32,50.35 122.32,50.35 JDIMM2.201
N55632055: length 1.7
  TOP w0.114: v3(213.7,156.3) 213.8,156.4 v4(213.8,157.24)
  TOP w0.254: PR627.2 213.59,156.15 213.7,156.25 v3(213.7,156.3)
N55632901: length 2.1
  TOP w0.114: v4(215.55,157.24) 215.55,157.16 v1(214.69,156.3)
  TOP w0.254: PR637.2 214.46,156.02 214.69,156.25 v1(214.69,156.3)
N55634236: length 5.4
  TOP w0.114: v4(217.18,153.51) 216.82,153.86 PR640.1
  TOP w0.254: v3(216.92,155.34) 215.86,154.27 PR640.1
  BOTTOM w0.203: PU601.2 216.09,154.25 216.92,155.08 v3(216.92,155.34)
N55637104: length 1.6
  TOP w0.114: v3(216.06,155.61) 216.36,155.61 v4(216.74,156)
  TOP w0.254: PR638.1 v3(216.06,155.61)
N55638710: length 2.2
  TOP w0.114: v4(210.47,156.53) 211.74,156.53 v3(211.87,156.4)
  TOP w0.254: PR628.1 v3(211.87,156.4)
N56243451:
  vias: v4(233.38,160.11)
N56300303: length 2.8
  BOTTOM w0.203: PU601.6 217.13,152.65 217.43,152.95 PR612.2
N56340374: length 3.1
  TOP w0.114: v4(212.05,157.29) 212.05,157.04 v3(212.73,156.35)
  TOP w0.254: PR629.1 v3(212.73,156.35)
  BOTTOM w0.203: v3(212.73,156.35) 212.53,156.15 PU601.34
N56471499: length 3.6
  BOTTOM w0.203: PU701.3 138.32,48.9 v4(137.88,48.45) 137.72,48.3 137.72,46.93 PR705.1
N56767462: length 6.8
  TOP w0.114: v4(155.15,120.82) 155.15,118.66 154.74,118.25 RV13.1 CV19.1 RV11.2 153.8,116.45 QV1.2
N56767499: length 9.2
  TOP w0.114: v3(145.04,135.78) 144.25,134.99 143.41,134.99 140.8,132.37 139.58,132.37 139.1,131.89 139.1,131.59 139.35,131.33 RV4.2
  BOTTOM w0.084: UV1.AB35 145.6,135.74 145.52,135.83 145.09,135.83 v3(145.04,135.78)
N56767500: length 9.1
  TOP w0.114: RV5.2 138.87,131.59 138.87,131.99 139.48,132.6 140.7,132.6 143.32,135.22 144.16,135.22 144.41,135.47 v3(144.41,135.93)
  BOTTOM w0.102: UV1.AA36 144.41,135.55 v3(144.41,135.93)
N56772982: length 3
  BOTTOM w0.114: RV28.1 RV27.2 CV77.1 166.4,156.43 v4(166.2,156.63)
N56786553: length 25
  IN3 w0.084: v1(146.99,140.7) 146.99,140.15 147.88,139.26 148.37,139.26 149.13,140.02 149.66,140.02 150.22,139.46 151.74,139.46 152.12,139.84 155.48,139.84 155.67,139.65 157.96,139.65 159.85,137.76 159.85,135.84 v3(160.2,135.49)
  BOTTOM w0.084: v1(146.99,140.7) 147.14,140.7 UV1.AD28
  BOTTOM w0.114: RV94.2 161.91,129.77 RV93.2 160.89,130.79 v2(160.89,132.02) 160.89,132.32 160.2,133.01 v3(160.2,135.49)
N56786719: length 1.1
  TOP w0.114: RV101.1 162.52,148.27 TPV12.1
N56786731: length 9.5
  TOP w0.114: RV101.2 157.54,148.27 156.98,147.72 152.74,147.72 152.58,147.56 v1(152.58,147.15)
  BOTTOM w0.102: UV1.AL21 153,146.74 v1(152.58,147.15)
N56787089: length 10.4
  TOP w0.114: QV4.2 169.81,131.63 169.35,131.17 169.35,130.02 169.73,129.64 169.73,128.87 v4(169.22,128.36) 167.52,126.66 164.85,126.66 CV209.1 RV105.2
N56787095: length 7.2
  TOP w0.114: v4(165.74,129.76) RV104.2 RV105.1 RV102.2 ; RV102.2 163.3,128.77 163.25,128.82 162.81,128.82 v3(161.92,127.93) ; RV102.2 RV103.1
  BOTTOM w0.114: v3(161.92,127.93) 161.67,127.93 DV4.2
N56799483:
  vias: v3(38.04,112.97) v3(38.18,120.77) v3(38.21,119.47) v3(38.31,113.74) v3(38.31,112.3) v3(38.38,121.44) v3(38.39,120.09) v4(37.42,113.35)
N56839363: length 19.5
  TOP w0.114: v4(156.8,126.35) 156.8,128.08 156.98,128.26 157.74,128.26 158.17,127.83
  TOP w0.381: CV217.1 CV215.1 158.25,129.88 158.49,129.64 CV216.1 158.49,128.65 158.17,128.33 LV6.2
  TOP w0.508: CV217.1 158.25,132.93 156.77,134.41 153.3,134.41 151.72,135.98 151.72,136.84 151.05,137.51 v1(150.71,137.51)
  BOTTOM w0.254: v1(150.71,137.51) 151.15,137.96 UV1.AJ32
N56839883: length 11.6
  IN3 w0.102: v3(160.97,154.34) 160.58,153.96 160.2,153.96 159.24,154.93 154.72,154.93 154.29,154.5 v1(154.13,154.5)
  BOTTOM w0.102: UV1.AN13 154.46,153.9 154.46,154.09 154.13,154.41 v1(154.13,154.5)
  BOTTOM w0.114: v4(160.99,155.08) 160.99,154.37 ; 160.99,154.37 161.02,154.4 RV129.2 RV130.2 ; 160.99,154.37 v3(160.97,154.34)
N56881458: length 10.9
  TOP w0.114: RV138.2 159.96,149.86 158.69,149.86 158.32,149.49 155.43,149.49 154.87,148.93 152.81,148.93 152.63,148.76 151.57,148.76 v1(151.19,148.38)
  BOTTOM w0.102: v1(151.19,148.38) 150.97,148.16 UV1.AH20
N56882589: length 12.2
  TOP w0.114: RV139.2 161.02,150.64 155.84,150.64 155.15,149.95 153.04,149.95 152.2,149.11 151.57,149.11 v1(151.02,149.66)
  BOTTOM w0.102: UV1.AH18 150.6,149.23 v1(151.02,149.66)
N56882611: length 6.8
  TOP w0.114: v1(154.74,151.93) 159.75,151.93 RV140.2
  BOTTOM w0.084: v1(154.74,151.93) 154.6,151.79 UV1.AN16
N57615062: length 2.9
  TOP w0.114: T24.1 50.22,112.61 49.11,113.72 UL1.34
N57615075: length 4.1
  TOP w0.114: T23.1 48.42,110.56 48.42,113.76 48.31,113.86 UL1.32
N57725801: length 4.1
  TOP w0.114: JKB.25 172.39,118.54 171.98,118.95 171.57,118.95 171.1,119.42 v4(171.1,119.83) 171.15,119.88 172.22,119.88 R111.2
N57726117: length 3.1
  BOTTOM w0.114: v4(234.83,155.85) D6.2
  BOTTOM w0.508: D6.2 232.85,156.45 R112.1
N57740748:
  vias: v4(114.71,183.63)
N57878197: length 1.3
  TOP w0.114: JCRT.11 8.11,86.42 T25.1
N57919388: length 0.8
  TOP w0.254: RA14.2 CA29.1
N57919390: length 0.8
  TOP w0.254: RA15.2 CA30.1
N57919402: length 1
  TOP w0.254: CA31.1 215.51,19.32 RA19.2
N57919454: length 1.1
  TOP w0.254: CA32.1 215.23,20.21 RA24.2
N57919827: length 6.8
  TOP w0.114: DA1.1 197.78,30.22 v4(198.66,30.22) 198.66,29.73 CA22.2 199.32,29.1 RA11.1 201.1,28.21 CA23.2 RA13.1
N57919838: length 2.7
  TOP w0.114: RA11.2 201.12,29.88 201.4,30.16 v4(201.81,30.16) 201.99,29.99 CA24.1
N57996073: length 5.5
  TOP w0.114: UX1.1 27.27,66.77 27.54,67.05 27.84,67.05 28.91,68.11 30.13,68.11 v4(30.54,67.71) 30.56,67.73 CX2.2
N57996075: length 3.4
  TOP w0.114: RX2.2 19.21,59.22 v4(19.38,59.39) 20.53,60.55 UX1.27
N57996720: length 3.9
  TOP w0.114: TP939.1 30.91,60.91 29.13,60.91 28.69,61.35 UX1.46
N58098354: length 4.3
  TOP w0.114: v4(232.9,154.14) v3(232.9,154.78)
  BOTTOM w0.254: R112.2 232.44,155.06 232.72,154.78 v3(232.9,154.78)
  BOTTOM w0.508: R112.2 231.98,153.54 JRTC.1
N58156905: length 1.9
  TOP w0.114: v4(225.94,162.35) v3(225.3,162.35)
  TOP w0.254: PR102.1 224.87,161.91 v3(225.3,162.35)
N59027809: length 21.5
  TOP w0.254: v3(240.62,159.86) 239.88,160.59 v4(239.43,160.59) 238.69,160.59 236.42,162.86 236.42,174.14 v3(236.02,174.54)
  BOTTOM w0.254: v3(240.62,159.86) PR6.1 PR7.1 241.51,159.8 PQ4.1
N59027813: length 4.6
  BOTTOM w0.114: v4(238.61,159.58) 238.61,161.3 PR4.1
  BOTTOM w0.254: PR4.1 239.68,161.46 PR6.2 239.71,159.81 PQ4.6
N59062655: length 27.4
  TOP w0.114: v4(202.67,136.97) 203.31,136.97 v3(203.36,136.92)
  IN2 w0.254: v3(203.36,136.92) 203.61,137.17 204.94,137.17 207.75,139.99 207.75,142.48 211.44,146.17 216.97,146.17 218.98,148.17 v3(218.98,148.43)
  BOTTOM w0.254: PRT602.2 202.04,137.2 203.08,137.2 v3(203.36,136.92) ; PR643.1 220.53,149.9 219.86,149.23 219.14,149.23 PR641.2 218.98,149.06 v3(218.98,148.43)
N59480687: length 4.1
  BOTTOM w0.084: 145.88,132.02 146.64,132.78 146.64,134.12 UV1.AC38
  BOTTOM w0.114: 145.88,132.02 v2(145.85,131.99) 145.85,131.87 RV145.1
N59480694: length 4.6
  BOTTOM w0.084: 147.61,132.02 147.61,132.27 146.84,133.03 146.84,134.47 146.4,134.92 UV1.AC36
  BOTTOM w0.114: 147.61,132.02 v2(147.61,131.97) RV146.1
N59482294: length 7.3
  BOTTOM w0.084: 149.36,132.02 149.36,132.42 147.63,134.15 147.63,135.04 147.5,135.17 147,135.17 145.8,136.36 UV1.AB34
  BOTTOM w0.114: RV148.1 149.36,131.36 v2(149.36,131.97) 149.36,132.02
N59727618: length 3.1
  BOTTOM w0.114: v4(174.78,162.42) 174.78,163.92 PD101.1
  BOTTOM w0.254: PD101.1 173.18,163.95 PQ105.1
N59727917: length 3.5
  BOTTOM w0.114: v4(168.2,163.72) 169.37,163.72 PR109.2
  BOTTOM w0.254: PQ105.2 171.14,163.74 PR110.2 PR109.2
N59815935: length 5.6
  TOP w0.114: RV166.1 RV183.2 180.98,123.76 180.98,124.55 180.57,124.96 ; v4(181.29,125.67) 180.57,124.96 ; 180.57,124.96 QV19.5
N59815943: length 19.2
  TOP w0.114: v4(165.68,125.76) 165.54,125.62 RV162.1 166.12,124.63 v3(166.38,124.37) ; v3(177.22,123.67) 177.41,123.48 178.77,123.48 179.61,124.32 179.61,125.47 179.75,125.61 QV19.6
  IN1 w0.14: v3(177.22,123.67) 177.22,124.25 176,125.47 167.47,125.47 v3(166.38,124.37)
N59815947: length 2.1
  TOP w0.114: RV164.2 176.71,124.96 v4(177.68,124.96) QV19.2
N59815979: length 13.5
  TOP w0.114: QV6.2 175.55,130.44 176.08,129.91 176.08,126.3 174.81,125.03 174.81,122.9 RV163.2 CV228.1 172.89,122.01 v4(172.71,121.83)
N59815990:
  vias: v2(169.55,125.87)
N60277905: length 6.4
  TOP w0.114: JLCD.4 98.74,138.84 98.74,135.83 99.09,135.47 v2(99.19,135.47) 99.19,133.95 R21.2
N60939795: length 1.2
  BOTTOM w0.114: v4(169.73,2.48) 169.5,2.71 PR205.1
N60939813: length 1.4
  TOP w0.254: v4(163.63,11.39) PR204.1
N61210253: length 2.4
  TOP w0.254: DA6.1 216.93,14.34 217.61,13.65 v4(217.61,13.32) 217.35,13.07 RA16.2
N61210291: length 2.4
  TOP w0.254: RA22.2 219.18,13.07 219.51,13.4 v4(219.51,13.48) 219.51,13.5 218.68,14.34 DA7.1
N61716887: length 2
  BOTTOM w0.114: PC212.2 165.84,3.27 v4(165.74,3.16)
  BOTTOM w0.254: PR207.1 167.67,3.27 PC212.2
N61905058: length 4.4
  TOP w0.114: JCRT.4 6.39,93.29 7.37,94.27 T26.1
N62243754: length 4.1
  BOTTOM w0.508: RL16.2 18.73,111.62 17.99,112.36 v4(17.94,112.36) 17.35,112.36 16.5,111.51 JRJ452.9
N62244120: length 5.1
  BOTTOM w0.508: RL15.2 18.34,122.52 18.12,122.29 v4(18.07,122.29) 17.43,122.29 16.52,123.21 JRJ452.11
N62639755: length 27.9
  BOTTOM w0.076: UC1.BB68 70.62,82.34 69.88,81.6 68.33,81.6 67.95,81.22 67.3,81.22 66.04,79.95 66.04,78.84
  BOTTOM w0.114: TC31.1 54.2,82.48 54.2,78.87 58.65,74.41 62.44,74.41 62.44,74.41 62.64,74.41 66.04,77.81 66.04,78.84
N62639757: length 26.1
  BOTTOM w0.076: UC1.BB69 70.17,82.2 69.72,81.75 68.27,81.75 67.89,81.37 67.24,81.37 65.79,79.92 65.79,79.08
  BOTTOM w0.114: 65.79,79.08 65.79,77.91 62.54,74.65 58.93,74.65 54.69,78.89 TC32.1
N62639791: length 1.2
  TOP w0.076: TC45.1 102.5,88.95 v3(102.75,89.21)
  BOTTOM w0.076: v3(102.75,89.21) UC1.AK13
N62639793: length 1.7
  TOP w0.076: v3(103.4,89.21) 103.93,88.69 TC46.1
  BOTTOM w0.076: UC1.AK12 v3(103.4,89.21)
N62639820: length 27.4
  BOTTOM w0.076: 115.5,78.22 113.93,79.8 112.26,79.8 111.28,80.78 110.62,80.78 109.22,82.17 UC1.BB2
  BOTTOM w0.114: TC37.1 124.24,87.85 122.79,86.4 122.79,85.71 124.1,84.4 124.1,80.1 121.37,77.37 116.37,77.37 116.3,77.43 116.29,77.43 115.5,78.22
N62639829: length 27.9
  BOTTOM w0.076: UC1.BA3 108.4,82.93 108.9,82.43 108.9,82.2 110.51,80.6 111.19,80.6 112.29,79.5 113.86,79.5 115.5,77.87
  BOTTOM w0.114: 115.5,77.87 116.21,77.15 116.24,77.15 116.26,77.13 121.47,77.13 124.34,80 124.34,84.55 123.07,85.82 123.07,86.27 123.41,86.62 124.2,86.62 TC38.1
N62639863: length 20.7
  TOP w0.114: TC50.1 121.34,77.31 v3(120.59,78.06)
  IN1 w0.076: v3(106.57,85.12) 106.71,85.12 107.31,84.51 108.93,84.51 111.26,82.19 111.26,81.24 112.01,80.49
  IN1 w0.14: v3(120.59,78.06) 120.59,77.92 120.02,77.36 118.54,77.36 118.05,77.84 117.79,77.84 115.14,80.49 112.01,80.49
  BOTTOM w0.076: v3(106.57,85.12) 106.9,85.45 UC1.AU5
N62639865: length 19.9
  TOP w0.114: v3(119.91,78.08) TC51.1
  IN1 w0.076: 112.05,80.75 111.49,81.31 111.49,83.09 110.34,84.24 109.98,84.24 109.55,84.67 107.38,84.67 107.07,84.98 107.07,85.25 v3(106.57,85.75)
  IN1 w0.14: 112.05,80.75 115.26,80.75 117.87,78.14 118.12,78.14 118.65,77.62 119.45,77.62 v3(119.91,78.08)
  BOTTOM w0.076: UC1.AT5 106.91,86.1 v3(106.57,85.75)
N62639899: length 9.2
  BOTTOM w0.076: TC60.1 114.41,108.9 114.41,107.51 113.34,106.44 110.83,106.44 109.53,105.15 109.37,105.15 108.56,104.33 UC1.B3
N62639901: length 6.7
  BOTTOM w0.076: TC62.1 112.66,106.59 110.71,106.59 109.48,105.36 109.12,105.36 UC1.A3
N62640032: length 23
  BOTTOM w0.076: 117.02,90.72 116.54,90.24 116.54,85.82 115.22,84.49 115.22,83 113.39,81.17 112.2,81.17 111.97,81.4 111.97,82.56 110.69,83.85 109.95,83.85 109.88,83.92 109.86,83.92 UC1.AW1
  BOTTOM w0.114: TC64.1 123.07,90.39 119.49,90.39 119.16,90.72 117.02,90.72
N62640090: length 7.2
  TOP w0.114: v3(108.5,103.72) 109.78,105 109.78,105.7 111.23,107.15 111.23,107.91 111.54,108.22 TC55.1
  BOTTOM w0.076: v3(108.5,103.72) 108.11,103.33 UC1.D4
N62640092: length 9.9
  BOTTOM w0.076: TC56.1 114.56,107.05 113.65,106.14 110.86,106.14 UC1.B2
N62640101: length 12
  BOTTOM w0.076: TC58.1 114.92,111.5 114.92,110.2 114.71,110 114.71,106.99 113.71,105.98 111.19,105.98 UC1.C2
N62640103: length 9.4
  TOP w0.114: TC53.1 111.03,109.74 111.03,107.23 109.53,105.73 109.53,105.35 107.8,103.62 107.8,102.72 v3(107.85,102.68)
  BOTTOM w0.076: UC1.D5 107.51,103.01 v3(107.85,102.68)
N62640164: length 12.2
  BOTTOM w0.076: TC65.1 116.13,109.31 115.6,108.78 115.6,108.17 115.83,107.94 115.83,106.75 114.81,105.73 114.81,104.59 113.67,103.44 111.87,103.44 111.26,102.83 109.83,102.83 109.69,102.69 UC1.E1
N62640180: length 10
  BOTTOM w0.076: TC66.1 115.42,106.64 114.38,105.6 114.38,104.46 113.52,103.6 111.79,103.6 111.24,103.04 109.39,103.04 UC1.E2
N62640214: length 29.9
  BOTTOM w0.076: 110.62,79.86 109.98,79.86 107.63,82.21 107.63,82.46 107.74,82.57 UC1.BA4
  BOTTOM w0.101: 110.62,79.86 112.33,78.15
  BOTTOM w0.114: TC68.1 127.62,86.04 125.3,83.73 125.3,79.6 121.85,76.14 114.34,76.14 112.33,78.15
N62640216: length 27.9
  BOTTOM w0.076: 110.91,80.03 110.17,80.03 107.92,82.28 UC1.BB4
  BOTTOM w0.102: 110.91,80.03 112.64,78.3
  BOTTOM w0.114: TC70.1 126.37,85.14 125.06,83.83 125.06,79.7 121.75,76.39 114.56,76.39 112.64,78.3
N62640259: length 7.3
  BOTTOM w0.076: TC72.1 112.63,107.99 112.78,107.84 112.78,107.4 112.32,106.95 110.57,106.95 109.33,105.7 108.75,105.7 108.66,105.62 108.07,105.03 UC1.A4
N62640261: length 10
  BOTTOM w0.076: TC74.1 113.37,110.23 113.37,107.74 112.41,106.78 110.63,106.78 109.38,105.53 108.8,105.53 108.4,105.13 108.4,104.79 107.99,104.37 UC1.C4
N62640281: length 14.8
  TOP w0.114: TC76.1 114.79,71.29 114.79,72.76 v3(113.34,74.21)
  BOTTOM w0.076: 112.1,77.33 109.94,79.49 109.84,79.49 107.16,82.17 UC1.BB5
  BOTTOM w0.114: v3(113.34,74.21) 113.34,74.72 112.66,75.4 112.66,76.77 112.1,77.33
N62640313: length 26.9
  BOTTOM w0.076: 115.5,78.58 113.93,80.15 112.15,80.15 110.89,81.41 110.89,82.25 110.02,83.12 109.56,83.12 UC1.AY2
  BOTTOM w0.114: TC67.1 122.54,87.03 122.54,85.62 123.86,84.3 123.86,80.2 121.27,77.61 116.47,77.61 115.5,78.58
N62640315: length 26.1
  BOTTOM w0.076: 115.5,79.11 114.1,80.51 112.01,80.51 111.17,81.34 111.17,82.18 109.9,83.45 UC1.AY1
  BOTTOM w0.114: 115.5,79.11 116.06,78.55 121.19,78.55 122.91,80.27 122.91,80.59 123.44,81.12 123.44,84.38 122.26,85.56 122.26,87.29 123.12,88.15 TC69.1
N62640335: length 9.7
  BOTTOM w0.076: UC1.D1 111.32,103.35 111.99,104.03 111.99,104.21 112.48,104.69 112.86,104.69 115.02,106.84 115.02,108.78 TC71.1
N62640353: length 12.3
  BOTTOM w0.076: UC1.D3 109.1,103.26 109.48,103.65 111.36,103.65 111.84,104.13 111.84,104.38 112.35,104.89 112.83,104.89 114.86,106.92 114.86,109.49 115.7,110.33 TC73.1
N62640386: length 9.6
  TOP w0.114: v3(73.87,108.37) 73.84,108.4 TC86.1
  IN1 w0.14: v3(73.87,108.37) 74.83,107.41 75.54,107.41 75.93,107.02 75.93,102.1 75.66,101.83 v3(75.48,101.83)
  BOTTOM w0.076: v3(75.48,101.83) UC1.F60
N62640584: length 2.2
  TOP w0.076: TC75.1 83.06,101.51 v3(82.78,101.23)
  BOTTOM w0.076: v3(82.78,101.23) 82.78,100.93 83.25,100.46 UC1.K46
N62640593: length 2.6
  TOP w0.076: TC77.1 83.13,99.49 84.15,99.49 v3(84.16,99.48)
  BOTTOM w0.076: v3(84.16,99.48) UC1.K45
N62640620: length 38.3
  TOP w0.114: v3(116.64,69.25) 115.98,69.92 114.64,69.92 TC79.1
  IN1 w0.076: 114.23,71.42 112.78,72.86 111.88,72.86 111.25,73.5 109.5,73.5 109.12,73.88 109.12,78.66 106.19,81.6 105.1,81.6 104.31,82.39 103.9,82.39 102.76,83.53 101.2,83.53 99.77,84.95 99.77,88.94 99.24,89.47 96.05,89.47 v3(95.59,89.93)
  IN1 w0.14: 114.23,71.42 115.93,69.71 116.21,69.71 116.64,69.28 v3(116.64,69.25)
  BOTTOM w0.076: UC1.AL25 v3(95.59,89.93)
N62640629: length 41.1
  TOP w0.114: v3(116.01,69.25) 115.93,69.18 113.62,69.18 TC81.1
  IN1 w0.076: 114.23,71.04 112.58,72.68 111.84,72.68 111.23,73.29 109.38,73.29 108.95,73.72 108.95,78.48 106.06,81.37 105.11,81.37 104.25,82.23 103.84,82.23 102.7,83.38 101.14,83.38 99.8,84.72 99.1,84.72 98.76,85.05 98.76,89.14 98.58,89.32 95,89.32 v3(94.11,90.21)
  IN1 w0.14: v3(116.01,69.25) 116.01,69.26 114.23,71.04
  BOTTOM w0.076: v3(94.11,90.21) 94.49,89.83 94.49,89.36 UC1.AL27
N62640656: length 8.9
  BOTTOM w0.076: 65.46,107.35 66.16,106.64 66.99,106.64 67.85,105.79 67.85,104.48 68.48,103.85 UC1.C71
  BOTTOM w0.114: TC82.1 63.56,109.25 65.46,107.35
N62640665: length 22.1
  BOTTOM w0.076: 65.63,107.52 66.31,106.83 67.02,106.83 68.05,105.8 68.05,104.51 68.38,104.18 69.53,104.18 UC1.B70
  BOTTOM w0.114: 65.63,107.52 64.2,108.94 64.2,109.88 62.29,111.8 54.16,111.8 TC83.1
N62640692: length 5.6
  BOTTOM w0.076: TC88.1 79.94,109.56 79.84,109.46 79.84,108.37 80.3,107.91 80.3,107.33 80.02,107.05 80.02,106.31 80.37,105.96 80.37,105.07 80.26,104.96 UC1.A52
N62640710: length 11
  TOP w0.114: v3(63.51,77.08) 62.67,76.24 TP92.1
  BOTTOM w0.076: 65.04,79.83 67.09,81.88 67.6,81.88 68.84,83.12 69.53,83.12 UC1.BA70
  BOTTOM w0.114: 65.04,79.83 64.5,79.29 64.5,78.07 v3(63.51,77.08)
N62640712: length 11.6
  TOP w0.114: TP93.1 64.12,75.86 v3(63.56,76.42)
  BOTTOM w0.076: 65.22,79.66 67.24,81.68 67.87,81.68 68.12,81.92 69.56,81.92 69.84,82.2 69.84,82.42 70.34,82.92 UC1.BA68
  BOTTOM w0.114: v3(63.56,76.42) 65.13,77.99 65.13,79.57 65.22,79.66
N62640746: length 18.4
  TOP w0.114: v3(64.09,103.32) 64.5,103.32 64.61,103.43 64.61,105.92 64.04,106.49 64.04,107.74 63.32,108.45 63.32,112.99 TC94.1
  BOTTOM w0.076: 64.57,102.99 67.45,100.11 69.03,100.11 UC1.J71
  BOTTOM w0.114: v3(64.09,103.32) 64.24,103.32 64.57,102.99
N62640748: length 18.5
  TOP w0.114: TC95.1 63.08,111.61 63.08,108.35 63.8,107.64 63.8,106.39 64.37,105.82 64.37,104.22 64.1,103.95 v3(63.84,103.95)
  BOTTOM w0.076: 64.57,103.47 67.77,100.27 68.77,100.27 68.85,100.35 69.16,100.35 69.27,100.3 69.49,100.3 69.6,100.35 69.81,100.35 69.89,100.31 70.17,100.31 70.2,100.35 70.51,100.35 70.55,100.31 70.86,100.31 UC1.J68
  BOTTOM w0.114: 64.57,103.47 64.09,103.95 v3(63.84,103.95)
N62640782: length 15
  TOP w0.114: v3(73.82,107.08) 73.6,106.86 72.02,106.86 71.54,106.38 69.62,106.38 68.89,107.11 68.89,107.76 68.69,107.96 TC99.1
  IN1 w0.14: v3(74.56,101.2) 74.99,101.62 74.99,102.83 75.15,103 75.15,104.02 73.82,105.35 v3(73.82,107.08)
  BOTTOM w0.076: UC1.F61 v3(74.56,101.2)
N62640818: length 10.2
  TOP w0.114: v3(69.59,84.22) 69.25,84.22 TC103.1
  BOTTOM w0.076: v3(69.59,84.22) 69.69,84.11 69.88,84.11 UC1.AW69
N62640820: length 9.8
  TOP w0.114: TC102.1 64.32,78.63 67.39,81.7 68.61,81.7 70.2,83.29 v3(70.2,83.52)
  BOTTOM w0.076: v3(70.2,83.52) UC1.AW68
N62640854: length 16.1
  TOP w0.114: TC106.1 65.97,79.47 67.42,80.91 70.62,80.91 74.33,84.62 76.81,84.62 v3(77.31,85.12)
  BOTTOM w0.076: UC1.AU56 v3(77.31,85.12)
N62640856: length 26.5
  TOP w0.114: TC108.1 68.69,73.27 79.05,73.27 v3(80.54,74.76)
  BOTTOM w0.076: 80.98,78.54 81.1,78.66 81.1,79.58 81.8,80.28 81.8,80.95 82.02,81.16 82.02,81.98 82.12,82.08 82.12,82.92 82.31,83.1 82.31,83.84 82.64,84.18 UC1.AW48
  BOTTOM w0.102: 80.98,78.54 80.98,75.2 v3(80.54,74.76)
N62640904: length 8.6
  BOTTOM w0.076: UC1.C7 106.46,103.96 106.46,105.25 107.7,106.49 108.97,106.49 111.08,108.6 TC110.1
N62640906: length 29.7
  IN3 w0.076: v3(103.4,95.46) 103.4,95.73 103.13,96 102.52,96 102.24,96.28 102.24,96.84 102.6,97.19 108.91,97.19
  IN3 w0.114: 108.91,97.19 114.74,97.19 115.12,97.58 117.38,97.58 117.99,96.97 119.26,96.97 119.97,96.26 122.46,96.26 123.18,95.53 123.18,95.25 123.88,94.56 123.88,92.97 124.38,92.47 v3(124.92,92.47)
  BOTTOM w0.076: UC1.U12 v3(103.4,95.46)
  BOTTOM w0.114: v3(124.92,92.47) 124.87,92.47 TC112.1
N62640922: length 32.8
  IN3 w0.076: v3(104.04,95.46) 104.04,95.53 103.41,96.15 102.58,96.15 102.39,96.34 102.39,96.78 102.66,97.04 108.71,97.04 108.94,96.81
  IN3 w0.114: v3(125.91,91.89) 125.91,91.54 125.66,91.29 125.22,91.29 123.64,92.87 123.64,94.46 122.94,95.15 122.94,95.37 122.41,95.9 119.94,95.9 119.16,96.69 117.71,96.69 117.07,97.32 115.13,97.32 114.62,96.81 108.94,96.81
  BOTTOM w0.076: UC1.U11 v3(104.04,95.46)
  BOTTOM w0.114: v3(125.91,91.89) 126.42,91.38 TC114.1
N62640924: length 18.4
  TOP w0.114: v1(111.36,104.18) 111.84,104.18 112.55,104.89 112.55,106.06 114.03,107.53 114.03,109.26 TC116.1
  IN3 w0.076: v3(102.91,100.56) 103.38,101.03 103.38,102.61 103.82,103.04 107.19,103.04 107.4,103.24 110.83,103.24 111.36,103.77 v1(111.36,104.18)
  BOTTOM w0.076: v3(102.91,100.56) UC1.H11
N62641188: length 19
  TOP w0.076: v1(112.96,104.05) 112.96,105.88 114.43,107.35 114.43,109.79 114.24,109.98 114.24,111.61 TC104.1
  IN3 w0.076: v3(105.65,101.83) 105.78,101.83 106.08,101.54 106.08,101.03 106.38,100.73 106.67,100.73 107.33,101.39 108.44,101.39 109.86,102.81 111.36,102.81 111.87,103.32 112.6,103.32 112.96,103.67 v1(112.96,104.05)
  BOTTOM w0.076: UC1.F6 v3(105.65,101.83)
N62641190: length 14.1
  TOP w0.114: TC105.1 114.76,107.41 114.13,106.77 v3(114.13,102.91)
  BOTTOM w0.076: v3(114.13,102.91) 113.75,103.29 111.94,103.29 111.31,102.66 110.08,102.66 109.82,102.4 108.67,102.4 UC1.E3
N62641192: length 20.3
  BOTTOM w0.076: UC1.C11 103.87,103.97 103.95,104.23 103.95,104.4 103.89,104.59 103.89,104.74 103.95,104.86 104.04,104.94 104.04,105.8 104.32,106.08 105.27,106.08 108.16,108.98
  BOTTOM w0.114: 108.16,108.98 108.16,110.43 109.2,111.47 109.2,114.23 108.18,115.24 108.18,120.51 TC107.1
N62641208: length 20
  BOTTOM w0.076: UC1.B11 103.56,104.43 103.56,104.66 103.42,104.81 103.42,105.12 103.71,105.41 103.71,105.9 104.25,106.44 105.19,106.44 107.58,108.83 107.58,109.39
  BOTTOM w0.114: 107.58,109.39 107.58,110.74 108.64,111.8 108.64,114.02 107.55,115.11 107.55,118.76 107.04,119.27 107.04,120.26 TC109.1
N62641224: length 20.7
  BOTTOM w0.076: 107.8,109.51 107.8,108.84 105.23,106.26 104.29,106.26 103.87,105.85 103.87,105.15 UC1.A11
  BOTTOM w0.114: 107.8,109.51 107.8,110.56 108.9,111.65 108.9,114.15 107.79,115.25 107.79,118.9 107.37,119.32 107.37,121.45 TC111.1
N62641226: length 18.5
  BOTTOM w0.076: 107.37,109.44 107.37,108.84 105.15,106.62 104.21,106.62 103.54,105.95 103.54,105.49 103.25,105.19 103.25,104.5 103.41,104.34 103.41,103.87 103.12,103.58 UC1.D12
  BOTTOM w0.114: 107.37,109.44 107.37,110.89 108.36,111.88 108.36,113.92 106.74,115.55 TC113.1
N62641228: length 16.5
  BOTTOM w0.076: UC1.C12 103.12,104.38 103.01,104.48 103.01,105.21 103.38,105.57 103.38,106 104.15,106.77 105.09,106.77 107.14,108.82 107.14,109.39
  BOTTOM w0.114: TC115.1 106.13,114.63 108.08,112.68 108.08,111.98 107.14,111.04 107.14,109.39
N62641230: length 4.6
  TOP w0.076: TC117.1 81.36,100.9 81.21,100.75 80.7,100.75 80.51,100.94 80.51,101.37 v3(80.05,101.83)
  BOTTOM w0.076: UC1.F52 v3(80.05,101.83)
N62685817: length 17.4
  TOP w0.254: RC121.1 97.69,114.93 97.69,114.3 96.51,113.13 96.51,110.94 94.1,108.52 93.63,108.52 v1(93.47,108.36)
  IN3 w0.254: v1(93.47,108.36) 92.96,107.85 92.96,107.36 91.01,105.41 91.01,103.39 90.56,102.94 90.56,102.3 90.56,102.29 90.56,102.28 90.83,102.01 90.84,102.01 v3(91.02,101.83)
  BOTTOM w0.254: UC1.E32 91.07,101.83 v3(91.02,101.83)
N62687376: length 16.3
  TOP w0.254: v3(93.53,107.56) 94.09,108.12 94.26,108.12 96.89,110.75 96.89,112.97 98.16,114.24 98.16,114.84 RC142.1
  IN3 w0.254: v3(93.53,107.56) 93.34,107.37 93.34,107.1 91.42,105.18 91.42,102.86 v3(91.02,102.47)
  BOTTOM w0.254: v3(91.02,102.47) 90.79,102.47 UC1.E33
N62693311: length 16.9
  TOP w0.114: v3(116.69,108.4) 116.92,108.62 116.92,109.11 116.77,109.26 RC385.1 v4(116.41,110.48)
  IN1 w0.14: v3(106.57,102.47) 106.81,102.22 106.99,102.22 107.17,102.4 107.17,103.17 107.55,103.55 107.55,103.8 110.34,106.59 113.26,106.59 114.53,107.86 116.62,107.86 116.83,108.08 116.83,108.26 v3(116.69,108.4)
  BOTTOM w0.114: UC1.E5 v3(106.57,102.47)
N62870607: length 29.1
  TOP w0.114: v3(111.64,73.65) 111.64,73.21 112.12,72.72 113,72.72 113.37,72.35 113.37,70.55 T56.1
  IN3 w0.114: v3(102.91,87.66) 103.36,87.21 103.36,84.23 103.93,83.66 104.88,83.66 105.9,82.64 107.24,82.64 111.05,78.83 111.05,78.09 113.21,75.94 113.21,75.15 113.75,74.61 113.75,73.34 113.32,72.91 112.02,72.91 111.64,73.29 v3(111.64,73.65)
  BOTTOM w0.076: v3(102.91,87.66) 103.3,88.05 UC1.AN11
N62870645: length 32.5
  TOP w0.114: v3(115.91,66.54) 115.5,66.13 114.53,66.13 T57.1
  IN3 w0.076: v3(101.99,87.66) 101.77,87.66 101.46,87.35 101.46,84.77 101.7,84.53 102,84.53
  IN3 w0.114: v3(115.91,66.54) 115.91,68.62 114.41,70.12 113.23,70.12 111.76,71.59 111.76,72.9 111.16,73.5 111.16,74.09 111.47,74.41 111.47,76.56 110.31,77.72 110.31,78.68 107.12,81.88 105.37,81.88 104.34,82.9 103.63,82.9 102,84.53
  BOTTOM w0.076: v3(101.99,87.66) 102.39,88.05 UC1.AN13
N62959739: length 16.8
  TOP w0.114: v3(60.1,109.17) 60.26,109.01 v4(60.76,109.01)
  TOP w0.254: v3(60.1,109.17) 60.1,109.97 RC124.2
  IN1 w0.254: v3(64.2,102.59) 64,102.59 63.1,103.49 63.1,106.11 60.1,109.11 v3(60.1,109.17)
  BOTTOM w0.076: UC1.J70 69.56,100.08 69.42,99.94 69.41,99.94 69.41,99.93 69.16,99.82 68.73,99.82 68.61,99.94 66.85,99.94 66.45,100.34
  BOTTOM w0.254: 66.45,100.34 v3(64.2,102.59)
N62959779: length 18.4
  TOP w0.114: v3(59.41,109.17) 59.28,109.03 v4(58.73,109.03)
  TOP w0.254: RC183.2 59.41,109.98 v3(59.41,109.17)
  IN1 w0.254: v3(63.59,102.06) 62.64,103.01 62.64,105.78 59.41,109.01 v3(59.41,109.17)
  BOTTOM w0.076: 66.66,99.78 68.54,99.78 68.67,99.65 69.19,99.65 69.6,99.82 69.89,99.82 70.15,100.08 UC1.J69
  BOTTOM w0.254: 66.66,99.78 66.65,99.76 66.15,99.76 63.85,102.06 v3(63.59,102.06)
N62960030: length 17.5
  TOP w0.254: RC185.1 99.8,114.52 98.35,113.07 v3(98.35,112.74)
  IN1 w0.254: v3(98.35,112.74) 97.49,112.74 97.14,112.38 97.14,108.52 97.47,108.19 97.47,103.32 96.97,102.82 96.97,100.92 97.34,100.54 v3(97.42,100.54)
  BOTTOM w0.254: UC1.H21 97.68,100.29 v3(97.42,100.54)
N62960070: length 17.5
  TOP w0.254: v3(98.35,112.1) 98.47,112.1 98.99,112.63 98.99,113.01 100.72,114.73 RC126.1
  IN1 w0.254: v3(98.35,112.1) 97.64,112.1 97.52,111.98 97.52,108.73 97.88,108.36 97.88,100.95 98.27,100.56 v3(98.34,100.56)
  BOTTOM w0.254: v3(98.34,100.56) 98.61,100.29 UC1.H20
N63158955: length 2.6
  TOP w0.076: T21.1 100.87,89.7 101.45,89.12 101.45,88.67 v3(101.08,88.29)
  BOTTOM w0.076: UC1.AM15 v3(101.08,88.29)
N63295136: length 1.6
  TOP w0.254: PC203.1 163.56,6.42 v4(163.38,6.24)
N63299821: length 0.8
  BOTTOM w0.254: PC229.2 186.82,10.05 PR215.1
N63299840: length 2.9
  BOTTOM w0.114: v4(189.11,8.12) 189.11,8.6 PR211.2
  BOTTOM w0.254: PR209.2 PR210.2 188.55,9.16 PR211.2
N63300161: length 1.2
  TOP w0.254: PC226.2 192.11,2.83 v4(192.94,2.83)
N63300165: length 1.2
  TOP w0.254: PR212.2 191.88,7.56 v4(191.88,8.65)
N63360063: length 12.3
  TOP w0.254: v3(184.77,131.59) 185.22,131.59 RV150.2 ; v3(189.65,127.47) QV17.2
  TOP w0.381: v4(183.6,132.22) 185.12,132.22 185.4,131.94 RV150.2
  IN1 w0.254: v3(189.65,127.47) 186.24,127.47 185.43,128.28 185.43,129.2 184.28,130.34 184.28,131.1 v3(184.77,131.59)
N63360075: length 13.8
  TOP w0.114: v4(181.08,131.08) 181.18,131.18 RV143.1
  TOP w0.254: QV17.1 v3(190.3,129.1) ; v3(184.92,130.44) 183.44,130.44 182.71,131.18 RV143.1
  IN1 w0.254: v3(184.92,130.44) 184.92,131 185.32,131.41 186.25,131.41 186.54,131.11 186.54,129.33 187.48,128.39 189.59,128.39 v3(190.3,129.1)
N63360089: length 10
  TOP w0.381: RV185.2 CV229.1 185.58,126.71 185.2,127.09 v3(185.2,127.62)
  IN1 w0.381: v5(182.07,132.27) 182.07,130.75 v3(185.2,127.62)
  BOTTOM w0.381: v5(182.07,132.27) 182.1,132.25 QV9.4
N64244043: length 3.7
  TOP w0.114: v4(171.81,132.91) 171.81,131.09 QV4.1 172.01,130.89 RV110.1
N64344808: length 16.5
  TOP w0.114: RV181.1 169.73,156.71 v4(169.73,157.98)
  TOP w0.254: RV181.1 v3(170.62,156.63) RV92.2 ; v3(162.25,152.43) 162.82,152.99 RV133.1 RV179.2 162.85,153.94 UV14.3
  IN3 w0.254: v3(170.62,156.63) 168.08,154.09 163.38,154.09 162.36,153.07 162.36,152.54 v3(162.25,152.43)
N64344810: length 9.5
  TOP w0.114: v4(165.59,160.64) 166.1,160.14 RV180.1 165.44,159.55 164.56,158.67 164.23,158.67 163.2,157.65 RV127.1 162.82,156.38 RV91.2 RV178.2 163.23,154.44 UV14.2
N64344836: length 4.2
  TOP w0.254: UV14.5 167.94,153.44 v2(167.96,153.46) CV206.1
  TOP w0.381: CV208.1 168.89,155.25 RV134.1 CV206.1
N64344870: length 4.7
  TOP w0.114: RV96.1 165.46,157.49 v4(165.13,157.49)
  TOP w0.254: UV14.7 166.08,154.44 165.79,154.73 165.79,156.5 RV96.1
N64344872: length 7.8
  TOP w0.114: RV97.1 167.24,160.11 v4(167.34,160.21)
  TOP w0.254: RV97.1 167.24,158.69 168.08,157.85 168.08,154.12 167.9,153.94 UV14.6
N67782265: length 8.9
  IN1 w0.254: v3(106.58,93.33) 109.4,93.33 109.94,93.87 111.08,93.87 111.46,93.49 111.89,93.49 112.32,93.92 v3(112.32,93.99)
  BOTTOM w0.254: RC378.1 113.42,93.59 112.58,93.59 112.32,93.84 v3(112.32,93.99) ; v3(106.58,93.33) 106.36,93.69 UC1.AB7
N67912715: length 18.3
  TOP w0.508: v3(119.36,88.64) 119.36,89.38 RC389.1
  IN1 w0.305: v3(119.36,88.64) 119.36,86.25 119.03,85.92 118.13,85.92 114.99,82.78 113.53,82.78 113.09,83.22 113.09,86.08 112.72,86.45 110.52,86.45 v3(110.28,86.21)
  BOTTOM w0.203: UC1.AT1 v3(110.28,86.21)
N68010119: length 2.7
  BOTTOM w0.114: UTPM1.27 113.58,119.53 v4(112.83,118.78) 111.9,118.78 R9484.2
N68061247: length 5.6
  TOP w0.114: UA1.11 206.73,24.69 205.24,26.18 v4(204.98,26.18) 204.7,26.18 204.48,25.95 CA16.2
N68061309: length 4.2
  TOP w0.114: CA17.2 204.82,17.78 204.97,17.78 205.24,18.05 205.24,19.27 205.39,19.42 v2(205.47,19.42) 205.64,19.42 205.67,19.39 UA1.19
N68061311: length 2.8
  TOP w0.114: UA1.20 206.2,18.99 205.59,18.38 v2(205.59,18.15) 205.59,17.64 CA17.1
N68137601: length 6.1
  TOP w0.114: RC296.1 108.59,83 109.71,81.88 v1(110.34,81.88)
  BOTTOM w0.076: v1(110.34,81.88) 109.78,81.88 109.54,82.12 109.54,82.48 109.43,82.59 109.39,82.62 109.28,82.65 108.92,82.65 108.7,82.88 108.7,83.32 UC1.AY3
N68137603: length 14.5
  TOP w0.114: v3(60,75.12) 59.65,75.48 RC295.1 v4(58.22,75.48)
  BOTTOM w0.076: 64.85,80.02 66.86,82.03 67.52,82.03 68.94,83.45 UC1.AY71
  BOTTOM w0.114: v3(60,75.12) 60,75.17 64.85,80.02
N68137613: length 7.7
  TOP w0.114: RC391.2 70.9,108.47 v3(70.08,107.66)
  BOTTOM w0.076: v3(70.08,107.66) 70.85,106.9 72.13,106.9 73.29,105.74 73.29,104.26 73.38,104.17 UC1.C64
N68137683: length 8.8
  BOTTOM w0.076: UC1.A69 69.85,105.28 68.78,105.28 67.07,107 66.49,107 65.8,107.69
  BOTTOM w0.114: TC78.1 64.57,108.92 65.8,107.69
N68137699: length 8.2
  BOTTOM w0.076: 65.97,107.86 66.65,107.18 67.11,107.18 68.84,105.45 70.12,105.45 70.47,105.09 70.47,104.62 70.47,104.62 70.47,104.47 UC1.B69
  BOTTOM w0.114: 65.97,107.86 65.08,108.75 TC80.1
N68137715: length 21.9
  BOTTOM w0.076: UC1.D71 68.7,103.2 67.54,104.36 67.54,105.63 66.86,106.31 65.81,106.31 65.12,107.01
  BOTTOM w0.114: 65.12,107.01 62.03,110.09 62.03,110.76 61.23,111.56 54.43,111.56 53.63,110.76 53.63,109.46 TC84.1
N68137731: length 11.3
  BOTTOM w0.076: 65.29,107.18 66,106.47 66.95,106.47 67.7,105.72 67.7,104.42 68.57,103.55 69.55,103.55 UC1.C70
  BOTTOM w0.114: TC85.1 62.62,109.85 65.29,107.18
N68137747: length 14.8
  TOP w0.076: v3(78.59,107.91) 78.54,107.91 78.35,108.1
  TOP w0.114: TC87.1 79.61,114.35 78.47,113.21 78.47,112.01 77.81,111.36 77.81,110.45 78.05,110.21 78.05,108.41 78.35,108.1
  BOTTOM w0.076: UC1.C54 79.09,103.97 79.17,104.23 79.17,104.4 79.11,104.59 79.11,104.74 79.17,104.86 79.17,105.12 79.02,105.27 79.02,106.21 78.19,107.05 78.19,107.51 v3(78.59,107.91)
N68137763: length 15.4
  TOP w0.076: v3(78.59,107.28) 77.81,108.07 77.81,108.1
  TOP w0.114: TC89.1 78.23,116.31 79.18,115.36 79.18,114.26 78.2,113.29 78.2,112.09 77.57,111.47 77.57,110.35 77.81,110.11 77.81,108.1
  BOTTOM w0.076: UC1.D54 79.12,103.34 79.2,103.61 79.2,103.72 79.33,104.2 79.33,104.45 79.3,104.54 79.3,104.73 79.33,104.83 79.33,105.19 79.19,105.34 79.19,106.28 78.59,106.87 v3(78.59,107.28)
N68137779: length 30.9
  BOTTOM w0.076: UC1.AY4 108.13,83.12 108.13,82.55 108.27,82.42 108.27,82.21 110.21,80.27 110.97,80.27 112.64,78.59 112.83,78.59 114.8,76.63 115.5,76.63
  BOTTOM w0.114: 115.5,76.63 121.65,76.63 124.82,79.8 124.82,83.94 126.02,85.13 126.02,86.3 TC91.1
N68137795: length 27.8
  BOTTOM w0.076: 115.5,77.51 113.86,79.15 112.37,79.15 111.09,80.43 110.44,80.43 108.57,82.3 UC1.BB3
  BOTTOM w0.114: 115.5,77.51 116.12,76.89 121.57,76.89 124.58,79.9 124.58,84.13 125.76,85.31 125.76,87.42 TC93.1
N68137811: length 3.6
  TOP w0.114: TC96.1 76.87,88.3 76.87,86.83 v3(77.31,86.39)
  BOTTOM w0.076: UC1.AR56 v3(77.31,86.39)
N68137827: length 12.9
  TOP w0.114: TC97.1 60.79,77.28 v3(60.03,77.28)
  BOTTOM w0.076: UC1.AW71 69,84.1 67.32,82.41 66.43,82.41
  BOTTOM w0.102: v3(60.03,77.28) 61.3,77.28 66.43,82.41
N68137843: length 13.9
  TOP w0.114: v3(60.05,75.86) TC98.1
  BOTTOM w0.076: 66.6,82.23 67.39,82.23 68.91,83.75 69.28,83.75 69.41,83.62 UC1.AW70
  BOTTOM w0.102: 66.6,82.23 60.33,75.96
  BOTTOM w0.114: 60.33,75.96 60.23,75.86 v3(60.05,75.86)
N68139906: length 3.4
  TOP w0.114: v3(77.31,87.02) 77.62,87.02 79.13,88.53 TC100.1
  BOTTOM w0.076: UC1.AP56 v3(77.31,87.02)
N68447222: length 0.9
  TOP w0.114: RC47.2 TC18.1
N68512911: length 2.5
  TOP w0.114: RW11.2 54.13,29.88 53.02,31 UW1.28
N68512942: length 3.6
  TOP w0.203: 47.59,32.87 47.87,32.6 UW1.9
  TOP w0.508: 47.59,32.87 47.12,33.34 47.12,33.85 v2(46.74,34.23) 45.8,34.23 RW8.2
N68512946: length 3.5
  TOP w0.203: RW20.2 54.13,33.24 53.73,33.64 v2(53.45,33.64) 53.24,33.44 53.24,33.05 52.79,32.6 UW1.32
N68513948:
  vias: v4(195.84,69.08)
N68514036: length 3.5
  TOP w0.254: RG6.1 204.04,71.87 v4(204.04,70.83) 205.28,69.59 UGSEN1.8
N68520625: length 2.5
  BOTTOM w0.114: RW16.2 28.2,33.01 28.53,32.68 v4(28.84,32.68) 29.14,32.98 CW14.1
N68576329: length 3
  TOP w0.114: UC3.4 47.74,109.02 RC348.1 RC48.1 47.73,107.2 v4(47.91,107.02)
N68614825: length 3.2
  TOP w0.114: v2(226.82,154.41) 227.08,154.67 227.08,154.68 PR18.1
  TOP w0.508: PD6.2 228.59,153.59 PR19.2 227.74,154.71 PR18.1
N68925385: length 10.5
  TOP w0.254: RL24.2 CL17.1 v4(59.67,121.2) 58.6,122.26 58.6,123.36 58.07,123.89 53.96,123.89 QL2.2
N68926087: length 5.8
  TOP w0.114: Q26.2 216.57,36.87 v4(215.88,37.56) 215.19,37.56 C75.1 R51.2
N69409003:
  vias: v1(32.57,83.03) v1(32.95,83.48) v1(34.09,82.97) v1(34.54,83.42) v4(31.25,84.24)
N69409147: length 4
  TOP w0.305: UVG2.10 29.58,91.51 29.88,91.81 30.64,91.81 v4(31.12,92.29) 30.16,93.26 CVG43.2
N69638631: length 2.8
  BOTTOM w0.114: PR216.2 v4(175.85,3.9)
  BOTTOM w0.254: PR216.2 174.71,4.71 PQ201.3 PQ201.2
N69643262: length 1.2
  TOP w0.114: TC118.1 101.87,87.02 v3(101.99,87.02)
  BOTTOM w0.076: v3(101.99,87.02) 102.37,87.4 UC1.AP13
N69649315: length 2.5
  TOP w0.114: v4(171.89,169.71) CV239.1
  TOP w0.305: CV239.1 172.41,171.25 UV12.6
N69711319: length 7.8
  BOTTOM w0.076: TC119.1 73.44,108.62 73.44,106.78 74.23,105.99 74.23,105.34 74.38,105.19 74.38,104.83 74.34,104.73 74.34,104.54 74.38,104.45 74.38,104.2 74.24,103.72 74.24,103.61 74.16,103.34 UC1.D63
N69867788: length 2.4
  TOP w0.114: v4(109.91,139.31) 110.04,139.44 RV197.1
  TOP w0.381: RV197.1 111.03,138.77 v1(111.03,138.77)
  BOTTOM w0.254: UV6.J10 111.03,138.68 111.03,138.77 v1(111.03,138.77)
N69867866: length 2.3
  TOP w0.254: RV195.1 103.64,139.99 103.36,139.71 103.36,139.01 v1(103.11,138.76)
  BOTTOM w0.254: v1(103.11,138.76) UV6.J1
N69867911: length 4.8
  BOTTOM w0.114: RV194.1 116.63,137.33 v4(117.46,137.33)
  BOTTOM w0.254: UV6.J13 113.51,137.96 114.55,137.96 115.02,137.5 RV194.1
N69916609: length 1.9
  TOP w0.381: RV200.1 110.33,159.6 v1(111.11,160.39)
  BOTTOM w0.254: UV5.J10 111.11,160.38 v1(111.11,160.39)
N69916637: length 2.3
  TOP w0.114: v4(101.38,160.39) 101.41,160.36 RV199.1
  TOP w0.381: RV199.1 102.52,160.15 v1(103.04,160.15)
  BOTTOM w0.305: UV5.J1 103.21,159.98 v1(103.04,160.15)
N69916654: length 7
  BOTTOM w0.114: v4(117.46,155.74) 116.91,155.74 RV198.1
  BOTTOM w0.254: UV5.J13 113.51,159.58 114.55,159.58 115.02,159.12
  BOTTOM w0.381: RV198.1 115.02,157.64 115.02,159.12
N69928133: length 3
  TOP w0.381: v4(132.62,178.93) RV203.1 132.62,177.47 133,177.09 v1(133.41,177.09)
  BOTTOM w0.254: v1(133.41,177.09) 133.4,177.09 UV7.J10
N69928161: length 2.4
  TOP w0.114: RV202.1 133.2,186.02 v4(132.39,186.02)
  TOP w0.254: v1(133.4,185.09) 133.38,185.11 RV202.1
  BOTTOM w0.254: v1(133.4,185.09) UV7.J1
N69928178: length 4.8
  BOTTOM w0.114: RV201.1 132.14,170.93 v4(131.93,170.73)
  BOTTOM w0.254: RV201.1 132.14,173.19 132.6,173.65 132.6,174.69 UV7.J13
N69934691: length 2.7
  TOP w0.114: RV205.1 154.54,177.94 v4(153.63,177.94)
  TOP w0.254: RV205.1 154.66,177.84 v1(155.41,177.09)
  BOTTOM w0.254: v1(155.41,177.09) 155.4,177.09 UV8.J10
N69934709: length 2.3
  TOP w0.114: RV206.1 v4(155.38,186.78)
  TOP w0.254: v1(155.4,185.09) 155.38,185.11 RV206.1
  BOTTOM w0.254: UV8.J1 v1(155.4,185.09)
N69934726: length 4.9
  BOTTOM w0.114: v4(153.83,170.7) 154.14,171.01 RV204.1
  BOTTOM w0.254: RV204.1 154.14,173.19 154.6,173.65 154.6,174.69 UV8.J13
N71613177:
  vias: v2(78.54,131.68)
N71720577: length 4.6
  TOP w0.114: v2(164.59,177.27) 164.76,177.45 RV210.1
  TOP w0.381: RV210.1 CV241.1 164.76,180.85 165.06,181.14 QV23.2
N71772349: length 2.8
  TOP w0.114: U149.2 129.54,66.97 129.34,67.17 129.34,67.3
  TOP w0.254: 129.34,67.3 R9488.1 128.47,67.98 D15.2
N71772380: length 2.2
  TOP w0.114: U149.5 129.54,64.2 C747.2 129.5,64.15 v4(128.48,64.15)
N71772404: length 2.7
  TOP w0.114: Q6.3 208.32,137.38 R159.2 210.78,137.38 v4(210.9,137.25)
N71772436: length 5.6
  TOP w0.254: R9487.2 C8540.1 68.08,55.41 Q23.4 v4(65.39,55.41)
N71772497: length 5.4
  BOTTOM w0.114: v4(134.5,44.97) 134.5,46.27 R9486.2
  BOTTOM w0.254: R9486.2 133.33,46.62 132.96,46.99 Q24.6 132.96,47.96 132.82,48.1 132.45,48.1 132.31,47.96 Q24.5
N71773388: length 2.7
  TOP w0.114: v4(189.54,26.02) 188.96,25.44 C71.1
  TOP w0.254: C71.1 188.87,24.95 U11.12
N71773402: length 4.2
  TOP w0.114: v4(191.47,23.66) 189.44,23.66 C72.1
  TOP w0.254: U11.10 188.95,24.15 C72.1
N71773779:
  vias: v4(220.17,15.08)
N72685536: length 3.2
  TOP w0.114: R9493.2 124.33,67.41 v2(124.26,67.35)
  TOP w0.203: U148.B1 125.73,66.12 R9492.2 R9493.2
N72718653: length 11.3
  TOP w0.114: RC411.2 118.1,94.36 v1(118.1,93.83)
  IN3 w0.114: v1(118.1,93.83) 117.63,93.36 115.98,93.36 115.75,93.59 112.05,93.59 v1(111.69,93.94)
  BOTTOM w0.076: UC1.AB3 108.59,93.5 108.85,93.76 109.14,93.76 109.55,93.93 110.15,93.93 110.45,94.22 111.41,94.22 v1(111.69,93.94)

## Copper pours and planes (outline as drawn)
1.8VSP_LX on BOTTOM (solid shape): 181.92,184.57 181.92,183.66 182.25,183.33 183.55,183.33 183.7,183.17 183.7,180.05 183.37,179.72 179.51,179.72 179.33,179.9 179.33,184.67 179.48,184.82 181.67,184.82
+0.95VS_VGA on TOP (solid shape): 179.57,131.32 179.54,131.28 179.59,130.81 180.07,130.76 180.11,130.78 180.32,130.57 180.32,130.39 180.32,129.4 179.76,129.4 179.76,128.66 180.3,128.66 180.3,128.21 179.76,128.21 179.76,127.47 180.3,127.47 180.3,126.46 180.07,126.23 178.92,126.23 176.36,128.79 176.36,131.23 176.61,131.48 179.41,131.48
+0.95VS_VGA on BOTTOM (solid shape): outline of 1177 points within 156.09,140.15 161.58,162.45
+0.95VS_VGA on TOP: 134.32,139.61 134.32,140.71 134.98,141.37 137.29,141.37 137.51,141.58 137.51,142.52 137.75,142.76 138.87,142.76 139.17,142.46 139.81,142.46 139.83,142.43 140.54,142.43 140.75,142.23 140.75,139.94 140.67,139.87 140.21,139.87 140.06,140.02 140.06,140.58 139.93,140.71 139.1,140.71 139.05,140.65 139.05,139.61 138.91,139.47 134.46,139.47
+0.95VS_VGA on TOP: 158.5,137.99 158.5,137.45 156.75,135.7 152.94,135.7 152.38,136.26 152.38,138.22 156.29,142.13 160.23,142.13 160.24,142.11 160.37,142.11 161.12,141.37 161.12,139.82 160.69,139.38 159.9,139.38
+0.95VS_VGA on BOTTOM: 133.26,139.71 133.5,139.95 133.5,140.13 133.98,140.61 133.98,140.65 134.09,140.76 134.59,140.76 135.26,141.44 135.55,141.44 135.65,141.33 135.98,141.33 136.17,141.53 137.51,141.53 138.44,142.46 138.69,142.46 139.12,142.03 139.12,141.92 139.22,141.82 140.01,141.82 140.26,142.08 140.26,142.31 140.37,142.41 140.9,142.41 140.93,142.38 140.93,141.87 140.77,141.72 140.77,141.35 140.87,141.25 140.94,141.25 140.95,141.25 141.06,141.23 141.18,141.25 141.19,141.25 141.31,141.25 141.49,141.44 141.87,141.44 141.99,141.32 141.99,141.1 141.98,141.09 141.98,141.02 141.86,140.9 140.25,140.9 140.05,140.7 140.05,140.45 140.04,140.36 140.04,140 139.83,139.79 136.73,139.79 136.3,139.36 134.31,139.36 133.78,138.83 133.78,138.68 133.65,138.55 133.38,138.55 133.26,138.67 133.26,138.93 133.36,139.03 133.36,139.36 133.26,139.45
+0.95VS_VGA on IN1: 158.98,142.25 161.73,142.25 161.78,142.2 171.2,142.2 173.67,139.74 173.67,134.46 175.09,133.03 177.58,133.03 180.3,130.32 180.3,126.56 180.02,126.28 172.27,126.28 171.68,126.86 170.34,126.86 170.29,126.91 170.29,130.42 169.09,131.61 164.67,131.61 163.14,133.15 161.72,133.15 156.67,138.19 156.67,139.94
+0.95VS_VGA on IN3: 134.17,141.52 136.84,141.52 137.47,142.15 139.12,142.15 139.13,142.14 139.79,142.14 141.05,140.88 143.44,140.88 145.61,138.71 146.27,138.71 146.89,138.09 150.68,138.09 151.06,138.47 153.57,138.47 153.75,138.65 155.61,138.65 156.39,137.86 156.39,134.91 156.36,134.88 156.36,134.22 156.17,134.02 149.28,134.02 149.05,134.25 134.68,134.25 132.64,136.29 132.64,139.99
+0.95VS_VGA_EN# on TOP: 187,132.25 187.51,131.74 187.51,130.06 187.33,129.88 187.15,129.88 187.08,129.96 187.08,130.72 187,130.8 186.87,130.8 186.8,130.72 186.8,129.96 186.72,129.88 186.54,129.88 186.34,130.09 186.34,130.72 185.96,131.1 185.96,132.12 186.09,132.25
+0.675VS on TOP (solid shape): 132.87,38.37 132.87,37.94 132.75,37.81 130.99,37.81 130.89,37.91 130.89,38.34 131.04,38.5 132.75,38.5
