# Allegro board Lenovo ThinkPad E460 E560 BE560 NM-A561 boardview.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VCC_IO_AP on TOP: 88.83,64.94 90.1,66.21 90.1,70.02 89.34,70.78 82.51,70.78 82.12,71.16 66.55,71.16 63.13,67.73 63.13,56.83 63.71,56.25 67.95,56.25 68.66,56.96 68.66,63.11 70.49,64.94
+VCC_MPHYGT on BOTTOM (solid shape): outline of 310 points within 113.52,96.18 125.02,102.66
+VCC_MPHYGT on BOTTOM (solid shape): outline of 334 points within 126.17,73.06 138.33,81.8
+VCC_MPHYGT on TOP: 97.82,92.22 97.72,92.32 97.72,95.07 97.71,95.08 97.71,95.31 97.71,95.32 97.71,95.89 98.08,96.26 98.08,97.61 99.57,99.1 99.57,99.4 100.11,99.94 100.38,99.94 100.82,100.38 100.82,103.44 101.89,104.51 107.73,104.51 109.07,103.16 111.99,103.16 112.02,103.19 115.32,103.19 116.62,101.89 116.62,100.57 116.34,100.29 114.86,100.29 114.05,99.48 111.46,99.48 111.46,97.57 113.91,97.57 114.74,96.75 114.74,95.23 114.01,94.5 108.17,94.5 105.33,94.5 105.05,94.78 99.58,94.78 98.32,93.51 98.32,92.49 98.05,92.22
+VCC_MPHYGT on IN2: 129.77,97.96 134.42,93.31 134.42,77.74 132.85,76.16 130.49,76.16 129.29,74.97 127.69,74.97 126.57,76.09 126.57,91.96 125.77,92.76 125.77,93.98 122.99,96.76 122.99,98.85 123.25,99.1 124.9,99.1 126.04,97.96
+VCC_SA on BOTTOM (solid shape): 137.24,87.9 137.24,84.9 137.39,84.75 137.39,81.62 137.04,81.27 135.36,81.27 135.06,81.57 135.06,83.58 134.93,83.71 134.14,83.71 134.07,83.63 134.07,81.68 133.66,81.27 131.91,81.27 131.68,81.5 131.68,83.28 131.15,83.81 131.15,84.16 130.77,84.55 130.1,84.55 130.09,84.53 129.97,84.53 129.77,84.34 129.62,84.34 128.83,85.13 128.83,86.88 130,88.05 137.09,88.05
+VCC_SA on BOTTOM (solid shape): 93.77,100.2 93.8,100.2 93.91,100.16 93.95,100.05 94.01,99.83 94.23,99.73 94.28,99.72 94.3,99.67 94.68,99.3 95.06,99.67 95.08,99.72 95.13,99.73 95.27,99.76 95.37,99.86 95.82,99.86 95.95,99.75 96.12,99.74 96.25,99.71 96.28,99.59 96.4,99.22 96.79,99.15 96.89,99.14 96.96,99.05 97.01,98.9 97.12,98.79 97.17,98.69 97.12,98.58 97.09,98.57 96.45,98.57 96.45,98.56 93.84,98.56 93.82,98.6 93.48,98.82 93.13,98.6 93.11,98.56 92.69,98.56 92.29,98.96 92.29,99.24 92.31,99.26 92.31,99.42 92.31,99.43 92.34,99.54 92.32,99.65 92.34,99.71 92.39,99.73 92.4,99.73 92.45,99.72 92.47,99.67 92.85,99.3 93.23,99.67 93.25,99.72 93.3,99.73 93.52,99.83 93.58,100.05 93.62,100.16 93.73,100.2
+VCC_SA on TOP: 96.37,100.68 96.37,99.89 96.28,99.8 96.28,98.76 95.99,98.46 95.87,98.46 95.76,98.36 95.76,95.92 95.92,95.77 95.92,94.58 95.33,93.99 95.33,93.23 95.59,92.98 95.96,92.98 96.07,92.87 96.07,91.42 96.12,91.37 96.12,90.53 95.87,90.28 95.79,90.28 95.27,89.75 94.85,89.75 94.16,90.44 93.88,90.44 93.87,90.45 93.39,90.45 93.33,90.51 93.33,91.4 93.48,91.56 93.83,91.56 93.98,91.7 93.98,96.31 93.83,96.46 93.83,99.2 93.45,99.58 93.45,100.52 93.3,100.67 93.3,101.97 93.55,102.22 93.68,102.22 93.91,102.45 94.16,102.45 94.75,103.04 94.75,103.93 95.08,104.26 96.42,104.26 96.55,104.13 96.55,102.85 96.11,102.4 96.11,100.94
+VCC_SA on TOP: 137.09,87.87 137.47,87.49 137.47,84.77 136.45,83.76 130.54,83.76 130.16,84.14 129.8,84.14 128.89,85.05 128.89,86.27 129.88,87.26 129.88,87.64 130.1,87.87
+VCC_SA on IN1: 94.29,93 95.36,93 96.35,92.01 96.35,90.29 95.97,89.91 94.47,89.91 93.96,90.41 93.96,92.67
+VCC_SA on VCC: 115.99,77.38 109.02,84.35 109.02,86.37 108.01,87.39 107.98,87.39 106.31,89.07 98.13,89.07 97.54,88.48 96.65,88.48 96.45,88.28 96.45,87.39 95.71,87.39 95.7,87.4 95.08,87.4 94.6,87.89 93.62,87.89 93.43,88.08 93.43,98.44 94.93,99.94 95.79,99.94 96.04,99.68 96.04,99.28 97.1,98.22 97.19,98.31 110.32,98.31 110.45,98.19 113.85,98.19 113.85,97.68 113.85,97.68 113.85,97.48 115.53,95.8 115.53,93.66 115.5,93.64 115.5,92.9 117.4,91 129.88,91 130.23,90.64 130.23,89.19 132.76,86.67 132.76,80.52 129.62,77.38
+VCC_SFROC on TOP: 96.2,90.21 96.7,90.21 96.83,90.08 96.83,89.57 96.58,89.32 96.58,88.94 96.2,88.56 96.2,85.13 95.81,85.13 95.81,89.83
GND on TOP (solid shape): 30.23,90.26 30.23,86.71 30.18,86.66 26.68,86.66 26.58,86.76 26.58,90.19 26.68,90.29 30.21,90.29
GND on TOP (solid shape): 35.31,19.39 35.31,17.79 35.21,17.69 33.58,17.69 33.51,17.77 33.51,19.42 33.58,19.5 35.21,19.5
GND on TOP (solid shape): 39.53,75.66 39.53,73.95 39.43,73.85 37.34,73.85 37.22,73.98 37.22,75.66 37.39,75.83 39.35,75.83
GND on TOP (solid shape): 138.28,31.43 138.28,30.55 138.16,30.42 135.54,30.42 135.39,30.57 135.39,31.38 135.64,31.64 138.08,31.64
GND on TOP (solid shape): 146.57,145.87 146.57,145.49 146.37,145.28 140.01,145.28 139.87,145.42 139.87,145.96 140,146.08 146.36,146.08
GND on TOP (solid shape): 181.34,117.79 181.34,116.4 181.18,116.24 179.23,116.24 178.8,116.68 178.8,117.74 179.05,118 181.13,118
GND on TOP (solid shape): 138.09,150.04 138.09,149.55 137.68,149.14 136.82,149.14 136.69,149.26 136.69,149.99 136.88,150.18 137.95,150.18
GND on TOP (solid shape): 123.12,94.02 123.12,93.13 122.68,92.69 121.41,92.69 120.77,93.32 120.77,93.64 121.21,94.08 123.06,94.08
GND on TOP (solid shape): 149.38,147.89 149.38,147.51 149.18,147.31 140.92,147.31 140.91,147.31 140.05,147.31 139.91,147.46 139.91,148 140.01,148.11 149.17,148.11
GND on TOP (solid shape): 149.42,149.85 149.42,149.45 149.23,149.26 139.16,149.26 139,149.42 139,149.99 139.08,150.06 149.21,150.06
GND on TOP (solid shape): 179.38,114.44 179.38,112.28 179.15,112.05 177.76,112.05 177.63,112.18 177.63,113.12 177.78,113.27 177.78,114.34 177.98,114.54 179.28,114.54
GND on TOP (solid shape): 215.58,154.88 215.58,154.5 215.35,154.27 215.35,150.69 215.02,150.36 211.05,150.36 210.6,150.81 210.6,154.73 210.88,155.01 215.45,155.01
GND on TOP (solid shape): 73.34,124.8 73.34,119.37 73.51,119.19 73.51,118.63 73.41,118.53 68.1,118.53 67.8,118.84 67.8,123.69 68.15,124.04 70.26,124.04 71.18,124.96 73.18,124.96
GND on TOP (solid shape): 145.04,16.17 145.04,10.83 144.76,10.56 141.13,10.56 140.75,10.94 140.75,16.04 141.08,16.37 144.84,16.37
GND on TOP (solid shape): 145.47,80.63 145.47,76.98 145.37,76.87 143.57,76.87 143.47,76.98 143.47,77.38 142.7,78.14 142.2,78.14 142.04,78.3 142.04,80.58 142.22,80.76 145.34,80.76
GND on TOP (solid shape): 197.67,118.43 197.67,116.6 197.39,116.32 196.22,116.32 196.04,116.5 196.04,117.79 195.71,118.12 195.71,118.48 195.84,118.61 197.49,118.61
GND on TOP (solid shape): 45.08,43.54 45.08,40.81 42.28,38.01 35.81,38.01 35.36,38.46 35.36,41.44 35.87,41.95 37.01,41.95 37.2,42.14 37.2,43.54 37.46,43.79 44.82,43.79
GND on TOP (solid shape): 52,59.43 52,55.44 51.67,55.11 40.29,55.11 40.09,55.31 40.09,58.49 40.44,58.84 47.63,58.84 48.14,59.35 48.14,59.68 48.29,59.83 51.59,59.83
GND on TOP (solid shape): 98.42,118.78 98.42,118.34 98.28,118.2 93.35,118.2 90.94,115.79 86.4,115.79 86.06,116.13 86.06,117.33 86.25,117.51 91.11,117.51 92.51,118.91 98.29,118.91
GND on TOP (solid shape): 136.52,90.12 136.89,90.12 137.34,89.66 137.34,88.48 137.24,88.38 130.38,88.38 130.05,88.71 130.05,89.85 130.32,90.12 132.01,90.12 132.4,90.51 136.12,90.51
GND on TOP (solid shape): 204.63,11.75 205.75,11.75 206.08,11.42 206.08,10.56 205.7,10.17 205.7,8.88 206.23,8.35 206.23,2.83 205.64,2.25 199.27,2.25 198.89,2.63 198.89,11.42 199.42,11.95 204.43,11.95
GND on TOP (solid shape): 120.64,99.1 120.64,97 120.26,96.62 119.82,96.62 119.69,96.75 119.69,97.39 119.12,97.96 119.12,98.46 119.18,98.53 119.75,98.53 119.94,98.72 119.94,99.1 120.01,99.16 120.58,99.16
GND on TOP (solid shape): 141.89,60.92 141.89,53.08 143.08,51.88 143.08,48.55 142.53,48 139.15,48 137.83,49.32 137.83,60.8 138.59,61.56 138.59,62.85 139.06,63.32 139.49,63.32
GND on TOP (solid shape): 158.69,115.25 158.69,114.75 158.61,114.66 158.61,114.16 158.55,114.11 158.55,112.49 158.11,112.04 156.38,112.04 156.31,112.12 156.31,113.97 157.89,115.56 158.39,115.56
GND on TOP (solid shape): 144.61,152.79 146.26,152.79 146.38,152.67 146.38,151.62 146.2,151.44 144.91,151.44 144.75,151.6 144.75,152.09 144.68,152.16 144.03,152.16 143.91,152.28 143.91,152.92 143.97,152.98 144.42,152.98
GND on TOP (solid shape): 166.99,142.38 172.19,142.38 172.48,142.09 172.48,140.57 171.96,140.04 169.04,140.04 168.81,140.27 166.53,140.27 166.3,140.04 165.16,140.04 165.11,140.1 165.11,141.75 165.14,141.78 165.14,142.7 165.46,143.02 166.35,143.02
GND on TOP (solid shape): 195.71,154.37 195.71,153.63 195.21,153.13 195.21,143.22 195.76,142.66 195.76,141.75 195.26,141.24 189.87,141.24 189.67,141.44 189.67,143.96 189.31,144.31 188.17,144.31 187.84,143.98 187.84,142.41 187.31,141.87 182.25,141.87 182.23,141.9 179.28,141.9 178.47,142.71 178.47,152.77 179.18,153.48 182.45,153.48 183.18,154.21 184.58,154.21 184.59,154.22 187.56,154.22 187.74,154.04 187.74,151.55 188.12,151.17 189.31,151.17 189.57,151.42 189.57,154.07 189.97,154.47 195.61,154.47
GND on TOP (solid shape): 8.11,85.21 8.11,83.05 13.26,77.89 15.3,77.89 17.33,75.86 17.33,71.31 13.85,67.83 8.96,67.83 8.96,69.76 8.21,70.73 7.08,70.26 0.51,70.26 0.51,74.89 5.85,74.89 6.98,74.43 7.73,75.4 7.73,82.6 6.98,83.57 5.85,83.11 5.23,83.11 5.23,85.63 5.35,85.75 7.56,85.75
GND on TOP (solid shape): 16.62,54.5 16.62,52.47 14.14,49.99 14.13,49.99 13.77,49.62 13.85,49.12 13.76,48.65 14.05,48.28 14.05,48.05 13.26,47.26 12.34,47.26 12.34,47.38 12.37,47.4 12.8,48.53 11.83,49.26 1.66,49.26 1.66,53.75 7.08,53.75 8.21,53.28 8.96,54.25 8.96,56.78 14.33,56.78
GND on TOP (solid shape): outline of 178 points within 5.23,95.11 26.65,109.49
GND on BOTTOM (solid shape): 118.45,118.52 114.92,118.52 114.92,122.06 118.45,122.06
GND on BOTTOM (solid shape): 30.23,90.26 30.23,86.71 30.18,86.66 26.68,86.66 26.58,86.76 26.58,90.19 26.68,90.29 30.21,90.29
GND on BOTTOM (solid shape): 53.6,127.98 53.6,126.13 53.32,125.85 52.25,125.85 52.15,125.95 52.15,127.88 52.33,128.06 53.52,128.06
GND on BOTTOM (solid shape): 64.55,95.32 64.55,93.56 64.37,93.38 60.48,93.38 60.28,93.59 60.28,95.19 60.56,95.47 64.4,95.47
GND on BOTTOM (solid shape): 72.85,123.31 72.85,119.32 72.62,119.09 68.41,119.09 68.28,119.22 68.28,123.43 68.38,123.53 72.62,123.53
GND on BOTTOM (solid shape): 88.71,117.28 88.71,115.68 88.64,115.61 86.3,115.61 86.06,115.85 86.06,117.38 86.22,117.53 88.45,117.53
GND on BOTTOM (solid shape): 145.45,15.91 145.45,10.99 144.94,10.48 140.85,10.48 140.54,10.78 140.54,15.91 140.95,16.32 145.04,16.32
GND on BOTTOM (solid shape): 154.72,4.95 154.72,3.76 154.41,3.46 150.37,3.46 150.2,3.63 150.2,4.83 150.42,5.06 154.62,5.06
GND on BOTTOM (solid shape): 180.14,173.75 180.14,173.01 179.91,172.79 178.97,172.79 178.9,172.86 178.9,173.12 179.61,173.83 180.07,173.83
GND on BOTTOM (solid shape): 205.97,11.5 205.97,10.4 205.72,10.15 199.65,10.15 199.4,10.4 199.4,11.44 199.68,11.72 205.75,11.72
GND on BOTTOM (solid shape): 214.84,154.45 214.84,151.32 214.64,151.12 211.66,151.12 211.44,151.35 211.44,154.5 211.51,154.57 214.71,154.57
GND on BOTTOM (solid shape): 154.92,11.7 154.92,10.43 154.59,10.1 150.45,10.1 150.27,10.28 150.27,11.72 150.5,11.95 154.67,11.95
GND on BOTTOM (solid shape): 178.57,172.86 178.57,170.63 178.39,170.45 176.16,170.45 176.03,170.58 176.03,172.91 176.1,172.99 178.44,172.99
GND on BOTTOM (solid shape): 28.12,82.46 30.35,82.46 30.54,82.27 30.54,81.83 27.82,79.11 22,79.11 21.42,79.69 21.42,83.35 22,83.94 26.65,83.94
GND on BOTTOM (solid shape): 41.64,82.82 41.64,78.2 41.38,77.94 37.39,77.94 37.09,78.25 37.09,82.84 37.57,83.33 41.13,83.33
GND on BOTTOM (solid shape): 46.79,125.69 46.79,123.31 46.64,123.15 43.43,123.15 43.22,123.36 43.22,123.66 43.21,123.66 43.21,125.72 43.85,126.35 46.13,126.35
GND on BOTTOM (solid shape): 49.28,119.12 49.28,116.04 49.21,115.97 45.5,115.97 45.04,116.42 45.04,119.29 45.14,119.39 49,119.39
GND on BOTTOM (solid shape): 58.88,120.36 58.88,118.56 58.25,117.92 58.25,116.24 58.1,116.09 57.41,116.09 57.13,116.37 57.13,120.13 57.61,120.61 58.63,120.61
GND on BOTTOM (solid shape): 131.73,67.83 131.73,64.58 132.04,64.28 132.04,60.75 131.34,60.05 130.78,60.05 130.46,60.36 130.46,67.76 130.59,67.88 131.68,67.88
GND on BOTTOM (solid shape): 133.1,34.53 133.1,32.2 132.95,32.04 131.15,32.04 130.97,32.22 130.97,34.58 131.07,34.69 132.95,34.69
GND on BOTTOM (solid shape): 229.62,176.54 229.62,168.72 229.27,168.37 223.5,168.37 223.12,168.75 223.12,173.37 224.42,174.66 224.42,176.7 224.72,177 229.16,177
GND on BOTTOM (solid shape): 239.22,185.84 239.22,182.54 238.97,182.28 235.82,182.28 235.46,182.64 235.46,186.17 235.67,186.37 238.69,186.37
GND on BOTTOM (solid shape): 33.38,63.72 33.38,58.84 33.31,58.76 32.21,58.76 32.09,58.89 32.09,60.49 31.96,60.62 31.96,63.82 32.09,63.95 33.15,63.95
GND on BOTTOM (solid shape): 138.21,31.43 138.21,30.49 138.13,30.42 135.36,30.42 135.24,30.55 135.24,31.46 135.34,31.56 138.08,31.56
GND on BOTTOM (solid shape): 172.5,161.79 172.5,160.36 171.85,159.71 171.85,158.23 171.34,157.72 169.25,157.72 168.59,158.38 168.59,162.24 169.07,162.73 171.56,162.73
GND on BOTTOM (solid shape): 127.86,23.29 127.86,18.86 127.46,18.45 122.69,18.45 122.44,18.7 122.44,23.19 122.92,23.66 127.49,23.66
GND on BOTTOM (solid shape): 146.49,26.15 146.49,22.77 146.21,22.49 141.51,22.49 141.41,22.6 141.41,22.87 141.43,22.9 141.43,23.99 139.86,25.57 139.86,26.28 139.96,26.38 146.26,26.38
GND on BOTTOM (solid shape): 194.39,175.33 195.21,175.33 195.41,175.12 195.41,173.22 195.05,172.86 195.05,172.07 194.82,171.85 189.85,171.85 189.59,172.1 189.59,175.91 189.86,176.18 193.54,176.18
GND on BOTTOM (solid shape): 126.68,117.27 126.68,115.61 127.25,115.04 127.25,114.12 126.64,113.51 123.88,113.51 123.42,113.97 123.42,117.26 123.75,117.58 125.38,117.58 126.36,117.58
GND on BOTTOM (solid shape): 140.62,40.63 140.62,39.49 140.47,39.33 139.83,39.33 139.58,39.08 139.02,39.08 138.94,39.16 138.94,39.69 138.99,39.74 139.66,39.74 139.81,39.89 139.81,40.58 139.93,40.71 140.54,40.71
GND on BOTTOM (solid shape): 167.34,142.08 167.34,140.83 166.92,140.41 166.57,140.41 166.2,140.05 165.36,140.05 164.67,139.36 163.05,139.36 162.21,140.2 162.21,143.91 162.41,144.11 165.31,144.11
GND on BOTTOM (solid shape): 136.73,90.16 137.29,90.16 137.52,89.93 137.52,88.53 137.42,88.43 130.1,88.43 130,88.53 130,89.07 131.1,90.16 131.46,90.16 131.95,90.65 131.95,90.65 136.24,90.65
GND on BOTTOM (solid shape): 143.57,84.93 143.57,84.34 143.44,84.22 141.84,84.22 141.79,84.16 141.79,83.56 141.71,83.48 141.56,83.48 141.48,83.56 141.48,84.16 141.43,84.22 140.82,84.22 140.77,84.27 140.77,84.95 140.87,85.05 143.44,85.05
GND on BOTTOM (solid shape): 146.23,72.66 146.23,71.79 146.22,71.78 146.22,71.5 146.08,71.36 141.79,71.36 141.48,71.67 141.48,72.28 141.89,72.68 141.92,72.68 142.02,72.79 146.11,72.79
GND on BOTTOM (solid shape): 145.5,80.2 145.5,76.27 145.4,76.16 142.83,76.16 142.7,76.29 142.7,76.72 142.8,76.82 143.19,76.82 143.29,76.82 143.39,76.93 143.39,78.02 143.11,78.3 141.87,78.3 141.76,78.4 141.76,80.33 141.94,80.51 145.19,80.51
GND on BOTTOM (solid shape): 96.83,135.98 96.83,134.81 94.48,132.46 93.59,132.46 92.89,131.76 92.21,131.76 91.24,132.73 91.24,133.59 91.4,133.75 92.64,133.75 95.74,136.84 95.97,136.84
GND on BOTTOM (solid shape): 228.33,154.83 228.33,153.25 226.4,151.32 226.22,151.32 224.79,152.75 224.78,152.77 224.72,152.9 224.61,152.99 224.61,155.51 225.02,155.92 227.23,155.92
GND on BOTTOM (solid shape): 29.77,52.94 29.77,42.43 30.79,41.42 37.31,41.42 38.03,42.14 38.03,48.11 38.6,48.68 44.32,48.68 45.27,47.73 45.27,39.47 43.33,37.53 30.54,37.53 25.96,42.1 25.96,52.81 26.47,53.32 29.39,53.32
GND on BOTTOM (solid shape): 40.37,75.76 40.37,74.31 40.27,74.21 39.4,74.21 39.25,74.36 38.44,74.36 38.39,74.31 38.39,73.7 38.33,73.65 38.13,73.65 38.03,73.75 38.03,74.33 38,74.36 37.39,74.36 37.32,74.44 37.32,75.15 37.39,75.22 38.89,75.22 39.5,75.83 40.29,75.83
GND on BOTTOM (solid shape): 127.72,104.21 127.72,103.44 127.67,103.39 127.67,102.35 127.74,102.27 128.3,102.27 128.35,102.22 128.35,102 128.3,101.94 127.72,101.94 127.67,101.89 127.67,101.26 127.62,101.21 126.88,101.21 126.78,101.31 126.78,103.04 126.55,103.27 126.19,103.27 126.07,103.39 126.07,104.13 126.22,104.28 127.64,104.28
GND on BOTTOM (solid shape): 151.69,113.2 151.69,104.94 150.45,103.7 144.15,103.7 144.05,103.8 144.05,106.69 144.23,106.87 145.8,106.87 145.98,107.05 145.98,108.78 145.52,109.23 144.25,109.23 144.05,109.44 144.05,112.66 144.61,113.22 144.61,113.65 144.81,113.86 151.03,113.86
GND on BOTTOM (solid shape): 173.51,12.05 173.51,10.28 173.41,10.17 168.33,10.17 167.98,9.82 167.98,7.23 167.87,7.13 166.15,7.13 166.12,7.15 166.12,7.3 166.15,7.33 167.42,7.33 167.44,7.36 167.44,9.03 167.42,9.06 166.1,9.06 165.79,9.36 165.79,11.85 166.3,12.36 173.21,12.36
GND on BOTTOM (solid shape): 45.88,60.31 45.88,59.01 46.26,58.62 47.69,58.62 48.29,59.22 48.29,60.29 48.47,60.47 51.85,60.47 52.28,60.03 52.28,55.59 51.85,55.16 41.66,55.16 40.21,56.61 40.21,58.69 40.37,58.84 42.53,58.84 42.68,58.99 42.68,60.26 42.91,60.49 45.7,60.49
GND on BOTTOM (solid shape): 111.82,60.8 114.33,60.8 122.35,52.78 122.35,51.92 122.1,51.68 116.19,51.68 116,51.49 114.45,51.49 106.32,51.49 104.98,52.82 104.58,52.82 101.68,55.72 82.71,55.72 80.55,53.56 80.55,51.63 80.45,51.53 59.67,51.53 59.21,51.07 59.21,48.45 58.78,48.02 57.89,48.02 56.85,49.06 56.85,60.72 68.19,72.06 100.55,72.06
GND on BOTTOM (solid shape): 141.74,61.11 141.74,49.87 141.79,49.82 142.65,49.82 142.7,49.77 142.7,49.62 142.65,49.57 141.79,49.57 141.74,49.52 141.74,48.24 141.75,48.22 142.65,48.22 142.68,48.2 142.68,47.23 142.55,47.11 141.46,47.11 141.38,47.18 141.38,48.15 141.33,48.2 139.76,48.2 139.68,48.27 139.68,51.68 138.79,52.57 138.79,54.29 138.06,55.03 138.06,63.13 138.28,63.36 139.48,63.36
GND on BOTTOM (solid shape): 136.45,38.77 136.45,37.78 136.48,37.76 137.45,37.76 137.5,37.71 137.5,37.56 137.42,37.48 136.48,37.48 136.45,37.45 136.45,37.23 136.4,37.17 134.58,37.17 134.5,37.1 133.76,37.1 133.71,37.15 133.71,37.28 133.79,37.35 134.7,37.35 134.78,37.43 134.78,37.84 134.73,37.89 133.81,37.89 133.74,37.96 133.74,38.11 133.79,38.17 134.75,38.17 134.78,38.19 134.78,38.8 134.83,38.85 136.38,38.85
GND on BOTTOM (solid shape): 188.35,7.02 188.35,6.87 188.32,6.85 187.05,6.85 187.03,6.82 187.03,5.17 187.08,5.12 188.37,5.12 189.54,3.95 198.68,3.95 199.78,5.04 206.53,5.04 206.74,4.84 206.74,2.28 206.51,2.05 178.82,2.05 178.7,2.17 178.7,4.84 178.87,5.02 181.95,5.02 182.12,4.84 182.12,4.18 182.51,3.8 186.21,3.8 186.52,4.1 186.52,7.02 186.54,7.05 188.32,7.05
GND on BOTTOM (solid shape): 246.25,151.64 246.25,151.08 241.56,146.39 241.41,146.37 241.27,146.29 240.95,146.29 240.5,146.74 240.5,147.51 242.26,149.27 242.26,149.51 240.85,150.92 240.85,151.98 242.37,153.51 243.16,153.51 243.18,153.48 243.52,153.28 243.85,153.48 243.87,153.51 244.02,153.51 244.2,153.68
GND on BOTTOM (solid shape): 229.61,185.83 229.61,182.22 229.39,182.01 226.29,182.01 226.07,182.23 226.07,182.6 226.1,182.67 226.18,182.7 226.63,183.07 226.18,183.45 226.1,183.47 226.07,183.55 226.07,186.17 226.24,186.35 229.09,186.35
GND on BOTTOM (solid shape): 194.37,167.6 194.37,165.84 194.81,165.39 195.95,165.39 196.87,166.31 208.34,166.31 209.78,164.86 209.78,162.65 208.87,161.74 182.94,161.74 182.25,162.42 182.25,163.67 183.6,165.01 185.67,165.01 185.76,164.98 185.79,164.89 186.18,164.5 186.56,164.89 186.59,164.98 186.68,165.01 188.07,165.01 191.01,167.96 194.01,167.96
GND on BOTTOM (solid shape): 144.56,95.67 144.56,93.26 144.1,92.8 135.21,92.8 134.83,93.18 134.83,94.07 143.49,94.07 143.49,94.02 143.51,93.96 143.53,93.91 143.55,93.86 143.59,93.82 143.63,93.78 143.67,93.74 143.72,93.72 143.78,93.7 143.83,93.69 143.89,93.69 143.94,93.7 144,93.71 144.05,93.73 144.09,93.76 144.14,93.8 144.17,93.84 144.2,93.88 144.23,93.93 144.24,93.99 144.25,94.04 144.25,94.1 144.24,94.15 144.23,94.21 144.2,94.26 144.17,94.3 144.14,94.35 144.09,94.38 144.05,94.41 144,94.43 143.94,94.45 143.89,94.45 143.83,94.45 143.78,94.44 143.72,94.42 143.67,94.4 143.63,94.36 143.59,94.33 143.55,94.28 143.53,94.23 143.51,94.18 143.49,94.13 143.49,94.07 134.83,94.07 134.83,95.34 135.03,95.54 137.52,95.54 137.85,95.87 144.35,95.87
GND on BOTTOM (solid shape): 117.42,27.71 117.42,26.79 117.15,26.37 117.53,26.05 117.53,24.02 117.13,23.61 104.22,23.61 104.11,23.68 104.12,23.81 103.82,24.42 103.51,23.81 103.52,23.68 103.41,23.61 102.34,23.61 101.71,24.25 101.71,27.57 101.94,27.8 117.33,27.8
GND on BOTTOM (solid shape): 18.68,107.3 19.41,107.3 19.46,107.25 19.46,106.08 20.82,104.73 20.82,103.35 20.1,102.63 11.41,102.63 11.16,102.38 11.16,99.23 10.32,98.39 8.46,98.39 7.68,97.6 5.23,97.6 5.23,98.89 5.85,98.89 6.98,98.43 7.73,99.4 7.73,106.64 12.11,106.64 15.08,105.01 17.41,107.48 17.41,107.53 18.45,107.53
GND on BOTTOM (solid shape): outline of 100 points within 116.91,86.72 122.23,90.53
GND on BOTTOM (solid shape): 11.84,79.87 16.16,79.87 17.41,78.63 17.41,71.79 14.57,68.96 12.55,68.96 11.96,68.37 10.52,68.37 9.56,67.4 8.96,67.4 8.96,69.76 8.21,70.73 7.08,70.26 0.51,70.26 0.51,74.89 5.85,74.89 6.98,74.43 7.73,75.4 7.73,82.6 6.98,83.57 5.85,83.11 5.23,83.11 5.23,84.11 7.6,84.11
GND on BOTTOM (solid shape): outline of 112 points within 148.16,12.56 158.55,39.28
GND on BOTTOM (solid shape): 14.97,54.37 14.97,48.93 14.88,48.85 14.76,48.81 14.67,48.9 14.64,48.97 14.59,49.03 14.56,49.12 14.59,49.2 14.31,49.83 14.02,49.2 14.05,49.12 14.02,49.03 13.94,48.68 14.19,48.42 14.27,48.33 14.24,48.21 12.93,46.9 12.34,46.9 12.34,47.38 12.8,48.51 11.83,49.26 1.66,49.26 1.66,53.75 7.08,53.75 8.21,53.28 8.96,54.25 8.96,56.78 12.55,56.78
GND on BOTTOM (solid shape): 122.68,61.56 122.76,61.52 122.8,61.43 122.81,61.39 122.79,61.33 122.73,61.32 122.33,60.72 123.02,60.94 123.06,61.03 123.44,61.16 123.56,61.43 123.6,61.52 123.69,61.56 125.15,61.56 125.26,61.5 125.26,61.37 125.6,60.81 125.93,61.37 125.93,61.5 126.04,61.56 127.18,61.56 127.74,61 127.74,60.78 127.66,60.66 127.52,60.69 126.87,60.43 127.52,60.17 127.66,60.2 127.74,60.08 127.74,56 126.85,55.11 122.48,55.11 121.57,56.02 121.57,60.7 122.43,61.56
GND on BOTTOM (solid shape): 154.31,142.75 154.59,142.6 154.88,142.74 154.91,142.75 155.04,142.75 155.05,142.71 155.35,142.41 155.73,142.62 155.78,142.67 155.82,142.72 155.83,142.75 155.86,142.75 155.91,142.75 156.07,142.63 156.26,142.61 156.37,142.5 156.39,142.48 156.4,142.45 156.27,142.03 156.64,141.81 156.72,141.78 156.76,141.71 156.76,141.62 156.74,141.61 156.66,141.46 156.65,141.28 156.66,141.25 156.5,141.1 156.5,140.91 156.47,140.89 156.24,140.56 156.47,140.23 156.5,140.21 156.5,140.15 156.44,140.08 156.38,140.09 156.35,140.08 155.94,140 155.89,139.59 155.89,139.55 155.87,139.52 155.83,139.49 155.79,139.44 155.73,139.42 155.67,139.39 154.72,139.39 154.72,139.38 154.53,139.38 154.43,139.48 154.31,139.53 154.3,139.54 154.12,139.71 154.05,139.81 153.96,139.88 153.95,139.88 153.88,139.95 153.88,140.21 153.91,140.22 154.16,140.56 153.91,140.9 153.88,140.91 153.88,141.41 153.91,141.42 154.16,141.76 153.91,142.1 153.88,142.11 153.88,142.53 154.1,142.75
GND on BOTTOM (solid shape): outline of 84 points within 35.4,128.48 214.51,189.84
GND on BOTTOM (solid shape): outline of 128 points within 75.76,89.45 86.22,91.26
GND on GND1 (solid shape): outline of 160811 points within 0.51,0.51 250.69,194.64
GND on IN1 (solid shape): 46.79,125.69 46.79,123.31 46.77,123.28 43.59,123.28 43.21,123.66 43.21,125.72 43.85,126.35 46.13,126.35
GND on IN1 (solid shape): 72.38,122.34 72.38,120.44 72.22,120.28 69.72,120.28 69.53,120.47 69.53,122.34 69.65,122.47 72.26,122.47
GND on IN1 (solid shape): 118.88,90.41 118.88,87.16 118.47,86.76 117.18,86.76 115.17,88.76 115.17,89.38 116.46,90.67 118.62,90.67
GND on IN1 (solid shape): 136.61,40.02 136.61,37.3 136.3,37 133.66,37 133.36,37.3 133.36,39.89 133.71,40.25 136.38,40.25
GND on IN1 (solid shape): 27.51,82.77 27.51,79.98 26.67,79.14 23.42,79.14 22.4,80.16 22.4,82.49 23.59,83.68 26.6,83.68
GND on IN2 (solid shape): 27.5,82.73 27.5,80.05 27.34,79.88 22.68,79.88 22.03,80.53 22.03,82.67 23.07,83.71 26.52,83.71
GND on IN2 (solid shape): 46.79,125.69 46.79,123.31 46.77,123.28 43.59,123.28 43.21,123.66 43.21,125.72 43.85,126.35 46.13,126.35
GND on IN2 (solid shape): 136.66,40.12 136.66,37.38 136.4,37.12 133.64,37.12 133.41,37.35 133.41,39.97 133.71,40.27 136.51,40.27
GND on IN2 (solid shape): 9.34,84.84 9.34,78.36 11.64,76.06 14.99,76.06 16.44,74.61 16.44,70.52 14.05,68.14 10.04,68.14 9.68,67.78 8.96,67.78 8.96,69.76 8.21,70.73 7.08,70.26 0.51,70.26 0.51,74.89 5.85,74.89 6.98,74.43 7.73,75.4 7.73,82.6 6.98,83.57 5.85,83.11 5.23,83.11 5.23,85.69 8.49,85.69
GND on IN2 (solid shape): 16.21,108.42 16.21,104.74 14.74,103.27 9.94,103.27 8.92,102.25 8.92,96.64 8.26,95.98 8.17,95.94 8.07,95.98 7.16,96.02 7.2,95.11 7.24,95.01 7.2,94.92 7.12,94.83 6.78,94.83 6.57,94.99 6.32,95.05 5.88,95.05 5.64,94.99 5.44,94.85 5.42,94.83 5.23,94.83 5.23,98.89 5.85,98.89 6.98,98.43 7.73,99.4 7.73,106.29 8.15,106.71 12.26,106.71 13.14,107.58 13.14,108.27 14.03,109.16 15.47,109.16
GND on IN3 (solid shape): 46.79,125.69 46.79,123.31 46.77,123.28 43.59,123.28 43.21,123.66 43.21,125.72 43.85,126.35 46.13,126.35
GND on IN3 (solid shape): 136.73,40.1 136.73,37.5 136.4,37.17 133.61,37.17 133.36,37.43 133.36,40.02 133.64,40.3 136.53,40.3
GND on IN3 (solid shape): 31.07,90.67 31.07,87.85 28.77,85.54 28.53,85.54 27.69,84.7 27.69,80.25 26.57,79.14 22.33,79.14 22.1,79.37 22.1,83.09 25.25,86.25 25.25,91.02 25.98,91.74 30,91.74
GND on IN3 (solid shape): 170.14,129.94 170.14,128.28 170.07,128.17 169.93,128.18 169.41,128.12 169.46,127.59 169.5,127.5 169.46,127.4 169.01,126.94 165.67,126.94 165.03,127.59 165.03,130.53 165.54,131.04 169.03,131.04
GND on IN3 (solid shape): 119.38,89.56 119.38,89.02 119.32,89.01 118.98,88.64 119.32,88.26 119.38,88.25 119.38,87.8 119.35,87.71 119.26,87.67 119,87.55 118.9,87.28 118.9,87.22 116.91,87.22 116.41,87.72 116.41,88.62 116.98,89.18 116.98,89.99 117.12,90.14 118.8,90.14
GND on IN3 (solid shape): 13.42,55.92 13.42,47.61 12.91,47.11 12.34,47.11 12.34,47.38 12.8,48.51 11.83,49.26 1.66,49.26 1.66,53.75 7.08,53.75 8.21,53.28 8.96,54.25 8.96,56.71 12.63,56.71
GND on IN3 (solid shape): 14.61,36.44 14.61,25.62 13.6,24.6 12.34,24.6 12.34,24.78 12.37,24.8 12.8,25.93 11.83,26.66 1.66,26.66 1.66,34.74 11.83,34.74 12.8,35.49 12.34,36.62 12.34,37.07 13.98,37.07
GND on IN3 (solid shape): 10.57,83.61 10.57,82.21 12.27,80.51 14.87,80.51 16.17,79.2 16.17,75.54 16.64,75.07 16.64,72.3 12.48,68.14 10.04,68.14 9.68,67.78 8.96,67.78 8.96,69.76 8.21,70.73 7.08,70.26 0.51,70.26 0.51,74.89 5.85,74.89 6.98,74.43 7.73,75.4 7.73,82.6 6.98,83.57 5.85,83.11 5.23,83.11 5.23,85.69 8.49,85.69
GND on IN3 (solid shape): 18.29,106.69 18.29,105.81 17.33,104.84 16.59,104.84 14.66,102.91 9.56,102.91 8.92,102.27 8.92,96.64 8.26,95.98 8.17,95.94 8.07,95.98 7.16,96.02 7.2,95.11 7.24,95.01 7.2,94.92 7.12,94.83 6.78,94.83 6.57,94.99 6.32,95.05 5.88,95.05 5.64,94.99 5.44,94.85 5.42,94.83 5.23,94.83 5.23,98.89 5.85,98.89 6.98,98.43 7.73,99.4 7.73,106.31 8.01,106.59 11.39,106.59 14.23,109.44 15.55,109.44
GND on GND2 (solid shape): outline of 160749 points within 0.51,0.51 250.69,194.64
GND on TOP: 238.51,145.76 240.01,145.76 240.42,145.35 240.42,143.6 239.13,142.32 237.81,142.32 237.67,142.46 237.67,144.92
GND on TOP: 80.57,83.1 83.24,83.1 83.5,83.35 83.5,83.86 82.73,84.62 77.15,84.62 76.99,84.47 74.4,84.47 72.95,83.02 72.95,81.19 73.34,80.81 78.29,80.81
GND on TOP: 213.61,69.06 210.37,72.3 210.37,73.06 210.62,73.32 216.46,73.32 217.1,72.68 217.1,65.44 215.77,64.11 212.46,64.11 212.08,64.49 212.08,64.75 213.61,66.27
GND on TOP: 79.15,98.82 80.63,98.82 80.75,98.69 80.75,93.65 80.71,93.61 80.71,91.57 81.01,91.28 81.01,90.24 81.21,90.03 81.21,89.63 81.41,89.42 82.38,89.42 82.53,89.57 82.53,90.51 82.25,90.79 82.25,91.05 82.48,91.28 82.48,91.81 82.58,91.91 83.27,91.91 83.34,91.84 83.34,90.18 83.6,89.93 83.6,89.6 83.72,89.47 84.18,89.47 84.28,89.37 84.28,88.79 84.14,88.65 82.77,88.65 82.71,88.58 80.65,88.58 79.91,89.32 79,89.32 78.44,89.88 78.44,91.3 78.59,91.45 78.59,98.67 78.7,98.77 79.1,98.77
GND on TOP: 46.11,119.09 46.11,116.04 46.18,115.97 49.21,115.97 49.28,116.04 49.28,119.12 49.21,119.19 46.21,119.19
GND on TOP: 140.87,141.39 140.87,141.76 141.23,142.12 147.06,142.12 147.06,142.12 148.1,142.12 148.16,142.05 148.16,140.93 148.04,140.81 148.04,138.11 147.86,137.94 146.49,137.94 146.23,138.19 146.23,139.08 146.34,139.08 146.72,139.46 146.72,140.4 146.44,140.68 145.12,140.68 144.35,141.44 142.02,141.44 141.87,141.29 140.97,141.29
GND on TOP: 169.6,153.84 172.65,153.84 173.03,153.46 173.03,151.55 172.9,151.42 166.93,151.42 166.68,151.68 166.68,152.82 166.81,152.95 169.22,152.95 169.47,153.2 169.47,153.71
GND on TOP: 212.45,86.08 216.68,86.08 216.92,85.84 216.92,75.05 216.17,74.3 199.54,74.3 197.52,76.32 197.52,103.6 205.11,111.19 216.11,111.19 217,110.3 217,98.26 216.34,97.6 212.6,97.6 209.42,100.79 206.83,100.79 206.15,100.12 204.5,100.12 203.82,99.43 203.82,96.79 205.03,95.57 206.2,95.57 206.51,95.87 206.51,97.53 206.81,97.83 209.78,97.83 210.85,96.76 210.85,94.02 210.17,93.34 210.17,88.36
GND on TOP: 60.79,95.65 64.29,95.65 64.45,95.49 64.45,93.41 64.17,93.13 60.86,93.13 60.43,93.56 60.43,95.29
GND on TOP: 185.88,182.01 185.88,179.47 185.38,178.96 182.96,178.96 182.4,179.52 182.4,183.91 182.71,184.22 183.42,184.22 183.43,184.23 184.84,184.23 185.03,184.04 185.03,182.86
GND on TOP: 140.67,26.18 146.26,26.18 146.51,25.92 146.51,22.52 146.34,22.34 140.72,22.34 140.44,22.62 140.44,25.95
GND on TOP: 161.83,181.52 164.6,181.52 164.93,181.85 164.93,183.68 162.92,185.69 162.92,187.49 162.77,187.64 161.96,187.64 161.47,187.16 161.47,181.88
GND on TOP: 32.19,63.87 32.85,63.87 33.38,63.34 33.38,59.07 33.2,58.89 32.39,58.89 32.11,59.17 32.11,61.46 31.91,61.66 31.91,63.59
GND on TOP: 48.72,29.91 51.34,29.91 51.44,30.01 51.44,32.6 51.42,32.63 48.77,32.63 48.7,32.55 48.7,29.94
GND on TOP: 128.12,50.08 128.12,39.89 128.78,39.23 128.78,28.18 127.07,26.47 127.06,26.48 125.41,26.48 125.02,26.86 125.02,29.86 125.3,30.14 126.83,30.14 127.21,30.52 127.21,35.07 125.05,37.23 125.05,38.09 125.51,38.55 125.51,44.36 125.99,44.85 125.99,47.61 125.89,47.72 125.89,50.13 126.07,50.31 127.9,50.31
GND on TOP: 182.55,56.27 182.45,56.17 181.62,56.17 181.24,55.79 180.47,55.79 180.27,56 180.27,56.94 181.04,57.71 182.51,57.71 182.55,57.67
GND on TOP: 22.23,64.66 22.23,60.87 22.43,60.67 26.96,60.67 27.13,60.85 27.13,64.66 26.96,64.84 22.41,64.84
GND on TOP: 12.34,24.33 12.34,24.78 12.8,25.91 11.83,26.66 1.81,26.66 1.66,26.81 1.66,34.74 11.83,34.74 12.8,35.49 12.34,36.62 12.34,36.77 12.64,37.07 14.46,37.07 18.09,40.71 28.02,40.71 32.87,35.85 39.4,35.85 40.6,34.66 40.6,32.12 35.19,26.71 22.08,26.71 20.95,25.58 20.95,22.84 20.33,22.21 16.39,22.21 14.48,24.12 12.55,24.12
GND on TOP: 100.77,83.03 101.47,83.03 101.85,83.42 102.74,83.42 102.99,83.16 102.99,80.56 103.24,80.3 107.24,80.3 108.32,81.38 108.32,82.15 107.37,83.1 107.37,83.35 107.44,83.42 108.13,83.42 108.32,83.61 108.32,84.24 106.23,84.24 105.97,83.99 104.58,83.99 104.32,84.24 101.72,84.24 101.28,83.8 100.64,83.8 100.58,83.73 100.58,83.22
GND on TOP: 176.4,173.42 179.23,173.42 179.69,172.96 179.69,169.36 179.2,168.87 176.28,168.87 175.82,169.33 175.82,172.85
GND on TOP: 85.25,91.73 86.72,91.73 86.82,91.63 86.82,90.72 86.94,90.6 86.94,90.1 86.87,90.03 85.83,90.03 85.43,89.63 84.46,89.63 84.38,89.7 84.38,90.01 84.49,90.11 85.12,90.11 85.22,90.21 85.22,91.71
GND on TOP: 173.92,170.41 173.92,172.28 173.74,172.46 172.27,172.46 172.12,172.3 172.12,171.54 171.79,171.21 171.15,171.21 169.42,172.94 169.42,173.7 169.6,173.88 171.46,173.88 171.91,173.42 175.06,173.42 175.43,173.06 175.43,170.54 175.05,170.16 174.17,170.16
GND on TOP: 146.81,143.97 146.97,144.13 147.15,144.13 147.7,144.68 147.7,145.33 147.77,145.41 147.84,145.41 147.88,145.45 148.77,145.45 149.15,145.07 149.15,144.57 148.42,143.83 147.86,143.83 147.5,143.47 147.03,143.47 146.81,143.69
GND on TOP: 209.15,28.64 209.48,28.31 209.48,27.37 209.42,27.31 209.42,26.67 209.25,26.51 208.21,26.51 208.13,26.58 208.13,28.49 208.29,28.64
GND on TOP: 76.21,51.98 76.93,51.26 76.93,28.32 75.06,26.46 64.98,26.46 63.23,28.21 63.23,39.41 66.91,43.09 68.61,43.09 68.94,43.42 68.94,44.36 64.47,48.83 64.47,50.46 59.44,55.49 53.73,55.49 53.24,55.97 53.24,62.98 57.69,67.43 61.68,67.43 62.74,66.36 62.74,56.73 66.02,53.46 69.7,53.46 69.83,53.33 69.83,52.44 70.29,51.98
GND on TOP: 164.27,163.49 167.32,163.49 167.57,163.23 167.57,162.35 167.06,161.84 164.27,161.84 164.01,162.09 164.01,163.23
GND on TOP: 100.16,133.34 100.19,133.34 100.87,132.67 101,132.67 101.17,132.5 101.17,132.21 101.04,132.08 100.56,132.08 99.78,132.85 99.78,132.96
GND on TOP: 97.03,98.59 96.86,98.41 96.86,97.37 96.73,97.25 96.73,96.41 97.47,95.67 97.47,91.61 98.15,90.92 98.15,90.51 97.36,89.73 97.11,89.73 96.96,89.88 96.96,90.11 96.25,90.82 96.25,93.03 96.2,93.08 95.76,93.08 95.71,93.13 95.71,94.05 96.09,94.43 96.09,95.77 95.87,96 95.87,98.16 96.37,98.67 96.37,99.68 96.48,99.79 96.48,100.75 96.2,101.03 96.2,101.44 96.35,101.59 96.83,101.59 97.03,101.39
GND on TOP: 145.39,143.93 145.39,143.55 145.19,143.35 140.88,143.35 140.61,143.08 140.61,142.67 140.54,142.61 139.35,142.61 139.2,142.76 139.2,143.09 138.89,143.4 137.83,143.4 137.75,143.47 137.75,145.25 137.57,145.43 136.96,145.43 136.86,145.53 136.86,145.86 137.21,146.21 138.68,146.21 138.96,145.93 138.96,144.66 139.38,144.24 140.54,144.24 140.63,144.15 145.18,144.15
GND on TOP: 130.99,34.23 132.72,34.23 132.98,33.97 132.98,32.04 132.87,31.94 131.15,31.94 130.89,32.2 130.89,34.13
GND on TOP: 246.28,168.04 246.94,168.04 248.47,166.51 248.47,165.39 248.37,165.29 246.34,165.29 246.11,165.52 246.11,167.86
GND on TOP: 238.66,154.5 239.68,154.5 240.62,153.56 240.62,152.14 240.39,151.91 238.16,151.91 237.85,152.21 237.85,153.68
GND on TOP: 153.98,134.02 156.14,134.02 157.66,132.5 157.66,128.56 157.41,128.31 156.27,128.31 153.6,130.98 153.6,133.64
GND on TOP: 210.75,22.42 207.57,22.42 207.47,22.32 207.47,18.99 210.88,18.99 210.88,22.29
GND on TOP: 133.58,40.27 136.71,40.27 136.91,40.07 136.91,37.35 136.63,37.07 133.71,37.07 133.41,37.38 133.41,40.1
GND on TOP: 38.97,103.65 38.97,101.74 38.66,101.44 35.64,101.44 35.31,101.77 35.31,103.09 36.02,103.8 38.82,103.8
GND on TOP: 93.24,99.58 93.24,100.76 92.97,101.03 92.54,101.03 92.44,100.93 92.44,93.31 92.06,92.93 92.06,91.45 91.75,91.15 91.6,91.15 91.5,91.05 91.5,90.36 90.89,89.75 90.89,89.19 91.04,89.04 92.41,89.04 92.49,89.12 92.49,89.68 92.28,89.88 92.28,90.44 92.41,90.57 92.89,90.57 93.02,90.69 93.02,91.3 93.12,91.4 93.12,91.61 93.25,91.73 93.66,91.73 93.75,91.83 93.75,99.07
GND on TOP: 100.6,133.66 101.34,133.66 101.71,134.02 101.94,134.02 102.51,133.45 101.55,132.49 101.42,132.49 100.89,133.02 100.76,133.02 100.43,133.35 100.43,133.49
GND on TOP: outline of 363 points within 1.66,0.51 250.69,194.63 ; 2 cut-outs
GND on TOP: 38.06,94.5 38.84,94.5 39.05,94.3 39.05,91.99 38.94,91.89 36.58,91.89 35.69,92.78 35.69,93.82 35.41,94.1 35.41,95.34 35.57,95.49 37.06,95.49
GND on TOP: 64.29,99.28 54.01,99.28 53.96,99.23 53.37,99.23 52.99,99.61 52.99,100.88 53.45,101.34 55.05,101.34 55.12,101.41 55.4,101.41 55.89,101.89 55.33,102.45 55.33,106.36 57.31,108.35 61.27,108.35 63.13,106.49 63.13,103.49 64.47,102.15 64.47,99.46
GND on TOP: 55.25,93.16 54.41,93.16 54.24,93.33 54.24,94.05 53.84,94.44 53.64,94.44 53.4,94.68 53.4,95.47 53.6,95.67 54.06,95.67 54.26,95.47 55.07,95.47 55.45,95.09 55.45,93.36
GND on BOTTOM: 160.71,49.11 164.75,49.11 169.27,44.59 169.27,38.98 174.55,33.69 183.52,33.69 184.64,32.58 184.64,23.66 183.78,22.8 183.78,15.43 181.24,12.89 164.7,12.89 162.24,15.36 162.24,22.21 160.18,24.27 160.18,48.58
GND on BOTTOM: 18.68,52.9 22.21,52.9 22.61,52.49 22.61,49.98 22.33,49.7 19.26,49.7 18.45,50.51 18.45,52.67
GND on BOTTOM: 181.26,130.7 181.39,130.57 181.39,130.01 181.26,129.88 180.6,129.88 179.56,130.93 179.56,131.82 180.24,132.5 181.11,132.5 181.26,132.35
GND on BOTTOM: 201.73,183.3 201.61,183.43 201.61,184.95 202.34,185.69 207.12,185.69 208.08,184.72 208.08,183.55 207.83,183.3
GND on BOTTOM: 206.56,127.95 216.74,127.95 217.58,127.12 217.58,122.37 218.9,121.05 218.9,109.82 217.43,108.35 217.43,96.69 216.9,96.15 214.51,96.15 205.97,104.69 205.97,127.37
GND on BOTTOM: 204.74,58.45 171.51,91.68 171.51,104.15 175.09,107.74 175.09,112.21 176.08,113.2 178.42,113.2 180.98,110.63 185.02,110.63 186.75,112.36 193.58,112.36 207.38,98.55 207.38,96.93 208.92,95.39 208.92,83.38 213.26,79.03 213.26,57.7 212.07,56.5 208.46,56.5 207.98,56.99 207.98,57.95 207.49,58.45
GND on BOTTOM: 169.27,182.36 170.59,182.36 170.85,182.11 170.85,178.22 170.67,178.04 169.53,178.04 169.04,178.53 169.04,182.13
GND on BOTTOM: 190.02,141.24 189.67,141.59 189.67,143.78 189.36,144.08 188.14,144.08 187.79,143.73 187.79,141.47 187.59,141.26 183.44,141.26 182.81,141.9 179.41,141.9 179.2,142.1 179.2,152.9 179.58,153.28 182.71,153.28 183.47,154.04 187.48,154.04 187.64,153.89 187.64,151.58 187.92,151.3 189.26,151.3 189.57,151.6 189.57,153.81 189.79,154.04 192.54,154.04 192.56,154.01 193.68,154.01 195.08,155.41 195.64,155.41 195.74,155.31 195.74,153.84 195.27,153.37 195.27,145.98 195.28,145.96 195.28,143.12 195.81,142.58 195.81,141.39 195.66,141.24
GND on BOTTOM: 185.63,184.88 185.63,179.11 185.43,178.91 184.23,178.91 184,179.14 184,184.88 184.03,184.88 184.13,184.98 185.53,184.98
GND on BOTTOM: 221.39,4.71 222.66,4.71 222.99,4.38 222.99,3.65 222.76,3.41 220.71,3.41 220.2,3.93 220.2,4.41 220.5,4.71 221.39,4.71
GND on BOTTOM: 164.33,129.26 165.22,130.15 166.87,130.15 167.19,130.47 167.19,131.23 167.32,131.36 168.59,131.36 169.92,130.02 169.92,127.48 169.25,126.82 164.81,126.82 164.33,127.29
GND on BOTTOM: 191.57,129.2 191.52,129.25 191.52,130.42 192.08,130.98 192.08,132.5 192.21,132.63 199.4,132.63 199.6,132.42 199.6,129.86 199.32,129.58 196.32,129.58 195.94,129.2
GND on BOTTOM: outline of 109 points within 131.75,135.48 144.19,137.84
GND on BOTTOM: 39.93,90.62 38.36,92.19 38.36,101 43.36,106.01 43.36,108.17 44.35,109.16 44.35,109.87 45.55,111.06 46.95,111.06 52.08,116.19 53.9,116.19 55.67,114.43 55.67,112.97 54.83,112.13 53.55,112.13 51.67,110.25 51.67,109.21 52.48,108.4 55.99,108.4 56,108.38 60.98,108.38 63.18,106.19 63.18,102.12 64.57,100.73 64.57,99.43 64.45,99.3 51.92,99.3 43.24,90.62
GND on BOTTOM: 154.56,132.47 153.79,133.23 153.79,133.66 153.95,134 153.72,134.3 153.69,134.31 153.69,134.41 153.72,134.42 153.87,134.53 153.95,134.7 153.95,134.72 154.14,134.91 154.18,134.88 154.56,134.84 154.76,135.17 154.75,135.19 154.84,135.28 154.98,135.28 155.03,135.25 155.08,135.16 155.03,135.07 155.2,134.4 155.37,135.07 155.32,135.16 155.37,135.25 155.53,135.42 155.55,135.65 155.56,135.73 155.64,135.77 155.68,135.77 155.75,135.74 155.78,135.67 156.1,135.34 156.42,135.67 156.45,135.74 156.52,135.77 156.58,135.77 156.65,135.74 156.68,135.67 156.77,135.44 156.98,135.34 157.05,135.31 157.08,135.24 157.08,134.49 157.05,134.42 156.98,134.39 156.79,134.34 156.65,134.21 156.7,134.16 156.7,133.09 156.08,132.47
GND on BOTTOM: 1.66,26.66 1.66,34.74 11.83,34.74 12.8,35.49 12.34,36.62 12.34,36.84 14.38,36.84 15.45,37.91 15.45,43.7 16.03,44.29 20.12,44.29 20.48,43.93 20.48,39.69 19.18,38.39 19.18,35.19 16.87,32.88 16.87,27.83 15.22,26.18 12.69,26.18 12.32,26.53 11.83,26.66
GND on BOTTOM: 232.57,139.79 230.92,141.44 230.89,141.47 230.89,141.95 232.53,143.59 233.31,143.59 233.34,143.62 234.26,143.62 234.3,143.59 236.92,143.59 237.65,144.31 238.33,144.31 238.99,143.65 238.99,142.48 237.23,140.72 235.63,140.72 234.96,141.39 234.92,141.43 234.88,141.47 234.86,141.49 234.85,141.49 234.65,141.54 234.45,141.49 234.28,141.24 234.34,140.95 233.18,139.79
GND on BOTTOM: 231.7,150.53 232.97,149.26 232.97,148.39 231.34,146.75 229.06,146.75 228.38,147.44 228.38,149.8 229.11,150.53
GND on BOTTOM: 203.76,187.14 203.76,188.25 204.17,188.66 207.42,188.66 207.78,188.3 207.78,187.09 207.55,186.86 204.04,186.86
GND on BOTTOM: outline of 200 points within 1.66,0.51 250.69,188.49
GND on IN1: 23.42,65.31 27.36,65.31 27.93,64.74 27.93,60.62 27.01,59.7 23.3,59.7 22.55,60.45 22.55,64.43
GND on IN1: 122.33,25.16 128.53,25.16 129.7,23.99 129.7,9.62 128.28,8.19 123.5,8.19 115.27,16.42 115.27,19.24 117.68,21.66 118.83,21.66
GND on IN1: 179.89,40.71 183.24,40.71 184,39.94 184,31.1 183.37,30.47 183.37,19.75 182.45,18.84 177.91,18.84 176.94,19.8 176.94,37.76
GND on IN1: 131.78,138.27 143.47,138.27 144.89,136.84 144.89,130.82 142.59,128.53 125.6,128.53 124.47,129.66 124.47,130.95
GND on IN1: outline of 307 points within 0.51,0.51 250.69,189.84 ; 1 cut-out
GND on IN1: 67.42,24.78 65.59,26.61 54.9,26.61 52.97,28.54 52.97,40.93 53.98,41.95 113.39,41.95 114.53,40.81 114.53,28.61 112.99,27.07 79.38,27.07 77.1,24.78
GND on IN1: 83.78,24.55 105.37,24.55 106.71,23.2 106.71,17.59 106,16.88 80.98,16.88 80.5,17.36 80.5,21.27
GND on IN1: 169.98,128.28 170.08,128.18 170.08,127.52 169.35,126.79 165.16,126.79 164.9,127.04 164.9,130.34 165.54,130.98 169.22,130.98 169.98,130.21
GND on IN1: 179.43,153.66 193.25,153.66 194.54,152.36 194.54,143.52 192.79,141.77 179.63,141.77 178.29,143.12 178.29,152.52
GND on IN1: 160.61,36.69 168.84,28.46 168.84,25.34 164.14,20.64 158.27,20.64 151.47,27.45 151.47,35.45 152.71,36.69
GND on IN1: 106.61,174.74 117.46,174.74 118.85,176.14 118.85,177.84 118.83,177.87 118.83,178.78 119.18,179.14 123.17,179.14 123.58,178.73 123.58,169.94 122.38,168.75 113.06,168.75 106.72,162.41 104.84,162.41 103.97,161.53 103.97,161.48 103.43,160.95 103.43,151.91 103.97,151.37 103.97,151.17 105.42,149.72 105.42,138.52 104.3,137.4 100.01,137.4 97.15,134.55 95.42,134.55 92.82,137.15 92.82,142.71 100.08,149.98 100.08,168.21
GND on IN1: 186.57,126.43 200.79,126.43 202.32,124.91 202.32,117.64 199.09,114.42 199.09,103.09 198,102 172.55,102 171.61,102.94 171.61,106.54 173.82,108.75 173.82,118.53 176.13,120.84 180.98,120.84
GND on IN2: 179.46,153.71 193.71,153.71 194.9,152.52 194.9,142.99 193.2,141.29 179.74,141.29 178.9,142.13 178.9,153.15
GND on IN2: 169.2,131.15 170.24,130.11 170.24,127.8 168.93,126.49 165.12,126.49 164.78,126.84 164.78,129.96 165.97,131.15
GND on IN2: 164.5,106.85 204.55,106.85 211.33,100.07 211.33,52.08 211.32,52.07 211.32,51.21 210.62,50.51 207.83,50.51 207.09,51.25 204.32,51.25 202.49,53.08 202.49,57.52 196.58,63.44 196.58,70.4 177.76,89.22 166.45,89.22 163.02,92.65 163.02,105.37
GND on IN2: outline of 201 points within 1.66,0.51 250.69,189.85
GND on IN2: 63.68,24.75 56.9,31.54 56.9,33.87 50.09,40.68 50.09,50.84 50.58,51.32 50.58,55.28 52,56.71 52,58.97 50.58,60.39 50.58,68.77 49.54,69.81 49.54,76.42 51.67,78.55 51.67,81.75 60.76,90.84 78.56,90.84 80.57,88.84 86.82,88.84 87.74,87.92 91.09,87.92 92,88.84 98.58,88.84 98.89,88.53 98.89,85.46 101.5,82.84 105.16,82.84 114.84,73.17 114.84,69.79 117.23,67.4 117.23,65.67 129.19,53.71 129.19,44.95 128,43.75 128,37.68 126.09,35.78 126.09,33.57 118.78,26.25 109.66,26.25 108.16,24.75 ; 1 cut-out
GND on VCC: 210.37,154.73 210.37,149.77 210.69,149.46 211.83,149.46 212.46,150.09 215.7,150.09 216.08,150.47 216.08,154.6 215,155.68 210.88,155.68 210.75,155.55 210.75,155.11
GND on VCC: outline of 325 points within 0.51,0.51 250.69,194.64 ; 1 cut-out
GND on VCC: 99.92,30.34 99.92,34.92 99.56,35.27 99.56,37.71 100.32,38.47 100.32,40.68 102.74,43.09 102.74,49.34 103.12,49.72 103.12,53.35 101.75,54.71 99.78,54.71 87.39,67.1 87.39,70.53 87.33,70.59 87.33,70.73 87.26,70.81 87.26,79.65 87.2,79.7 87.2,79.82 87.74,80.35 87.83,80.35 87.83,80.35 87.94,80.24 97.11,80.24 98.09,81.22 98.09,84.29 98.02,84.36 98.02,88.46 98.23,88.66 106.2,88.66 108.77,86.1 108.77,84.35 108.64,84.22 108.64,84.01 115.78,76.87 128.6,76.87 128.96,76.52 128.96,71.69 130.13,70.52 132.64,70.52 132.64,65.04 132.14,64.53 132.14,60.47 130.36,58.69 130.36,46.63 129.72,45.99 129.72,35.07 124.52,29.87 100.39,29.87
GND on IN3: outline of 174 points within 1.66,0.51 250.69,189.84
GND on IN3: 190.1,145 193.58,145 193.78,144.79 193.78,143.22 193.33,142.76 189.87,142.76 189.77,142.86 189.77,144.67
GND on IN3: 184.16,142.74 187.61,142.74 187.81,142.94 187.81,145.02 188.83,146.04 188.83,146.5 188.47,146.85 188.47,148.48 188.3,148.66 184.16,148.66 183.95,148.45 183.95,142.94
GND on IN3: 187.69,151.58 187.94,151.32 189.28,151.32 189.56,151.61 189.56,153.1 189.71,153.24 194.05,153.24 194.29,153 194.29,151.17 194.29,151.16 189.76,146.63 188.91,146.63 188.65,146.89 188.65,148.63 188.4,148.88 187.79,148.88 187.43,149.24 183.7,149.24 183.47,149.47 183.47,153.44 183.78,153.75 187.47,153.75 187.69,153.54
GND on IN3: 149.36,22.49 148.82,23.03 148.82,35.83 155.94,42.94 182.35,42.94 184.46,40.83 184.46,31.28 177.6,24.42 170.85,24.42 168.92,22.49 ; 1 cut-out
GNDA on GND1 (solid shape): outline of 791 points within 206.69,5.25 223.2,21.63
GNDA on VCC (solid shape): outline of 792 points within 206.69,5.25 223.2,21.62
GNDA on GND2 (solid shape): outline of 793 points within 206.69,5.25 223.2,21.62
GNDA on TOP: 210.37,14.37 212.32,14.37 212.5,14.19 212.5,13.2 212.25,12.94 210.47,12.94 210.09,13.32 210.09,14.09
GNDA on TOP: 215.19,16.91 215.86,16.91 215.98,16.78 215.98,14.98 215.83,14.82 215.25,14.82 215.02,15.05 215.02,16.73
GNDA on BOTTOM: 211.38,18.99 211.38,20.77 211.61,20.99 214.53,20.99 215.17,21.63 217.99,21.63 218.67,20.94 218.67,16.19 219.61,15.25 219.61,10.78 220.55,9.84 222.21,9.84 223.17,8.88 223.17,5.7 222.71,5.25 220.22,5.25 220.02,5.45 220.02,6.64 215.96,10.71 215.96,11.8 215.02,12.74 210.47,12.74 209.07,14.14 208.84,14.14 206.69,16.3 206.69,17.97 207.3,18.58 210.98,18.58
GNDA on IN2: 219.61,10.78 220.55,9.84 222.23,9.84 223.2,8.88 223.2,5.75 222.69,5.25 220.25,5.25 220.02,5.48 220.02,6.62 215.96,10.68 215.96,11.85 215.04,12.77 210.47,12.77 209.1,14.14 208.84,14.14 206.71,16.27 206.71,17.97 207.32,18.58 211,18.58 211.38,18.96 211.38,20.77 211.61,20.99 214.56,20.99 215.19,21.63 215.6,21.63 215.61,21.62 217.99,21.62 219.61,19.99
VCC0R9GBE on TOP (solid shape): 51.9,119.27 51.9,118.96 51.8,118.86 50.22,118.86 50.15,118.94 50.15,119.09 51.24,119.09 51.24,119.22 50.15,119.22 50.15,119.42 50.18,119.46 51.71,119.46
VCC0R9GBE on BOTTOM (solid shape): 51.47,128.13 51.47,126.02 51.19,125.74 47.66,125.74 47.05,126.35 47.05,127.88 47.43,128.26 51.34,128.26
VCC0R9GBE on TOP: 48.49,128.41 51.64,128.41 52,128.06 52,126.63 51.77,126.4 50.35,126.4 49.71,125.77 48.27,125.77 48.14,125.9 48.14,128.06
VCC0R9GBE on IN2: 47.45,128.36 51.11,128.36 51.57,127.9 51.57,126.91 49.79,125.13 49.79,120.97 51.24,119.52 51.92,119.52 52.1,119.34 52.1,115.05 52.05,115 48.9,115 47.99,114.09 42.78,114.09 42.36,114.5 42.36,121.41 43.19,122.24 47.1,122.24 47.15,122.29 47.15,128.06
VCC0R9GBE_L on BOTTOM (solid shape): 47.69,124.81 47.83,124.78 47.98,124.81 47.99,124.81 49.38,124.81 49.52,124.67 49.52,123.22 49.22,122.92 48.38,122.92 47.94,122.48 47.94,122.02 47.84,121.92 47.48,121.92 47.46,121.95 47.15,122.16 46.81,122 46.77,121.98 46.72,122 46.66,122.05 46.66,122.79 47.18,123.3 47.18,124.66 47.33,124.81 47.68,124.81
VCC0R9GBE_L on TOP: 47.23,123.67 48.4,123.67 48.47,123.59 48.47,122.96 47.95,122.43 47.17,122.43 47.07,122.54 47.07,123.51
VDD_62771 on BOTTOM (solid shape): 211.46,155.84 211.46,155.01 211.41,154.95 211.26,154.95 210.55,155.67 210.55,156 210.72,156.17 211.13,156.17
VDDPALW_PWRGD on BOTTOM (solid shape): 139.48,48.17 139.48,47.92 138.82,47.26 138.26,47.26 138.16,47.36 138.16,47.84 138.54,48.22 139.43,48.22
VIN_1.00VS on BOTTOM (solid shape): 143.74,59.63 143.74,59.15 143.8,59.09 144.28,59.09 144.3,59.12 144.3,59.63 144.33,59.65 144.51,59.65 144.53,59.63 144.53,59.15 144.58,59.09 146.06,59.09 146.26,58.89 146.26,53.15 145.27,52.16 144.48,52.16 144.23,51.91 144.23,50.74 143.85,50.36 142.07,50.36 141.97,50.46 141.97,58.59 142.47,59.09 143.47,59.09 143.52,59.15 143.52,59.63 143.54,59.65 143.72,59.65
VIN_+1.8VSP on BOTTOM (solid shape): 189.01,182.06 189.01,179.73 188.98,179.73 188.98,179.3 189.01,179.3 189.01,179.14 188.86,178.98 186.39,178.98 185.98,179.39 185.98,183.15 186.11,183.28 187.79,183.28
VSSIO_SENSE on TOP: 97.47,82.97 97.47,88.18 97.08,88.56 96.37,88.56 96.27,88.46 96.27,88.2 96.42,88.05 96.7,88.05 96.83,87.92 96.83,85 96.45,84.62 96.45,83.61 96.7,83.35 96.7,83.1 96.83,82.97
(no net) on TOP: 176.61,131.48 179.41,131.48 180.32,130.57 180.32,129.4 179.76,129.4 179.76,128.67 180.3,128.67 180.3,128.21 179.76,128.21 179.76,127.47 180.3,127.47 180.3,126.46 180.07,126.23 178.92,126.23 176.36,128.79 176.36,131.23
(no net) on TOP: 167.62,183.1 166.4,183.1 165.97,182.67 165.18,182.67 165.13,182.72 165.13,183.73 163.12,185.74 163.12,187.03 163.35,187.26 167.44,187.26 167.85,186.86 167.85,183.33
(no net) on IN2: outline of 83 points within 180.19,18.15 247.09,159.99
(no net) on IN2: 224.16,107.48 224.16,106.77 222.41,105.02 207.12,105.02 204.48,107.66 178.19,107.66 175.32,110.53 175.32,123.81 180.63,129.12 198.23,129.12 198.68,128.67 198.68,125.47 197.59,124.37 183.09,124.37 180.02,121.3 180.02,113.45 181.95,111.52 220.12,111.52
+CRD_POWER on TOP: 46.92,31.49 47.2,31.49 47.33,31.36 47.33,30.82 46.95,30.44 46.95,30.14 46.77,29.96 46.56,29.96 46.44,30.09 46.44,31
+CRD_POWER on BOTTOM: 31.68,31.87 31.68,29.99 31.48,29.78 29.7,29.78 29.55,29.94 29.55,31.56 31.07,33.09 31.07,35.02 31.51,35.46 40.33,35.46 43.67,32.12 47.38,32.12 47.61,31.89 47.61,30.67 47.2,30.27 42.68,30.27 39.83,33.11 32.92,33.11
+DCPRTC on TOP (solid shape): 106.42,82.34 106.42,81.89 106.29,81.76 104.39,81.76 104.2,81.57 103.92,81.57 103.8,81.7 103.8,81.97 104.29,82.46 106.29,82.46
+LCDVDD_CON on BOTTOM (solid shape): 94.77,136.56 94.77,136.07 92.58,133.87 91.62,133.87 90.63,134.86 90.63,135.22 92.21,136.8 92.33,136.83 92.42,136.74 92.84,136.47 93.17,136.84 93.17,137.53 93.3,137.66 93.33,137.73 93.61,137.73
+LCDVDD_CON on TOP: 93.83,136.56 94.24,136.56 96.63,138.95 96.63,139.21 96.04,139.79 95.43,139.79 93.27,137.63 93.27,137.12
+LEDVDD on TOP (solid shape): 101.66,139.23 101.66,138.95 101.4,138.7 101.4,137 101.75,136.65 102.22,136.65 102.62,136.25 102.62,136.07 101.32,134.77 101.32,134.59 100.63,133.9 100.13,133.9 99.86,134.17 99.86,135.15 99.76,135.25 99.76,135.71 99.3,136.16 99.3,138.62 99.09,138.83 99.09,139 99.82,139.73 101.16,139.73
+PCH_CORE on TOP: 115.82,90.53 114.23,88.94 108.01,88.94 106.99,89.96 105.34,89.96 105.15,90.15 101.54,90.15 100.62,91.07 100.44,91.07 100.06,90.69 100.06,90.64 98.58,90.64 98.02,91.2 98.02,92.05 98.39,92.42 101.1,92.42 102.29,93.61 110.12,93.61 110.39,93.89 115.63,93.89 115.65,93.87 116.24,93.87 117.02,93.08 120.2,93.08 120.21,93.07 120.76,93.07 121.34,92.5 123.12,92.5 123.25,92.37 123.25,90.4 123.06,90.21 120.59,90.21 120.27,90.53
