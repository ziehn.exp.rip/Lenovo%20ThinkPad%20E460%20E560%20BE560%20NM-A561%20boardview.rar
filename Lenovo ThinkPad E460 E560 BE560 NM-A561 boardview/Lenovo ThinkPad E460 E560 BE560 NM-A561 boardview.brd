# Allegro board Lenovo ThinkPad E460 E560 BE560 NM-A561 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA0_EDC2: length 27.3
  IN3 w0.14: v1(127.56,143.03) 123.75,143.03 123.56,143.22 123.56,143.92 123.37,144.11 123.1,144.11 122.92,143.92 122.92,143.22 122.73,143.03 122.46,143.03 122.27,143.22 122.27,143.92 122.08,144.11 121.81,144.11 121.62,143.92 121.62,143.22 121.43,143.03 121.16,143.03 120.97,143.22 120.97,143.92 120.78,144.11 120.51,144.11 120.32,143.92 120.32,143.22 120.13,143.03 119.87,143.03 119.68,143.22 119.68,143.92 119.49,144.11 119.22,144.11 119.03,143.92 119.03,143.22 118.84,143.03 118.36,143.03 116.76,144.63 114.22,144.63 114.03,144.44 v1(113.52,144.44)
  BOTTOM w0.084: UV1.D25 131.09,143.76 130.74,143.41 130.47,143.41 130.44,143.43 130.33,143.47 129.93,143.47 129.85,143.4 127.93,143.4 v1(127.56,143.03)
  BOTTOM w0.14: v1(113.52,144.44) 113.52,143.56 UV6.R13
FBA0_EDC3: length 36
  BOTTOM w0.084: 126.79,146.73 128.39,146.73 128.86,147.21 129.33,147.21 129.34,147.21 130.39,147.21 130.56,147.39 131.43,147.39 UV1.E20
  BOTTOM w0.14: UV6.R2 104.31,143.43 103.86,143.89 103.86,144.9 103.74,145.02 103.74,145.79 106.07,148.12 115.42,148.12 116.99,146.55 118.64,146.55 118.83,146.36 118.83,146.03 119.02,145.84 119.28,145.84 119.47,146.03 119.47,146.36 119.66,146.55 119.93,146.55 120.12,146.36 120.12,146.03 120.31,145.84 120.58,145.84 120.77,146.03 120.77,146.36 120.96,146.55 121.23,146.55 121.42,146.36 121.42,146.03 121.61,145.84 121.88,145.84 122.06,146.03 122.06,146.36 122.25,146.55 v4(122.82,146.55) 126.3,146.55 126.49,146.73 126.79,146.73
FBA1_D0: length 33.7
  TOP w0.14: v1(103.89,152.05) 103.89,151.79 107.74,147.94 v4(122.79,147.94) 123.97,147.94 124.16,148.13 124.16,148.87 124.35,149.06 124.61,149.06 124.8,148.87 124.8,148.13 124.99,147.94 125.3,147.94 v1(127.18,149.82)
  BOTTOM w0.084: UV1.C18 130.7,149.36 130.36,149.03 130,149.03 129.91,149.11 127.9,149.11 v1(127.18,149.82)
  BOTTOM w0.14: v1(103.89,152.05) 104.14,152.31 104.14,153.21 104.31,153.38 UV5.A2
FBA1_D1: length 33.1
  TOP w0.14: v1(127.82,149.85) 127.82,149.57 125.7,147.45 v4(115.88,147.45) 107.54,147.45 103.36,151.64 103.36,152.41 v3(103.61,152.66)
  BOTTOM w0.084: UV1.A18 130.12,149.28 128.42,149.28 127.84,149.86 127.84,149.85 v1(127.82,149.85)
  BOTTOM w0.14: v3(103.61,152.66) 103.61,153.02 103.94,153.35 103.94,154 UV5.B2
FBA1_D2: length 40.1
  TOP w0.14: v1(103.88,156.35) 103.86,156.32 103.18,156.32 102.42,155.57 102.42,151.89 107.34,146.97 v4(125.28,146.97) 125.9,146.97 128.45,149.52 v1(128.45,149.85)
  BOTTOM w0.084: UV1.F18 132.36,149.8 130.97,149.8 130.82,149.65 130.38,149.65 130.34,149.69 130.06,149.69 129.82,149.45 128.86,149.45 128.46,149.85 v1(128.45,149.85)
  BOTTOM w0.14: UV5.E2 v1(103.88,156.35)
FBA1_D3: length 40.9
  TOP w0.14: v1(129.04,149.88) 129.04,149.39 126.11,146.47 v4(119.89,146.47) 107.16,146.47 101.94,151.69 101.94,155.77 103.22,157.05 103.76,157.05 v1(103.88,157.17)
  BOTTOM w0.084: UV1.D17 131.1,150.16 130.75,149.81 130.45,149.81 130.41,149.86 129.99,149.86 129.75,149.61 129.28,149.61 129.04,149.85 v1(129.04,149.88)
  BOTTOM w0.14: UV5.F2 103.91,157.18 103.89,157.18 v1(103.88,157.17)
FBA1_D4: length 33.5
  TOP w0.14: v1(127.06,151.75) 125.84,151.75 125.84,151.76 v4(123.45,151.76) 120.86,151.76 120.67,151.57 120.67,150.09 120.48,149.9 120.21,149.9 120.02,150.09 120.02,151.57 119.83,151.76 119.56,151.76 119.37,151.57 119.37,150.09 119.18,149.9 118.92,149.9 118.73,150.09 118.73,151.16 118.59,151.3 118.22,151.3 118.08,151.16 118.08,150.23 117.74,149.89 109.35,149.89 106.35,152.89 v1(106.35,152.99)
  BOTTOM w0.084: v1(127.06,151.75) 127.64,151.17 129.99,151.17 UV1.A16
  BOTTOM w0.14: v1(106.35,152.99) 105.91,153.43 UV5.A4
FBA1_D5: length 35.1
  TOP w0.14: v1(106.35,156.37) 106.35,155.36 106.77,154.93 106.77,153.28 109.63,150.43 110.65,150.43 110.79,150.57 110.79,150.93 110.93,151.07 111.3,151.07 111.44,150.93 111.44,150.57 111.58,150.43 111.95,150.43 112.09,150.57 112.09,150.93 112.23,151.07 112.6,151.07 112.74,150.93 112.74,150.57 112.88,150.43 113.24,150.43 113.38,150.57 113.38,150.93 113.52,151.07 113.89,151.07 114.03,150.93 114.03,150.57 114.17,150.43 116.51,150.43 118.32,152.24 v4(120.4,152.24) 127.28,152.24 v1(127.72,151.8)
  BOTTOM w0.084: v1(127.72,151.8) 128.16,151.36 130.03,151.36 130.03,151.36 130.27,151.36 130.43,151.2 130.75,151.2 130.75,151.2 130.78,151.2 130.95,151.37 131.86,151.37 132.07,151.16 UV1.F16
  BOTTOM w0.14: v1(106.35,156.37) 105.94,156.78 UV5.E4
FBA1_D6: length 33.3
  TOP w0.14: v1(128.35,151.91) 128.23,151.91 127.41,152.72 126.27,152.72 125.89,153.09 v4(118.32,153.09) 117.35,153.09 116.88,152.62 116.88,152.36 117.17,152.07 117.17,151.8 116.98,151.61 116.71,151.61 116.42,151.9 116.15,151.9 115.83,151.58 115.63,151.58 115.49,151.44 115.49,151.06 115.35,150.92 114.98,150.92 114.84,151.06 114.84,151.44 114.7,151.58 110.88,151.58 110.47,151.98 108.77,151.98 108.76,151.98 107.26,153.48 107.26,155.13 106.85,155.55 106.85,156.59 106.64,156.8 106.64,156.81 106.36,157.09 v1(106.36,157.19)
  BOTTOM w0.084: UV1.D15 131.08,151.76 130.68,151.36 130.5,151.36 130.34,151.53 128.76,151.53 128.38,151.91 v1(128.35,151.91)
  BOTTOM w0.14: v1(106.36,157.19) 105.97,157.58 UV5.F4
FBA1_D7: length 33.6
  TOP w0.14: v1(105.53,154) 105.54,154 105.87,153.67 105.87,152.69 109.15,149.41 121.06,149.41 121.25,149.6 121.25,150.78 121.44,150.97 121.71,150.97 121.9,150.78 v4(121.9,149.95) 121.9,149.6 122.09,149.41 122.32,149.41 124.19,151.27 128.5,151.27 128.94,151.7 v1(128.94,151.93)
  BOTTOM w0.084: v1(128.94,151.93) 129.29,152.29 129.66,152.29 129.91,152.05 130.35,152.05 130.49,152.12 130.52,152.15 130.53,152.16 131.4,152.16 UV1.E14
  BOTTOM w0.14: v1(105.53,154) 105.54,154 UV5.B4
FBA1_D8: length 23.4
  IN3 w0.084: v1(131.98,152.03) 131.02,152.03 130.21,151.22 128.76,151.22 128.35,150.81 127.82,150.81
  IN3 w0.14: 127.82,150.81 113.76,150.81 111.91,152.66 v1(111.91,153.18)
  BOTTOM w0.084: v1(131.98,152.03) 132.6,152.65 UV1.F14
  BOTTOM w0.14: UV5.A11 v1(111.91,153.18)
FBA1_D9: length 20.5
  IN3 w0.084: 127.85,153.28 v1(128.43,153.87)
  IN3 w0.14: 127.85,153.28 127.46,153.28 125.91,151.73 114.76,151.73 113.51,152.98 v1(113.51,153.18)
  BOTTOM w0.084: UV1.D13 131.07,153.03 130.45,153.03 130.39,153.1 129.61,153.1 129.39,153.32 128.97,153.32 v1(128.43,153.87)
  BOTTOM w0.14: UV5.A13 v1(113.51,153.18)
FBA1_D10: length 24.2
  IN3 w0.084: 127.82,151.3 128.05,151.3 128.25,151.5 129.77,151.5 131.68,153.41 v1(131.98,153.41)
  IN3 w0.14: v1(111.91,153.98) 112.04,153.98 112.47,153.55 112.78,153.55 113.06,153.27 113.06,152.69 114.46,151.3 127.82,151.3
  BOTTOM w0.084: v1(131.98,153.41) 132.08,153.5 132.08,153.84 UV1.F12
  BOTTOM w0.14: UV5.B11 v1(111.91,153.98)
FBA1_D11: length 19
  IN3 w0.14: v1(127.79,153.89) 127.35,153.89 125.62,152.16 115.98,152.16 114.76,153.39 114.11,153.39 v1(113.51,153.98)
  BOTTOM w0.084: UV1.A12 130.04,154.32 128.23,154.32 v1(127.79,153.89)
  BOTTOM w0.14: UV5.B13 v1(113.51,153.98)
FBA1_D12: length 19.8
  IN3 w0.14: v1(127.31,155.06) 125.94,155.06 125.43,154.55 116.95,154.55 115.12,156.38 v1(113.57,156.38)
  BOTTOM w0.084: UV1.D11 130.99,154.55 130.54,154.55 130.39,154.7 127.67,154.7 v1(127.31,155.06)
  BOTTOM w0.14: UV5.E13 113.51,156.38 v1(113.57,156.38)
FBA1_D13: length 24.3
  IN3 w0.14: v1(111.91,157.18) 112.31,157.58 112.31,158.14 112.55,158.38 115.12,158.38 117.71,155.79 124.59,155.79 125.02,156.22 127.95,156.22 128.64,155.53 128.65,155.53 128.88,155.3 128.88,155.29 v1(129.07,155.11)
  BOTTOM w0.084: UV1.F10 132.59,155.96 132,155.37 130.55,155.37 130.43,155.25 129.99,155.25 129.81,155.42 129.38,155.42 v1(129.07,155.11)
  BOTTOM w0.14: UV5.F11 v1(111.91,157.18)
FBA1_D14: length 18.7
  IN3 w0.084: v1(127.9,155.13) 127.82,155.21
  IN3 w0.14: v1(113.55,157.14) 113.58,157.18 114.96,157.18 117.03,155.11 125.13,155.11 125.56,155.54 127.49,155.54 127.82,155.21
  BOTTOM w0.084: UV1.A10 128.53,155.76 v1(127.9,155.13)
  BOTTOM w0.14: UV5.F13 v1(113.55,157.14)
FBA1_D15: length 22.1
  IN3 w0.14: v1(128.48,155.13) 127.73,155.88 125.16,155.88 124.73,155.45 117.48,155.45 115.35,157.58 113.31,157.58 113.11,157.38 113.11,157.01 112.88,156.78 112.49,156.78 112.09,156.38 v1(111.91,156.38)
  BOTTOM w0.084: v1(128.48,155.13) 128.94,155.59 129.88,155.59 130.04,155.43 130.38,155.43 130.71,155.76 UV1.C10
  BOTTOM w0.14: UV5.E11 v1(111.91,156.38)
FBA1_D16: length 27.6
  IN3 w0.084: 127.82,158.62 129.81,158.62 131.12,157.31 131.12,155.18 133.03,153.28 v1(133.03,153.23)
  IN3 w0.14: v5(114.98,161.22) 117.35,163.59 122.85,163.59 127.82,158.62
  BOTTOM w0.084: UV1.G13 133.4,153.6 v1(133.03,153.23)
  BOTTOM w0.14: UV5.M13 113.52,161.98 114.23,161.98 v5(114.98,161.22)
FBA1_D17: length 29.3
  IN3 w0.084: 128.14,159.03 129.74,159.03 131.45,157.32 131.45,156.17 132.52,155.09 132.52,154.23 133,153.75 134.35,153.75 134.88,153.23 v1(134.96,153.23)
  IN3 w0.14: v3(113.51,162.78) 113.77,162.52 115.29,162.52 116.74,163.97 123.2,163.97 128.14,159.03
  BOTTOM w0.084: UV1.H13 134.42,153.76 v1(134.96,153.23)
  BOTTOM w0.14: v3(113.51,162.78) 113.11,163.18 UV5.N13
FBA1_D18: length 30.4
  IN3 w0.084: v1(134.3,154.34) 133.89,153.94 133.08,153.94 132.71,154.31 132.71,155.17 131.76,156.12 131.76,157.37 130.89,158.23 130.89,158.41 129.77,159.53 128.25,159.53 127.82,159.96
  IN3 w0.14: v1(111.91,162.78) 112.69,163.55 115.42,163.55 116.22,164.35 123.42,164.35 127.82,159.96
  BOTTOM w0.084: UV1.J13 134.88,153.76 v1(134.3,154.34)
  BOTTOM w0.14: UV5.M11 v1(111.91,162.78)
FBA1_D19: length 30.2
  IN3 w0.084: 128.61,159.86 130,159.86 131.34,158.52 131.34,158.06 132.59,156.81 132.59,156.1 133.66,155.03 134.26,155.03 134.91,154.38 v1(134.91,154.34)
  IN3 w0.14: 128.61,159.86 123.75,164.71 115.54,164.71 v3(115.21,164.38)
  BOTTOM w0.084: v1(134.91,154.34) 134.29,154.96 UV1.H11
  BOTTOM w0.14: v3(115.21,164.38) 115.21,163.97 114.8,163.55 111.89,163.55 UV5.N11
FBA1_D20: length 26.9
  IN3 w0.084: 129.34,161.1 129.57,160.87 130.21,160.87 132.14,158.94 132.62,158.94 133.38,158.18 133.38,156.83 v1(133.83,156.39)
  IN3 w0.14: 129.34,161.1 123.25,167.2 113.93,167.2 v1(113.69,166.96)
  BOTTOM w0.102: v1(133.83,156.39) UV1.G10
  BOTTOM w0.14: UV5.U13 v1(113.69,166.96)
FBA1_D21: length 28.5
  IN3 w0.084: 129.56,163.7 129.77,163.49 129.77,162.96 130.26,162.47 130.74,162.47 133.33,159.88 133.33,158.71 133.81,158.23 v1(133.81,157.98)
  IN3 w0.14: 129.56,163.7 129.18,164.09 126.92,164.09 123.35,167.65 113.69,167.65 113.11,167.07 113.11,166.38 v1(112.71,165.98)
  BOTTOM w0.102: v1(133.81,157.98) 133.4,157.57 UV1.G8
  BOTTOM w0.14: v1(112.71,165.98) UV5.T13
FBA1_D22: length 33.9
  IN3 w0.084: 130.44,164.58 131.22,163.79 131.22,163.08 135.01,159.3 135.01,156.92 135.4,156.53 v1(135.4,156.36)
  IN3 w0.14: v1(111.11,165.98) 111.51,166.38 111.51,167.02 113.16,168.67 123.3,168.67 126.71,165.27 129.75,165.27 130.44,164.58
  BOTTOM w0.084: v1(135.4,156.36) UV1.K9
  BOTTOM w0.14: v1(111.11,165.98) UV5.T11
FBA1_D23: length 32.6
  IN3 w0.084: v1(135.36,155.54) 135.34,155.54 135.01,155.87 135.01,156.53 134.19,157.34 134.19,159.68 130.92,162.96 130.92,163.59 130.18,164.33
  IN3 w0.14: v1(111.91,166.78) 113.32,168.19 123.3,168.19 126.73,164.76 129.75,164.76 130.18,164.33
  BOTTOM w0.084: v1(135.36,155.54) 135.38,155.54 UV1.K10
  BOTTOM w0.14: v1(111.91,166.78) UV5.U11
FBA1_D24: length 41.9
  BOTTOM w0.084: 128.35,157.61 128.66,157.61 129.16,157.12 129.95,157.12 130.05,157.01 130.28,157.01 130.44,157.09 arc(130.6,157.13) 130.77,157.09 130.92,157.01 130.96,156.97 132.16,156.97 132.3,157.11 133.03,157.11 133.08,157.06 UV1.G9
  BOTTOM w0.14: UV5.T4 106.36,166.02 109.63,166.02 111.11,167.51 114.4,167.51 115.83,166.08 118.47,166.08 119.16,165.39 119.16,164.28 119.79,163.64 122.05,163.64 124.44,161.25 124.44,157.14 123.68,156.38 123.68,154.62 v4(124.01,154.29) 124.19,154.12 125.25,154.12 127.69,156.55 127.69,157.32 127.99,157.61 128.35,157.61
FBA1_D25: length 40.9
  BOTTOM w0.14: UV5.U4 106.35,166.82 109.66,166.82 110.88,168.04 114.63,168.04 115.98,166.69 v4(117.48,166.69) 118.55,166.69 120.03,165.2 120.03,165.01 119.69,164.66 119.69,164.46 119.95,164.2 120.14,164.2 120.49,164.55 120.69,164.55 121.04,164.2 122.18,164.2 124.92,161.45 124.92,156.94 124.16,156.18 124.16,154.82 124.39,154.6 125,154.6 125.35,154.95 125.35,155.14 125.06,155.43 125.06,155.63 125.32,155.89 125.52,155.89 125.8,155.6 126,155.6 126.26,155.86 126.26,156.06 125.98,156.34 125.98,156.54 126.24,156.8 126.44,156.8 126.72,156.52 126.92,156.52 127.13,156.73 127.13,157.49 127.62,157.98 128.61,157.98 129.23,157.36 UV1.A8
FBA1_D26: length 41.7
  BOTTOM w0.084: 129.18,157.75 129.32,157.61 129.91,157.61 130.01,157.66 130.13,157.71 130.28,157.71 130.37,157.67 130.39,157.66 130.39,157.66 130.44,157.64 130.71,157.36 UV1.C8
  BOTTOM w0.14: 129.18,157.75 128.58,158.36 126.56,158.36 126.42,158.22 126.42,157.51 126.28,157.37 125.92,157.37 125.78,157.51 125.78,158.22 125.41,158.59 125.41,159.22 125.55,159.36 125.98,159.36 126.12,159.5 126.12,159.87 125.98,160.01 125.55,160.01 125.41,160.15 125.41,160.52 125.55,160.66 125.98,160.66 126.12,160.8 126.12,161.17 125.98,161.31 125.55,161.31 125.41,161.44 125.41,161.65 122.33,164.73 v4(121.82,164.73) 121.19,164.73 120.83,165.09 120.83,165.29 121.24,165.71 121.24,165.9 120.98,166.16 120.78,166.16 120.37,165.75 120.17,165.75 119.91,166.01 119.91,166.21 120.32,166.62 120.32,166.82 120.06,167.08 119.86,167.08 119.45,166.67 119.25,166.67 118.75,167.17 116.18,167.17 114.61,168.75 110.88,168.75 109.66,167.53 105.34,167.53 104.73,166.92 104.73,166 UV5.T2
FBA1_D27: length 42.3
  BOTTOM w0.084: UV1.E8 131.8,157.37 131.36,157.81 130.52,157.81 130.44,157.84 130.4,157.86 130.38,157.88 130.34,157.89 130.03,157.89 129.86,157.84 129.75,157.8 129.52,157.8 129.31,158.01
  BOTTOM w0.14: UV5.U2 104.25,166.45 104.25,166.65 104.25,166.65 104.25,167.12 105.21,168.09 109.53,168.09 110.68,169.23 114.81,169.23 116.38,167.66 116.67,167.66 116.8,167.8 116.8,169.09 116.94,169.23 117.31,169.23 117.45,169.09 117.45,167.8 117.59,167.66 117.96,167.66 118.1,167.8 118.1,169.04 118.24,169.18 118.61,169.18 118.75,169.04 118.75,167.8 118.89,167.66 119.26,167.66 119.4,167.8 119.4,168.63 119.54,168.77 119.9,168.77 120.04,168.63 120.04,167.8 120.18,167.66 120.76,167.66 v4(125.47,162.95) 126.63,161.79 126.63,160.59 128.49,158.73 128.59,158.73 129.31,158.01
FBA1_D28: length 42.8
  BOTTOM w0.084: 127.03,164.23 127.92,163.34 127.92,161.16 130.12,158.96 UV1.A6
  BOTTOM w0.14: UV5.N4 105.47,163.62 104.06,163.62 103.92,163.76 103.92,164.1 103.59,164.43 103.36,164.43 103.18,164.61 102.57,164.61 102.04,165.14 102.04,167.21 105.64,170.8 120.45,170.8 v4(122.1,169.16) 127.03,164.23
FBA1_D29: length 43.7
  BOTTOM w0.084: 127.4,164.59 128.26,163.73 128.26,161.06 130,159.32 130.66,159.32 131,158.98 UV1.C6
  BOTTOM w0.14: UV5.N2 104.05,163.18 103.61,163.62 103.36,163.62 103.18,163.8 102.62,163.8 101.56,164.86 101.56,167.41 105.44,171.29 120.71,171.29 v4(125.14,166.86) 127.4,164.59
FBA1_D30: length 48.5
  BOTTOM w0.084: 127.77,164.96 128.56,164.17 128.56,161 130.03,159.53 131.23,159.53 UV1.E6
  BOTTOM w0.14: 127.77,164.96 v4(121.43,171.3) 120.96,171.77 105.24,171.77 101.07,167.61 101.07,164.48 102.6,162.96 103.21,162.96 103.38,162.78 105.29,162.78 105.69,162.38 UV5.M4
FBA1_D31: length 47.1
  BOTTOM w0.084: UV1.A5 129.93,159.86 128.83,160.97 128.83,164.67 128.15,165.34
  BOTTOM w0.14: UV5.M2 103.95,162.02 102.77,162.02 100.59,164.2 100.59,167.81 105.04,172.26 v4(118.85,172.26) 121.24,172.26 128.15,165.34
FBA1_DBI0#: length 33.6
  TOP w0.14: v1(129.6,150.79) 129.09,150.28 126.8,150.28 126.16,149.63 v4(124.57,149.63) 124.1,149.63 122.89,148.42 108.13,148.42 104.47,152.08 104.47,154.77 103.89,155.35 103.89,155.54 v1(103.88,155.54)
  BOTTOM w0.084: UV1.C16 130.7,150.96 130.34,150.6 129.78,150.6 v1(129.6,150.79)
  BOTTOM w0.14: UV5.D2 103.89,155.55 103.89,155.54 v1(103.88,155.54)
FBA1_DBI1#: length 19
  IN3 w0.14: v1(113.51,155.58) 113.59,155.51 115.23,155.51 116.66,154.08 126.1,154.08 v1(126.42,154.4)
  BOTTOM w0.084: v1(126.42,154.4) 126.52,154.49 130.34,154.49 130.51,154.32 130.84,154.32 UV1.C12
  BOTTOM w0.14: UV5.D13 v1(113.51,155.58)
FBA1_DBI2#: length 27.8
  IN3 w0.084: 128.13,161.06 128.9,160.29 130,160.29 131.77,158.52 131.77,158.15 132.84,157.09 132.84,156.35 133.75,155.44 v1(133.86,155.44)
  IN3 w0.14: v1(113.51,164.38) 113.51,164.45 114.45,165.39 115.4,165.39 115.83,165.83 118.34,165.83 118.98,165.19 124,165.19 128.13,161.06
  BOTTOM w0.084: UV1.J11 134.71,154.96 134.23,155.44 v1(133.86,155.44)
  BOTTOM w0.14: UV5.P13 v1(113.51,164.38)
FBA1_DBI3#: length 41.9
  BOTTOM w0.084: UV1.F8 132.48,157.56 131.71,158.33 131.71,158.36 131.53,158.54 arc(131.34,158.63) 131.14,158.59 arc(131.06,158.57) 130.96,158.57 arc(130.86,158.61) 130.78,158.68 arc(130.61,158.74) 130.43,158.69 arc(130.38,158.65) 130.32,158.62 arc(130.25,158.61) 130.18,158.61 130.04,158.61 129.9,158.75 129.57,158.75 128.75,159.57 128.75,159.79 127.46,161.08 127.46,162.93 126.93,163.46
  BOTTOM w0.14: UV5.P2 104.31,164.19 103.96,164.54 103.96,164.84 103.57,165.24 103.27,165.24 102.53,165.98 102.53,166.98 105.77,170.22 120.17,170.22 v4(122.99,167.41) 126.93,163.46
FBA1_EDC0: length 33.4
  TOP w0.14: v1(128.99,150.76) 125.95,150.76 125.76,150.57 125.76,150.34 125.57,150.15 125.31,150.15 125.12,150.34 125.12,150.57 124.93,150.76 124.42,150.76 122.56,148.9 v4(118.83,148.9) 108.4,148.9 v3(104.98,152.33)
  BOTTOM w0.084: UV1.E16 131.48,150.64 131.14,150.64 131.14,150.63 130.86,150.63 130.86,150.64 130.61,150.64 130.41,150.43 129.32,150.43 v1(128.99,150.76)
  BOTTOM w0.14: v3(104.98,152.33) 104.47,152.84 104.47,153.2 104.66,153.39 104.66,154.84 UV5.C2
FBA1_EDC1: length 23.9
  IN3 w0.084: 127.82,154.39 128.5,154.39 v1(129.02,153.87)
  IN3 w0.14: v1(113.51,154.78) 113.61,154.68 114.48,154.68 116.36,152.8 117.48,152.8 117.67,152.99 117.67,153.32 117.86,153.51 118.13,153.51 118.32,153.32 118.32,152.99 118.51,152.8 118.78,152.8 118.97,152.99 118.97,153.32 119.16,153.51 119.43,153.51 119.62,153.32 119.62,152.99 119.81,152.8 120.07,152.8 120.26,152.99 120.26,153.32 120.45,153.51 120.72,153.51 120.91,153.32 120.91,152.99 121.1,152.8 125.63,152.8 127.22,154.39 127.82,154.39
  BOTTOM w0.084: UV1.E12 131.47,153.83 130.06,153.83 129.74,154.15 129.3,154.15 v1(129.02,153.87)
  BOTTOM w0.14: UV5.C13 v1(113.51,154.78)
FBA1_EDC2: length 28.2
  IN3 w0.084: v1(134.7,155.49) 134.35,155.84 133.74,155.84 133.13,156.45 133.13,157.16 132.2,158.09 132.2,158.47 130.05,160.62 129.2,160.62 128.77,161.04
  IN3 w0.14: v1(113.51,165.18) 113.51,165.54 114.31,166.33 118.82,166.33 119.38,165.77 124.04,165.77 128.77,161.04
  BOTTOM w0.084: UV1.J10 135,155.79 v1(134.7,155.49)
  BOTTOM w0.14: UV5.R13 v1(113.51,165.18)
FBA1_EDC3: length 40.8
  BOTTOM w0.084: 126.93,162.57 127.08,162.42 127.08,160.75 128.44,159.39 128.67,159.39 129.5,158.56 129.83,158.56 129.98,158.41 130.21,158.41 arc(130.31,158.41) 130.41,158.46 arc(130.51,158.51) 130.61,158.52 arc(130.65,158.52) 130.69,158.51 130.79,158.46 arc(130.88,158.4) 130.97,158.33 arc(131.17,158.2) UV1.D7
  BOTTOM w0.14: UV5.R2 104.31,165.05 103.86,165.51 103.86,166.52 103.74,166.64 103.74,167.4 105.95,169.61 106.25,169.61 106.4,169.46 106.4,168.78 106.59,168.59 106.86,168.59 107.05,168.78 107.05,169.55 107.24,169.74 107.51,169.74 107.7,169.55 107.7,168.78 107.89,168.59 108.16,168.59 108.35,168.78 108.35,169.55 108.54,169.74 119.77,169.74 v4(124.28,165.22) 126.93,162.57
FBA_ADBIA0: length 41.2
  IN1 w0.084: v1(134.83,144.8) 134.32,145.31 132.8,145.31 132.29,144.8 128.27,144.8 127.81,145.26 127.01,145.26
  IN1 w0.14: 127.01,145.26 122.59,145.26 121.23,143.91 117.69,143.91 116.45,145.14 116.45,145.76 115.03,147.17 110.34,147.17 108.95,145.79 108.95,141.36 107.99,140.39 107.99,139.57 107.63,139.2 107.14,139.2 106.99,139.05 106.99,138.64 v1(106.28,137.92)
  BOTTOM w0.084: v1(134.83,144.8) 134.67,144.96 134.67,145.71 135,146.04 UV1.J21
  BOTTOM w0.14: v1(106.28,137.92) 106.28,138 UV6.J4
FBA_ADBIA1: length 38.4
  IN1 w0.084: 127.01,148.02 127.15,148.02 127.31,147.87 132.83,147.87 v1(133.2,148.23)
  IN1 w0.14: v1(105.54,159.57) 105.93,159.18 105.93,151.86 108.12,149.67 116.21,149.67 117.86,148.02 127.01,148.02
  BOTTOM w0.084: UV1.G19 133.2,148.76 v1(133.2,148.23)
  BOTTOM w0.14: UV5.J4 105.51,159.57 v1(105.54,159.57)
FBA_CASA0#: length 41.1
  IN1 w0.084: 127.01,146.71 127.18,146.71 127.24,146.66 127.61,146.66 127.87,146.4 132.38,146.4 132.59,146.61 134.79,146.61 v1(135.39,147.21)
  IN1 w0.14: 127.01,146.71 120.53,146.71 120.39,146.57 120.39,145.95 120.25,145.81 119.88,145.81 119.74,145.95 119.74,146.57 119.6,146.71 119.23,146.71 119.09,146.57 119.09,145.95 118.95,145.81 118.58,145.81 118.44,145.95 118.44,146.57 118.3,146.71 117.44,146.71 115.6,148.55 109.73,148.55 105.97,144.79 105.97,140.77 v1(105.54,140.34)
  BOTTOM w0.084: UV1.K20 135.8,147.62 v1(135.39,147.21)
  BOTTOM w0.14: v1(105.54,140.34) 105.49,140.34 UV6.L3
FBA_CASA1#: length 42.9
  IN1 w0.084: v1(135.59,149.6) 134.99,150.2 131.58,150.2 130.61,151.17 128.53,151.17 128.29,150.93 127.01,150.93
  IN1 w0.14: 127.01,150.93 125.29,150.93 125.1,150.73 125.1,150.37 124.91,150.18 124.64,150.18 124.45,150.37 124.45,151.15 124.26,151.33 123.99,151.33 123.8,151.15 123.8,150.37 123.61,150.18 123.34,150.18 123.15,150.37 123.15,151.15 122.96,151.33 121.49,151.33 121.33,151.17 121.33,150.88 121.17,150.71 120.94,150.71 120.77,150.88 120.77,151.17 120.61,151.33 120.01,151.33 119.31,152.03 111.5,152.03 110.12,153.41 110.12,156.81 109.53,157.41 109.53,157.64 109.67,157.78 109.67,158.01 109.51,158.18 109.28,158.18 109.13,158.03 108.9,158.03 108.76,158.17 v5(108.76,158.93)
  BOTTOM w0.084: UV1.K17 135.59,149.95 v1(135.59,149.6)
  BOTTOM w0.14: v5(108.76,158.93) 107.77,157.94 105.89,157.94 105.8,158.04 105.77,158.04 105.57,158.24 105.57,158.27 105.46,158.38 UV5.G3
FBA_CKEA0: length 40.8
  IN1 w0.084: 127.01,146.37 127.51,146.37 127.67,146.21 132.45,146.21 132.67,146.43 134.02,146.43 134.2,146.24 134.63,146.24 134.96,145.91 v1(135.39,145.91)
  IN1 w0.14: 127.01,146.37 122.24,146.37 120.8,144.93 118.12,144.93 117.48,145.57 117.48,146.18 115.46,148.2 109.91,148.2 106.35,144.64 106.35,140.49 105.89,140.03 105.89,139.13 v1(105.5,138.75)
  BOTTOM w0.084: UV1.K21 135.39,146.15 v1(135.39,145.91)
  BOTTOM w0.114: UV6.J3 v1(105.5,138.75)
FBA_CKEA1: length 41.6
  IN1 w0.084: v1(134.09,147.11) 133.78,146.8 130.74,146.8 130.31,147.23 128.91,147.23 128.73,147.06 127.01,147.06
  IN1 w0.14: 127.01,147.06 117.74,147.06 115.9,148.89 107.62,148.89 104.37,152.14 104.37,153.3 104.31,153.36 104.31,159.22 v1(104.69,159.59)
  BOTTOM w0.084: v1(134.09,147.11) 134.35,147.11 UV1.J20
  BOTTOM w0.14: v1(104.69,159.59) 105.07,159.98 UV5.J3
FBA_CLKA0: length 43.3
  TOP w0.127: v1(112.71,137.96) 112.55,137.96 112.42,138.09 112.42,138.43 112.55,138.56 113.2,138.56 113.48,138.28 114.41,138.28 RV41.1
  IN1 w0.14: v1(133.86,141.16) 133.49,140.79 133.15,140.79 132.99,140.63 131.45,140.63 130.18,139.36 126.37,139.36 125.29,138.28 125.29,136.65 122.37,133.74 121.9,133.74 121.5,134.14 121.24,134.14 121.05,133.95 121.05,133.68 121.45,133.28 121.45,132.81 120.78,132.15 119.65,132.15 119.32,132.48 119.32,134.97 119.13,135.16 118.86,135.16 118.67,134.97 118.67,132.48 118.34,132.15 117.77,132.15 117.27,132.65 117.27,133.53 116.05,134.75 116.05,136.96 114.33,138.67 112.64,138.67 112.5,138.53 112.5,138.17 v1(112.71,137.96)
  BOTTOM w0.127: UV6.J12 v1(112.71,137.96)
  BOTTOM w0.14: v1(133.86,141.16) 133.86,141.42 UV1.H27
FBA_CLKA0#: length 42.9
  TOP w0.127: v1(111.91,137.96) 112.19,138.25 112.19,138.53 112.46,138.79 113.3,138.79 113.57,138.51 v3(114,138.51) RV42.2
  IN1 w0.14: v1(111.91,137.96) 112.26,138.32 112.26,138.63 112.54,138.91 114.43,138.91 116.29,137.06 116.29,134.85 117.51,133.63 117.51,132.75 117.87,132.39 118.24,132.39 118.43,132.58 118.43,135.07 118.76,135.4 119.23,135.4 119.56,135.07 119.56,132.58 119.75,132.39 120.68,132.39 121.2,132.91 121.2,133.18 120.8,133.58 120.8,134.05 121.14,134.38 121.6,134.38 122,133.98 122.27,133.98 125.05,136.75 125.05,138.38 126.27,139.6 130.08,139.6 131.35,140.87 132.89,140.87 v1(133.22,141.2)
  BOTTOM w0.127: UV6.J11 v1(111.91,137.96)
  BOTTOM w0.14: UV1.G27 133.4,141.38 v1(133.22,141.2)
FBA_CLKA1: length 43.9
  TOP w0.127: v1(112.71,160.38) 112.47,160.38 112.32,160.24 112.32,159.86 112.53,159.65 114.53,159.65 RV53.1
  IN1 w0.084: v1(134.71,151.92) 134.71,152.04 134.08,152.67 131.97,152.67 131.26,153.38 131.26,154.65 130,155.91 127.98,155.91 127.88,156.01 127.88,156.05 127.86,156.06
  IN1 w0.14: 127.86,156.06 127.56,156.36 125.75,156.36 125.22,156.89 124.32,156.89 123.98,157.23 123.98,157.55 124.17,157.74 126.03,157.74 126.36,158.07 126.36,158.54 126.03,158.87 124.22,158.87 124.09,159.01 124.09,160.78 122,162.87 117.62,162.87 115.72,160.96 115.72,160.49 116.45,159.76 116.45,159.5 116.26,159.3 115.99,159.3 115.26,160.04 114.79,160.04 114.37,159.61 112.7,159.61 112.35,159.96 112.35,160.21 112.52,160.38 v1(112.71,160.38)
  BOTTOM w0.084: v1(134.71,151.92) 134.58,152.05 134.58,152.21 134.92,152.56 UV1.J14
  BOTTOM w0.127: UV5.J12 v1(112.71,160.38)
FBA_CLKA1#: length 43.5
  TOP w0.127: RV54.2 114.8,159.42 112.43,159.42 112.1,159.76 112.1,160.2 v1(111.91,160.38)
  IN1 w0.084: v1(134.1,151.93) 134.17,152 134.17,152.31 134,152.48 131.89,152.48 131.07,153.3 131.07,154.57 129.92,155.72 127.9,155.72 127.75,155.88 127.71,155.88 127.69,155.89
  IN1 w0.14: v1(111.91,160.38) 112.13,160.17 112.13,159.87 112.62,159.37 114.47,159.37 114.89,159.79 115.16,159.79 115.89,159.06 116.36,159.06 116.69,159.4 116.69,159.86 115.96,160.59 115.96,160.86 117.72,162.63 121.9,162.63 123.84,160.68 123.84,158.91 124.12,158.63 125.93,158.63 126.12,158.44 126.12,158.17 125.93,157.98 124.07,157.98 123.74,157.65 123.74,157.13 124.22,156.65 125.12,156.65 125.65,156.12 127.46,156.12 127.69,155.89
  BOTTOM w0.084: UV1.H14 134.37,152.39 134.37,152.2 v1(134.1,151.93)
  BOTTOM w0.127: UV5.J11 v1(111.91,160.38)
FBA_CSA0#: length 39.7
  IN1 w0.084: v1(135.46,143.53) 135.46,143.19 135.03,142.76 133.89,142.76 132.42,141.29 130.92,141.29 130.56,140.93 130.23,140.93
  IN1 w0.14: 130.23,140.93 126.68,140.93 124.36,138.62 124.36,136.98 122.45,135.07 120.48,135.07 119.46,136.08 118.47,136.08 118.23,136.32 118.23,137.14 118.04,137.33 117.77,137.33 117.58,137.14 117.58,135.26 117.39,135.07 117.12,135.07 116.93,135.26 116.93,137.33 115.63,138.64 115.63,139.71 115.28,140.06 112.98,140.06 112.88,139.96 112.55,139.96 111.73,139.14 111.73,138.56 111.51,138.34 111.51,137.8 111.51,137.8 111.51,137.58 111.87,137.22 v1(111.87,137.2)
  BOTTOM w0.084: UV1.K24 135.46,143.82 v1(135.46,143.53)
  BOTTOM w0.14: UV6.G12 v1(111.87,137.2)
FBA_CSA1#: length 41
  IN1 w0.14: v1(112.71,161.98) 112.31,162.38 112.31,162.97 112.85,163.51 115.57,163.51 116.44,164.38 117.66,164.38 118.85,165.57 124.29,165.57 124.98,164.88 124.98,164.62 124.58,164.22 124.58,163.95 124.77,163.76 125.04,163.76 125.43,164.16 125.7,164.16 125.89,163.97 125.89,163.7 125.5,163.31 125.5,163.04 125.69,162.85 125.96,162.85 126.35,163.24 126.62,163.24 126.81,163.05 126.81,162.78 126.42,162.39 126.42,162.12 126.61,161.93 126.88,161.93 127.27,162.32 127.54,162.32 127.73,162.13 127.73,161.87 127.33,161.47 127.33,161.21 127.52,161.02 127.79,161.02 128.18,161.41 128.45,161.41 128.64,161.22 128.64,160.95 128.25,160.56 128.25,160.29 128.44,160.1 128.71,160.1 129.1,160.49 129.37,160.49 133.43,156.43 133.43,156.22 133.7,155.95 135.62,155.95 135.87,155.69 135.87,155.06 137.06,153.86 v1(137.06,153.63)
  BOTTOM w0.084: v1(137.06,153.63) 137.54,153.16 UV1.M13
  BOTTOM w0.14: UV5.L12 v1(112.71,161.98)
FBA_D0: length 43
  TOP w0.14: v3(103.36,129.88) 103.36,129.84 107.14,126.06 v4(111.69,126.06) 117,126.06 120.68,129.74 125.79,129.74 129.19,133.14 v3(129.19,133.64)
  BOTTOM w0.084: v3(129.19,133.64) 129.19,134.43 129.93,135.17 130.59,135.17 UV1.C37
  BOTTOM w0.14: UV6.F2 104,135.96 103.6,135.56 102.89,135.56 101.53,134.2 101.53,131.92 102.06,131.38 102.06,130.42 102.6,129.88 v3(103.36,129.88)
FBA_D1: length 38.1
  TOP w0.14: v3(105.04,130.67) 105.04,129.58 107.59,127.03 116.6,127.03 v4(119.72,130.15) 121.44,131.87 122.01,131.87 122.2,132.06 122.2,132.51 122.39,132.7 122.66,132.7 122.85,132.51 122.85,132.06 123.04,131.87 123.31,131.87 123.5,132.06 123.5,132.51 123.69,132.7 123.96,132.7 124.15,132.51 124.15,132.06 124.34,131.87 124.6,131.87 124.79,132.06 124.79,132.51 124.98,132.7 125.25,132.7 125.44,132.51 125.44,132.06 125.63,131.87 126.12,131.87 v3(127.92,133.67)
  BOTTOM w0.084: v3(127.92,133.67) 127.92,133.7 129.69,135.47 129.69,135.63 130.01,135.95 130.71,135.95 UV1.C35
  BOTTOM w0.14: v3(105.04,130.67) 104.73,130.98 104.73,132.12 104.31,132.54 UV6.B2
FBA_D2: length 38.5
  TOP w0.14: v3(128.56,133.64) 128.56,133.19 v4(126.09,130.72) 125.59,130.22 125.38,130.22 125.19,130.41 125.19,131.04 125,131.23 124.73,131.23 124.54,131.04 124.54,130.41 124.35,130.22 124.09,130.22 123.9,130.41 123.9,131.04 123.71,131.23 123.44,131.23 123.25,131.04 123.25,130.41 123.06,130.22 122.79,130.22 122.6,130.41 122.6,131.04 122.41,131.23 122.14,131.23 121.95,131.04 121.95,130.41 121.76,130.22 120.48,130.22 116.8,126.55 107.38,126.55 104.42,129.51 v1(104.42,130.54)
  BOTTOM w0.084: v3(128.56,133.64) 128.56,134.1 130.11,135.66 UV1.A35
  BOTTOM w0.14: v1(104.42,130.54) 104.31,130.64 UV6.A2
FBA_D3: length 43.5
  TOP w0.14: v3(131.4,136.04) 131.4,135.37 129.75,133.72 129.75,133.01 125.99,129.25 120.91,129.25 117.22,125.56 v4(114.36,125.56) 106.96,125.56 102.75,129.77 v3(102.75,130.67)
  BOTTOM w0.084: UV1.E34 131.8,136.44 v3(131.4,136.04)
  BOTTOM w0.14: v3(102.75,130.67) 102.75,131.38 102.01,132.12 102.01,134 102.83,134.81 103.76,134.81 104.11,135.16 UV6.E2
FBA_D4: length 38.4
  TOP w0.14: v1(133.79,137.56) 133.41,137.17 132.05,137.17 131.39,136.52 131.2,136.52 130.02,135.35 125.25,135.35 124.64,135.96 119.94,135.96 v4(119.23,135.24) 117.92,133.93 117.92,131.2 115.83,129.11 108.88,129.11 107.31,130.69 107.31,131.07 106.75,131.62 106.75,134.32 v1(106.34,134.73)
  BOTTOM w0.084: UV1.G32 133.79,137.57 v1(133.79,137.56)
  BOTTOM w0.14: v1(106.34,134.73) UV6.E4
FBA_D5: length 38.6
  TOP w0.14: v3(126.73,134.84) 126.08,134.19 125.08,134.19 124.89,134.38 124.89,134.95 124.7,135.14 124.43,135.14 124.24,134.95 124.24,134.38 124.05,134.19 123.78,134.19 123.59,134.38 123.59,134.95 123.4,135.14 123.13,135.14 122.94,134.95 122.94,134.38 122.75,134.19 122.49,134.19 122.3,134.38 122.3,134.95 122.11,135.14 121.84,135.14 121.65,134.95 121.65,134.38 121.46,134.19 v4(121.39,134.19) 121.19,134.19 121,134.38 121,134.95 120.81,135.14 120.54,135.14 120.35,134.95 120.35,134.38 119.84,133.87 119.57,133.87 119.32,134.12 119.05,134.12 118.86,133.93 118.86,133.66 119.11,133.41 119.11,133.14 118.4,132.43 118.4,130.88 116.15,128.63 108.68,128.63 106.43,130.88 106.43,131.19 v1(106.35,131.27)
  BOTTOM w0.084: UV1.D33 131.01,136.97 130.15,136.97 128.7,135.52 127.41,135.52 v3(126.73,134.84)
  BOTTOM w0.14: UV6.A4 106.35,131.52 v1(106.35,131.27)
FBA_D6: length 38.1
  TOP w0.14: v1(106.28,135.59) 107.24,134.63 107.24,131.82 107.88,131.18 107.88,130.8 109.08,129.6 115.63,129.6 117.34,131.3 117.34,134.03 119.74,136.44 120.54,136.44 120.73,136.63 120.73,137.14 120.92,137.33 121.18,137.33 121.37,137.14 121.37,136.63 121.56,136.44 v4(122.21,136.44) 125,136.44 125.61,135.83 129.82,135.83 131,137 131.1,137 131.78,137.68 v1(132.09,137.68)
  BOTTOM w0.084: UV1.F32 132.36,137.96 v1(132.09,137.68)
  BOTTOM w0.14: UV6.F4 v1(106.28,135.59)
FBA_D7: length 37.9
  TOP w0.14: v1(133,138.37) 131.65,138.37 129.6,136.31 125.89,136.31 124.36,137.83 123.06,137.83 122.87,137.65 122.87,137.14 122.68,136.95 122.41,136.95 122.22,137.14 122.22,137.65 122.03,137.83 120.46,137.83 v4(119.74,137.12) 116.85,134.23 116.85,131.5 115.43,130.08 109.28,130.08 108.59,130.77 108.59,131.15 107.78,131.97 107.78,132.4 v3(107.75,132.42)
  BOTTOM w0.084: UV1.E32 132.01,138.37 v1(133,138.37)
  BOTTOM w0.14: v3(107.75,132.42) 107.47,132.7 107.47,132.75 107.09,133.14 106.31,133.14 105.93,132.76 UV6.B4
FBA_D8: length 23.7
  IN3 w0.14: v1(112.93,131.38) 114.31,130.01 120.61,130.01 127.93,137.34 127.94,137.34 128.19,137.59 128.19,137.59 128.53,137.94 129.22,137.94 129.5,138.22 v1(129.5,138.44)
  BOTTOM w0.084: v1(129.5,138.44) 129.71,138.44 129.95,138.69 130.38,138.69 130.55,138.52 130.96,138.52 UV1.D31
  BOTTOM w0.14: v1(112.93,131.38) 113.11,131.56 UV6.A13
FBA_D9: length 25.9
  IN3 w0.14: v1(127.76,137.76) 127.76,137.65 120.5,130.39 114.51,130.39 113.11,131.79 112.48,131.79 v1(111.91,132.36)
  BOTTOM w0.084: v1(127.76,137.76) 129.21,139.21 130.39,139.21 130.46,139.29 132.33,139.29 UV1.F30
  BOTTOM w0.14: UV6.B11 v1(111.91,132.36)
FBA_D10: length 25.3
  IN3 w0.14: v1(127.17,137.79) 127.18,137.79 127.18,137.55 120.45,130.82 114.99,130.82 113.06,132.76 111.47,132.76 v1(111.09,132.38)
  BOTTOM w0.084: v1(127.17,137.79) 127.55,138.16 127.87,138.16 129.09,139.38 130.32,139.38 130.39,139.46 130.7,139.46 UV1.C30
  BOTTOM w0.14: UV6.A11 v1(111.09,132.38)
FBA_D11: length 22.7
  IN3 w0.14: v1(112.71,133.16) 113.39,133.16 114,132.55 115.5,132.55 116.85,131.21 120.29,131.21 126.39,137.3 v1(126.39,137.71)
  BOTTOM w0.084: v1(126.39,137.71) 127.01,138.33 127.8,138.33 129.04,139.56 129.77,139.56 129.97,139.76 UV1.A30
  BOTTOM w0.14: UV6.B13 v1(112.71,133.16)
FBA_D12: length 22.4
  IN3 w0.14: v1(113.51,134.76) 113.54,134.74 116.48,134.74 120.77,134.74 125.37,139.33 127.96,139.33 v1(128.95,140.32)
  BOTTOM w0.084: v1(128.95,140.32) 128.96,140.32 129.42,140.78 130.36,140.78 130.46,140.89 130.74,140.89 130.87,140.76 131.13,140.76 131.26,140.89 132.33,140.89 UV1.F28
  BOTTOM w0.14: UV6.E13 v1(113.51,134.76)
FBA_D13: length 22.5
  IN3 w0.14: v1(127.09,140.49) 125.07,140.49 121.34,136.76 112.7,136.76 111.91,135.98 v1(111.91,135.56)
  BOTTOM w0.084: UV1.C28 130.61,141.62 130.6,141.63 130.44,141.63 130.3,141.71 130.06,141.71 129.63,141.28 129.13,141.28 128.89,141.04 127.65,141.04 127.09,140.49 v1(127.09,140.49)
  BOTTOM w0.14: UV6.F11 v1(111.91,135.56)
FBA_D14: length 21.8
  IN3 w0.14: v1(127.67,140.41) 127.28,140.02 125.08,140.02 121.02,135.96 113.31,135.96 113.11,135.76 113.11,135.39 112.88,135.16 112.49,135.16 112.09,134.76 v1(111.91,134.76)
  BOTTOM w0.084: UV1.A28 129.96,141.12 129.2,141.12 128.96,140.87 128.13,140.87 v1(127.67,140.41)
  BOTTOM w0.14: UV6.E11 v1(111.91,134.76)
FBA_D15: length 21.4
  IN3 w0.14: v1(113.55,135.53) 113.58,135.56 121.11,135.56 125.23,139.68 127.55,139.68 v1(128.28,140.4)
  BOTTOM w0.084: UV1.E28 131.5,141.36 131.06,140.92 130.94,140.92 130.81,141.06 130.39,141.06 130.29,140.95 129.27,140.95 129.03,140.71 128.58,140.71 v1(128.28,140.4)
  BOTTOM w0.14: UV6.F13 v1(113.55,135.53)
FBA_D16: length 20.3
  IN3 w0.14: v1(129.12,142.07) 129.12,142.01 128.1,140.98 118.47,140.98 117.09,139.6 v3(114.98,139.6)
  BOTTOM w0.084: UV1.D27 131.23,142.16 130.87,141.8 130.48,141.8 130.35,141.87 129.99,141.87 129.77,141.65 129.55,141.65 v1(129.12,142.07)
  BOTTOM w0.14: UV6.M13 113.52,140.36 114.23,140.36 v3(114.98,139.6)
FBA_D17: length 21
  IN3 w0.14: v1(128.39,142.11) 128.39,141.91 127.81,141.33 117.85,141.33 117.05,140.53 114.17,140.53 113.51,141.18 v1(113.51,141.19)
  BOTTOM w0.084: UV1.F26 132.07,142.76 131.94,142.63 131.9,142.63 131.77,142.49 130.44,142.49 130.28,142.45 129.99,142.45 129.94,142.49 128.77,142.49 v1(128.39,142.11)
  BOTTOM w0.14: v1(113.51,141.19) 113.51,141.18 113.14,141.56 UV6.N13
FBA_D18: length 20.7
  IN3 w0.14: v1(111.91,141.16) 112.69,141.93 115.82,141.93 116.08,141.67 127.49,141.67 127.8,141.99 v1(127.8,142.1)
  BOTTOM w0.084: UV1.C26 130.71,142.96 130.42,142.68 130.38,142.65 130.26,142.61 130.06,142.61 130.01,142.66 128.7,142.66 128.51,142.46 128.17,142.46 v1(127.8,142.1)
  BOTTOM w0.14: UV6.M11 v1(111.91,141.16)
FBA_D19: length 20.1
  IN3 w0.14: v1(127.22,142.13) 127.11,142.01 117.21,142.01 116.47,142.76 v3(115.21,142.76)
  BOTTOM w0.084: UV1.A26 130.07,142.83 128.63,142.83 128.44,142.63 127.72,142.63 v1(127.22,142.13)
  BOTTOM w0.14: v3(115.21,142.76) 115.21,142.35 114.8,141.93 111.89,141.93 UV6.N11
FBA_D20: length 26.3
  IN3 w0.14: v1(111.11,144.36) 111.51,144.76 111.51,145.97 113.33,147.78 125.32,147.78 129.11,143.98 v1(129.11,143.79)
  BOTTOM w0.084: UV1.F24 132.11,144.36 131.98,144.24 131.94,144.24 131.94,144.23 131.71,144.23 131.62,144.14 131.29,144.14 131.21,144.06 130.79,144.06 130.71,144.14 130.49,144.14 130.37,144.03 130.02,144.03 129.91,144.15 129.47,144.15 v1(129.11,143.79)
  BOTTOM w0.14: UV6.T11 v1(111.11,144.36)
FBA_D21: length 19.9
  IN3 w0.14: v1(127.24,143.8) 125.13,145.91 114.05,145.91 113.51,145.38 v1(113.51,145.16)
  BOTTOM w0.084: UV1.C24 130.69,144.56 130.39,144.86 130.27,144.91 130.13,144.91 130.05,144.9 129.99,144.9 129.76,144.67 128.1,144.67 v1(127.24,143.8)
  BOTTOM w0.14: UV6.U13 v1(113.51,145.16)
FBA_D22: length 21.2
  IN3 w0.14: v1(112.71,144.36) 113.11,144.76 113.11,145.96 113.65,146.49 125.31,146.49 127.82,143.98 v1(127.82,143.81)
  BOTTOM w0.084: v1(127.82,143.81) 128.5,144.49 130.13,144.49 UV1.A24
  BOTTOM w0.14: UV6.T13 v1(112.71,144.36)
FBA_D23: length 23.6
  IN3 w0.14: v1(111.91,145.16) 112.07,145.32 112.07,145.79 113.56,147.28 125.16,147.28 128.5,143.93 128.5,143.8 v1(128.5,143.8)
  BOTTOM w0.084: UV1.E24 131.55,144.31 131.22,144.31 131.14,144.23 130.86,144.23 130.78,144.31 130.42,144.31 130.34,144.23 130.06,144.23 129.98,144.32 129.04,144.32 128.5,143.78 v1(128.5,143.8)
  BOTTOM w0.14: UV6.U11 v1(111.91,145.16)
FBA_D24: length 35.2
  BOTTOM w0.084: 126.42,145.35 127.25,146.18 129.76,146.18 130.06,146.49 130.34,146.49 130.46,146.37 130.71,146.37 130.92,146.16 UV1.C22
  BOTTOM w0.14: 126.42,145.35 124.69,143.63 123.02,143.63 122.83,143.44 v4(122.83,143.19) 122.83,142.95 122.64,142.76 122.37,142.76 122.18,142.95 122.18,143.44 121.99,143.63 121.72,143.63 121.53,143.44 121.53,142.95 121.34,142.76 121.08,142.76 120.89,142.95 120.89,143.44 120.7,143.63 120.43,143.63 120.24,143.44 120.24,142.95 120.05,142.76 119.78,142.76 119.59,142.95 119.59,143.44 119.4,143.63 118.55,143.63 115.04,147.13 106.56,147.13 104.73,145.3 104.73,144.38 UV6.T2
FBA_D25: length 34.4
  BOTTOM w0.084: UV1.A22 130.05,146.01 127.9,146.01 126.52,144.64
  BOTTOM w0.14: 126.52,144.64 125.04,143.15 125.04,142.89 125.44,142.48 125.44,142.21 125.25,142.02 124.98,142.02 124.58,142.43 124.31,142.43 124.01,142.13 v4(120.2,142.13) 119.36,142.13 119.15,142.33 118.88,142.33 118.2,141.65 117.93,141.65 117.74,141.84 117.74,142.11 118.43,142.79 118.43,143.06 118.24,143.25 117.97,143.25 117.29,142.57 117.02,142.57 116.83,142.76 116.83,143.03 117.51,143.71 117.51,143.98 115.07,146.42 107.57,146.42 UV6.U4
FBA_D26: length 36.5
  BOTTOM w0.084: UV1.F22 132.08,145.96 131.73,145.61 131.73,145.18 131.57,145.02 130.43,145.02 130.3,145.07 129.93,145.07 129.69,144.84 127.55,144.84 126.68,143.96
  BOTTOM w0.14: 126.68,143.96 126.5,143.78 126.5,142.51 125,141.01 v4(122.13,141.01) 122.01,141.01 121.82,140.82 121.82,140.31 121.63,140.12 121.36,140.12 121.17,140.31 121.17,140.82 120.98,141.01 120.71,141.01 120.52,140.82 120.52,140.31 120.33,140.12 120.07,140.12 119.88,140.31 119.88,140.82 119.69,141.01 117.61,141.01 115.91,142.71 115.91,144.9 114.92,145.89 108.32,145.89 106.75,144.31 106.26,144.31 UV6.T4
FBA_D27: length 36.5
  BOTTOM w0.084: 126.19,145.81 126.73,146.35 129.69,146.35 129.99,146.66 130.41,146.66 130.49,146.57 130.77,146.57 131.15,146.96 UV1.D21
  BOTTOM w0.14: 126.19,145.81 125.53,145.15 123.43,145.15 123.24,144.96 123.24,144.37 123.05,144.18 122.78,144.18 122.59,144.37 122.59,144.96 122.4,145.15 122.13,145.15 121.94,144.96 121.94,144.37 121.75,144.18 121.48,144.18 121.29,144.37 121.29,144.96 121.1,145.15 120.83,145.15 120.64,144.96 120.64,144.37 120.45,144.18 120.19,144.18 120,144.37 120,144.96 119.81,145.15 119.54,145.15 119.35,144.96 119.35,144.37 119.16,144.18 118.89,144.18 118.7,144.37 118.7,144.96 118.51,145.15 v4(118.22,145.15) 117.71,145.15 115.24,147.61 106.36,147.61 104.32,145.58 104.32,144.77 UV6.U2
FBA_D28: length 37.2
  BOTTOM w0.084: UV1.A20 128.17,147.76 128.03,147.61 126.79,147.61
  BOTTOM w0.14: UV6.N4 105.47,142 104.17,142 103.92,142.25 103.92,142.48 103.59,142.81 103.36,142.81 103.18,142.99 102.57,142.99 102.04,143.52 102.04,145.59 105.64,149.18 115.78,149.18 117.35,147.61 v4(120.88,147.61) 126.79,147.61
FBA_D29: length 39.7
  BOTTOM w0.084: UV1.F20 132.29,147.76 131.88,148.17 130.94,148.17 130.82,148.05 130.38,148.05 130.34,148.09 130.04,148.09 129.88,147.93 129.27,147.93 129.1,148.1 126.79,148.1
  BOTTOM w0.14: 126.79,148.1 v4(123.91,148.1) 117.84,148.1 116.26,149.67 105.44,149.67 101.56,145.79 101.56,143.24 102.62,142.18 103.18,142.18 103.36,142 103.61,142 104.05,141.56 UV6.N2
FBA_D30: length 42
  BOTTOM w0.084: UV1.D19 131.07,148.56 130.74,148.23 130.46,148.23 130.4,148.29 129.93,148.29 129.77,148.13 129.46,148.13 129,148.59 126.79,148.59
  BOTTOM w0.14: UV6.M4 105.69,140.76 105.29,141.16 103.38,141.16 103.21,141.34 102.6,141.34 101.07,142.86 101.07,145.99 105.24,150.15 116.54,150.15 v4(117.77,148.93) 118.1,148.59 126.79,148.59
FBA_D31: length 42.4
  BOTTOM w0.084: UV1.E18 131.45,149.01 130.59,149.01 130.43,148.86 129.93,148.86 129.88,148.91 127.16,148.91 126.99,149.08 126.9,149.08
  BOTTOM w0.14: UV6.M2 103.95,140.4 102.77,140.4 100.59,142.58 100.59,146.19 105.04,150.64 v4(115.83,150.64) 116.82,150.64 118.38,149.08 126.9,149.08
FBA_MAA0_0: length 37.5
  IN1 w0.084: 127.01,144.58 127.54,144.58 127.69,144.42 130.87,144.42 131.01,144.28 132.63,144.28 v1(133.05,144.69)
  IN1 w0.14: v1(106.33,137.19) 106.33,137.37 106.94,137.99 107.73,137.99 108.67,138.93 108.67,140.11 109.64,141.07 109.64,145.36 110.59,146.31 114.93,146.31 115.73,145.51 115.73,144.9 117.41,143.22 124.62,143.22 125.98,144.58 127.01,144.58
  BOTTOM w0.084: UV1.G24 133.05,144.51 v1(133.05,144.69)
  BOTTOM w0.14: v1(106.33,137.19) 106.28,137.19 UV6.H4
FBA_MAA0_1: length 38.8
  IN1 w0.084: v1(135.41,144.72) 134.79,144.09 130.94,144.09 130.79,144.24 127.01,144.24
  IN1 w0.14: 127.01,144.24 126.17,144.24 124.67,142.74 117.4,142.74 115.37,144.77 115.37,145.38 114.79,145.97 110.75,145.97 109.98,145.2 109.98,140.93 109.02,139.96 109.02,138.79 107.79,137.56 v1(107.22,137.56)
  BOTTOM w0.102: v1(135.41,144.72) 135.41,144.95 UV1.J23
  BOTTOM w0.14: UV6.H5 v1(107.22,137.56)
FBA_MAA0_2: length 39.5
  IN1 w0.084: 128.99,142.58 131.15,142.58 131.32,142.76 132.93,142.76 133.69,143.52 133.71,143.52 v1(133.71,143.52)
  IN1 w0.14: v1(111.12,137.16) 110.55,137.73 110.55,139.51 111.21,140.17 111.21,140.58 111.51,140.88 111.51,141.37 111.97,141.82 115.48,141.82 117.43,139.87 117.97,139.87 118.16,140.06 118.16,140.97 118.35,141.16 118.62,141.16 118.81,140.97 118.81,140.06 118.99,139.87 119.26,139.87 119.45,140.06 119.45,140.97 119.64,141.16 119.91,141.16 120.1,140.97 120.1,140.06 120.29,139.87 120.56,139.87 120.75,140.06 120.75,140.97 120.94,141.16 121.21,141.16 121.4,140.97 121.4,140.06 121.59,139.87 121.85,139.87 122.04,140.06 122.04,140.97 122.23,141.16 122.5,141.16 122.69,140.97 122.69,140.06 122.88,139.87 123.73,139.87 126.44,142.58 128.99,142.58
  BOTTOM w0.084: v1(133.71,143.52) 133.71,143.67 UV1.H24
  BOTTOM w0.14: UV6.H11 v1(111.12,137.16)
FBA_MAA0_3: length 38.4
  IN1 w0.084: 129.93,141.67 130.16,141.67 130.34,141.86 131.01,141.86 131.68,142.53 132.97,142.53 133.57,143.13 133.9,143.13 134.26,143.5 134.3,143.5 134.3,143.5 134.29,143.5 v1(134.29,143.5)
  IN1 w0.14: v5(111.08,137.96) 111.08,138.26 111.49,138.66 111.49,139.37 112.31,140.19 112.31,140.57 112.5,140.76 116.05,140.76 118.19,138.62 118.19,138.23 118.38,138.04 118.65,138.04 118.84,138.23 118.84,138.62 119.03,138.81 119.3,138.81 119.49,138.62 119.49,137.72 119.68,137.53 119.94,137.53 120.13,137.72 120.13,139.22 120.32,139.41 120.59,139.41 120.78,139.22 120.78,137.75 120.97,137.56 121.24,137.56 121.43,137.75 121.43,139.27 121.62,139.46 121.89,139.46 122.08,139.27 122.08,138.23 122.27,138.04 122.54,138.04 122.73,138.23 122.73,138.62 122.92,138.81 123.16,138.81 126.02,141.67 129.93,141.67
  BOTTOM w0.084: UV1.J24 134.34,143.5 v1(134.29,143.5)
  BOTTOM w0.14: v5(111.08,137.96) 111.11,137.96 UV6.H10
FBA_MAA0_4: length 39.4
  IN1 w0.084: 127.01,138.32 128.05,138.32 128.56,138.83 130.71,138.83 131.64,139.75 132.98,139.75 133.73,140.5 134.04,140.5 134.4,140.86 134.4,142.08 v1(134.12,142.36)
  IN1 w0.14: 127.01,138.32 126.4,138.32 125.96,137.89 125.96,136.29 121.1,131.42 117.34,131.42 116.45,132.31 116.45,133.38 115.4,134.43 115.4,136.36 115,136.76 110.95,136.76 110.03,137.68 v3(109.81,137.68)
  BOTTOM w0.084: UV1.H26 134.12,142.88 v1(134.12,142.36)
  BOTTOM w0.14: v3(109.81,137.68) 109.92,137.8 109.92,138.99 110.47,139.54 111.14,139.54 UV6.K11
FBA_MAA0_5: length 38.5
  IN1 w0.084: 130.05,137.96 130.33,137.96 131.93,139.56 134.73,139.56 135.06,139.89 135.06,140.58 134.88,140.76 134.88,141.98 134.7,142.15 v1(134.7,142.33)
  IN1 w0.14: 130.05,137.96 128.61,137.96 121.49,130.85 117.43,130.85 116.11,132.17 116.11,133.24 115.02,134.33 115.02,135.57 114.63,135.96 110.75,135.96 110.17,136.54 v5(110.17,136.87)
  BOTTOM w0.084: v1(134.7,142.33) 135,142.63 UV1.J26
  BOTTOM w0.14: v5(110.17,136.87) 110.27,136.97 110.27,138.72 110.7,139.16 UV6.K10
FBA_MAA0_6: length 38.4
  IN1 w0.084: v1(134.32,145.86) 133.94,146.24 132.75,146.24 132.53,146.03 127.01,146.03
  IN1 w0.14: 127.01,146.03 122.38,146.03 120.94,144.59 117.98,144.59 117.14,145.43 117.14,146.04 115.32,147.86 110.05,147.86 108.08,145.89 108.08,145.15 107.82,144.88 107.08,144.88 106.69,144.5 106.69,140.35 106.31,139.97 v1(106.31,139.56)
  BOTTOM w0.084: UV1.H21 134.32,146.44 v1(134.32,145.86)
  BOTTOM w0.14: UV6.K5 v1(106.31,139.56)
FBA_MAA0_7: length 38
  IN1 w0.084: 127.01,145.68 130.59,145.68 130.71,145.81 132.59,145.81 132.91,145.5 133.37,145.5 v1(133.72,145.85)
  IN1 w0.14: v1(106.4,138.75) 106.4,138.94 106.91,139.46 106.91,139.8 108.61,141.5 108.61,145.93 110.2,147.52 115.18,147.52 116.8,145.9 116.8,145.29 117.83,144.25 121.09,144.25 122.52,145.68 127.01,145.68
  BOTTOM w0.084: UV1.G21 133.72,146.24 v1(133.72,145.85)
  BOTTOM w0.14: UV6.K4 106.33,138.74 106.4,138.74 v1(106.4,138.75)
FBA_MAA0_8: length 39.5
  IN1 w0.084: 127.01,144.92 127.77,144.92 128.07,144.62 132.37,144.62 132.87,145.12 133.91,145.12 v1(134.25,144.79)
  IN1 w0.14: v1(107.47,138.54) 107.7,138.54 108.33,139.17 108.33,140.25 109.3,141.21 109.3,145.55 110.39,146.64 110.44,146.64 110.45,146.65 115.07,146.65 116.11,145.61 116.11,145 117.55,143.56 123.08,143.56 123.27,143.75 123.27,144.66 123.46,144.85 123.73,144.85 123.92,144.66 123.92,143.75 124.11,143.56 124.48,143.56 125.84,144.92 127.01,144.92
  BOTTOM w0.084: UV1.H23 134.25,145.31 v1(134.25,144.79)
  BOTTOM w0.14: UV6.J5 107.22,138.36 107.4,138.54 v1(107.47,138.54)
FBA_MAA1_0: length 39.2
  IN1 w0.084: 127.01,149.39 128.99,149.39 129.09,149.49 132.3,149.49 132.57,149.22 133.41,149.22 133.74,149.54 v1(133.76,149.54)
  IN1 w0.14: 127.01,149.39 120.86,149.39 119.03,151.22 118.58,151.22 118.44,151.08 118.44,150.42 118.3,150.28 117.93,150.28 117.79,150.42 117.79,151.08 117.65,151.22 111.12,151.22 108.71,153.63 108.71,154.42 109.2,154.9 109.2,156.95 108.01,158.13 108.01,159.91 106.72,161.21 v1(106.34,161.21)
  BOTTOM w0.084: v1(133.76,149.54) 133.76,149.4 UV1.H19
  BOTTOM w0.14: UV5.K4 v1(106.34,161.21)
FBA_MAA1_1: length 38.6
  IN1 w0.084: 127.01,148.71 128.99,148.71 129.36,149.08 131.59,149.08 131.83,148.83 133.61,148.83 133.97,148.48 v1(133.97,148.35)
  IN1 w0.14: 127.01,148.71 118.34,148.71 116.64,150.41 109.28,150.41 107.42,152.28 107.42,155.86 107.67,156.12 107.67,157.21 106.77,158.11 106.77,159.86 v1(106.29,160.35)
  BOTTOM w0.084: v1(133.97,148.35) 134.2,148.12 UV1.H20
  BOTTOM w0.14: UV5.K5 v1(106.29,160.35)
FBA_MAA1_2: length 39.1
  IN1 w0.14: v1(135.81,153.16) 135.81,153.49 135.34,153.96 135.34,154.55 134.93,154.95 133.69,154.95 132.87,155.77 132.87,156.3 130.37,158.8 128.95,158.8 123.81,163.95 123.57,163.95 123.38,164.14 123.38,164.9 123.19,165.09 122.92,165.09 122.73,164.9 122.73,164.14 122.54,163.95 122.27,163.95 122.08,164.14 122.08,164.9 121.89,165.09 121.62,165.09 121.43,164.9 121.43,164.14 121.25,163.95 120.98,163.95 120.79,164.14 120.79,164.9 120.6,165.09 120.33,165.09 120.14,164.9 120.14,164.14 119.95,163.95 119.68,163.95 119.49,164.14 119.49,164.9 119.3,165.09 119.03,165.09 118.84,164.9 118.84,164.14 118.65,163.95 117.13,163.95 115.47,162.29 113.79,162.29 113.08,161.58 112.31,161.58 v1(111.91,161.18)
  BOTTOM w0.084: UV1.L13 v1(135.81,153.16)
  BOTTOM w0.14: UV5.K11 v1(111.91,161.18)
FBA_MAA1_3: length 38.9
  IN1 w0.14: v1(111.16,161.22) 111.6,160.78 113.73,160.78 113.92,160.97 113.92,161.69 114.15,161.91 115.6,161.91 117.29,163.6 122.24,163.6 122.65,163.19 122.92,163.19 123.25,163.52 123.52,163.52 123.71,163.33 123.71,163.06 123.38,162.73 123.38,162.47 123.57,162.28 123.84,162.28 124.17,162.6 124.44,162.6 124.63,162.41 124.63,162.15 124.3,161.82 124.3,161.55 124.49,161.36 124.76,161.36 125.08,161.69 125.35,161.69 125.54,161.5 125.54,161.23 125.21,160.9 125.21,160.63 125.4,160.44 125.67,160.44 126,160.77 126.27,160.77 126.46,160.58 126.46,160.31 126.13,159.98 126.13,159.72 126.32,159.53 126.59,159.53 126.92,159.86 127.19,159.86 127.38,159.67 127.38,159.4 127.05,159.07 127.05,158.8 128.59,157.25 130.42,157.25 132.62,155.06 132.62,154.09 132.9,153.81 133.74,153.81 v1(134.35,153.2)
  BOTTOM w0.084: UV1.G16 133.65,151.61 133.65,152.22 133.87,152.45 133.87,152.73 v1(134.35,153.2)
  BOTTOM w0.14: v1(111.16,161.22) UV5.K10
FBA_MAA1_4: length 38.9
  IN1 w0.084: 127.01,151.3 127.08,151.37 130.95,151.37 131.93,150.39 134.43,150.39 v1(134.85,150.81)
  IN1 w0.14: 127.01,151.3 125.3,151.3 124.92,151.68 124.49,151.68 124.3,151.87 124.3,152.58 124.11,152.77 123.84,152.77 123.65,152.58 123.65,151.87 123.46,151.68 123.19,151.68 123.01,151.87 123.01,152.58 122.82,152.77 122.55,152.77 122.36,152.58 122.36,151.87 122.17,151.68 121.9,151.68 121.71,151.87 121.71,152.58 121.52,152.77 121.25,152.77 121.06,152.58 121.06,151.87 120.87,151.68 120.15,151.68 119.36,152.47 115.65,152.47 114.9,153.21 114.9,153.98 114.5,154.38 110.86,154.38 110.64,154.59 110.64,158.86 110.97,159.19 111.58,159.19 111.91,158.86 v1(111.91,158.78)
  BOTTOM w0.084: v1(134.85,150.81) 135,150.96 UV1.J16
  BOTTOM w0.14: UV5.H11 v1(111.91,158.78)
FBA_MAA1_5: length 39
  IN1 w0.084: v1(134.09,150.76) 133.71,151.14 131.68,151.14 130.46,152.36 127.01,152.36
  IN1 w0.14: v5(111.14,158.75) 111.14,158.61 112.31,157.44 112.31,155.41 112.55,155.18 114.02,155.18 114.35,155.51 114.9,155.51 115.55,154.85 115.55,153.66 115.96,153.25 116.85,153.25 117.03,153.44 117.03,154.05 117.22,154.24 117.49,154.24 117.68,154.05 117.68,153.44 117.87,153.25 118.14,153.25 118.33,153.44 118.33,154.05 118.52,154.24 118.79,154.24 118.98,154.05 118.98,153.44 119.17,153.25 119.44,153.25 119.63,153.44 119.63,154.05 119.82,154.24 120.08,154.24 120.27,154.05 120.27,153.44 120.46,153.25 120.73,153.25 120.92,153.44 120.92,154.05 121.11,154.24 121.38,154.24 121.57,154.05 121.57,153.44 121.76,153.25 122.03,153.25 122.22,153.44 122.22,154.05 122.41,154.24 122.67,154.24 122.86,154.05 122.86,153.44 123.05,153.25 123.32,153.25 123.51,153.44 123.51,154.05 123.7,154.24 123.97,154.24 124.16,154.05 124.16,153.44 124.35,153.25 125.61,153.25 126.5,152.36 127.01,152.36
  BOTTOM w0.084: v1(134.09,150.76) 134.09,151.25 UV1.H16
  BOTTOM w0.14: UV5.H10 v5(111.14,158.75)
