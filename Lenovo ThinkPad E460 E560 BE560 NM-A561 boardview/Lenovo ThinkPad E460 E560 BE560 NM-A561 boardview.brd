# Allegro board Lenovo ThinkPad E460 E560 BE560 NM-A561 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 6.8
  TOP w0.254: JAUF.10 220.32,10.15 219.69,10.78 v3(219.28,10.78)
  TOP w0.508: v3(210.67,13.17) CA10.2 210.27,14.19 209.56,14.9 CA19.2 ; CA11.2 v3(211.74,13.12) ; CA8.2 v3(215.3,16.55) ; CA9.2 v3(215.3,15.64)
  vias: v4(219.79,9.41)
VCC0R9GBE: length 8
  TOP w0.178: UL1.8 47.11,121.46 47.12,121.48 v3(47.12,121.78) ; v3(43.65,116.18) 44.69,116.18 UL1.22 ; UL1.16 43.44,118.55 v3(43.01,118.99) ; UL1.11 45.91,121.42 v3(45.85,121.48)
  TOP w0.254: UL1.37 v3(51.72,115.35) ; UL1.43 v3(51.65,117.75) ; UL1.40 v3(51.61,116.55)
  vias: v3(49.89,127.73) v3(50.53,127.75) v3(51.19,127.78) v3(51.67,119.17) v4(49.08,127.07)
VCC0R9GBE_L: length 2
  TOP w0.203: 47.71,122.06 47.71,121.6 47.51,121.41 UL1.7
  TOP w0.381: 47.71,122.47 47.71,122.06
  vias: v3(47.3,122.98) v3(47.99,122.98) v4(47.68,123.48)
VCC_SENSE: length 24
  TOP w0.254: RC120.2 97.29,117.52 v3(97.29,116.93) 97.29,116.55 97.53,116.31 RC121.2
  IN1 w0.254: v3(97.29,116.93) 96.57,116.21 81.54,116.21 80.63,115.31 78.31,115.31 v1(78.19,115.43)
  BOTTOM w0.203: v1(78.19,115.43) PC406.2 78.16,116.12 PC404.1 PR415.1
VCCGT_SENSE: length 20.2
  TOP w0.254: RC124.1 60.25,111.04 RC125.2 60.25,113.79 61.42,114.96 61.42,119.52 61.83,119.93 62.72,119.93 64.27,121.48 64.27,123.79 v3(64.8,124.32)
  BOTTOM w0.203: PU401.47 67.03,123.11 v2(66.1,124.04) 65.11,125.03 PC413.2 v3(64.8,124.32)
VCCIO_SENSE: length 1.4
  TOP w0.254: RC192.1 95.59,88.81 v3(95.59,88.31)
  BOTTOM w0.254: UC1.AM23 95.99,88.7 v3(95.59,88.31)
VCCSA_SENSE: length 59.2
  TOP w0.254: v3(103.97,124.4) 103.97,123.97 102.55,122.54 102.55,117.08 RC375.2 RC126.2
  IN1 w0.254: v3(62.19,121.5) 63.19,121.5 64.02,122.33 64.63,122.33 66.24,123.95 67.5,123.95 68.68,125.13 72.16,125.13 72.63,125.6 76.62,125.6 77.51,124.7 78.73,124.7 80.38,126.35 91.52,126.35 91.99,126.83 98.11,126.83 99.42,125.52 103.08,125.52 103.97,124.63 v3(103.97,124.4)
  BOTTOM w0.114: v3(62.19,121.5) 61.93,121.76 v2(61.6,121.76)
  BOTTOM w0.254: v3(62.19,121.5) 62.64,121.96 PC425.2 PC423.1 63.71,122.77 PR434.1
VCCST_PG_EC: length 193.4
  TOP w0.114: v4(200.08,59.91) 199.88,59.91 199.31,59.34 UE1.34 199.31,57.44 198.75,56.87 196.08,56.87 v3(195.6,56.39)
  IN2 w0.14: v3(195.6,56.39) 195.23,56.02 193.31,56.02 188.4,60.94 184.14,60.94 183.32,61.76 166.93,61.76 166.36,62.33 162.05,62.33 159.52,64.86 159.52,68.85 154.51,73.85 154.51,87.42 151.94,89.99 151.94,94.41 153.42,95.89 153.42,99.68 154.9,101.16 154.9,106.87 152.34,109.43 152.34,113.61 150.67,115.29 136.52,115.29 135.2,113.97 131.55,113.97 130.47,115.05 114.28,115.05 111.42,117.91 110.75,117.91 108.54,115.7 101.49,115.7 100.24,114.44 82.78,114.44 81.1,112.77 80.08,112.77 79.25,111.93 78.86,111.93 77.98,111.05 72.56,111.05 70.41,113.2 v1(69.78,113.2)
  BOTTOM w0.076: DC23.1 69.45,110.25 69.7,110.5 69.7,110.53
  BOTTOM w0.114: 69.7,110.53 69.7,113.12 v1(69.78,113.2)
VCCST_PWRGD: length 12.9
  BOTTOM w0.076: 70.31,106.81 70.41,106.71 72.11,106.71 73.13,105.69 73.13,104.62 UC1.B65
  BOTTOM w0.114: 70.31,106.81 69.4,107.72 DC23.2 68.76,109.94 v2(68.76,111.16) 69.17,111.57 RC123.2 69.17,113.22 69.73,113.78 RC410.2
VCCST_PWRGD_GD: length 37.7
  TOP w0.114: QC3.3 76.27,131.15 v2(78.48,128.94) 78.72,128.7 RC401.2 78.72,126.74 v1(79.11,126.34)
  IN2 w0.14: v1(68.51,113.2) 67.62,114.09 64.7,114.09 62.79,115.99 62.79,116.42 64.1,117.72 65.86,117.72 66.01,117.58 66.54,117.58 67.24,116.88 67.88,116.88 68.26,117.26 68.66,117.26 70.61,119.21 75.73,119.21 77.76,121.24 77.76,124.45 79.11,125.8 v1(79.11,126.34)
  BOTTOM w0.114: RC410.1 68.51,113.59 v1(68.51,113.2)
VDD_62771: length 14.3
  TOP w0.114: v3(207.73,152.69) 206.99,152.69 v4(206.97,152.72)
  IN3 w0.254: v3(207.73,152.69) 207.77,152.65 211.07,152.65 211.33,152.9 211.33,155.42 v3(210.88,155.87)
  BOTTOM w0.203: PC604.1 207.37,152.69 v3(207.73,152.69) 207.77,152.65 PU601.25
  BOTTOM w0.381: PC604.1 207.09,152.16 206.71,151.78 205.24,151.78 204.83,152.19 PR601.1
VDDC_RTN: length 74.6
  IN2 w0.254: v3(173.06,134.2) 173.84,133.42 191.63,133.42 192.14,132.91 197.34,132.91 198.46,131.8 202.34,131.8 206.43,135.88 207.16,135.88 211.08,139.8 211.08,142.97 211.53,143.42 211.74,143.42 v3(212.25,143.93)
  IN3 w0.254: v1(151.57,140.04) 151.64,140.11 155.59,140.11 155.78,139.92 158.43,139.92 165.64,132.7 169.86,132.7 171.35,134.2 v3(173.06,134.2)
  BOTTOM w0.114: v4(212.93,144.13) 212.45,144.13 v3(212.25,143.93)
  BOTTOM w0.254: PR625.2 212.22,143.96 v3(212.25,143.93) ; v1(151.57,140.04) 151.25,140.36 UV1.AH29
VDDC_SEN: length 81.1
  IN2 w0.254: v3(212.27,142.94) 212.17,143.04 211.72,143.04 211.46,142.79 211.46,139.64 207.27,135.45 206.53,135.45 202.5,131.41 198.3,131.41 197.19,132.53 191.98,132.53 191.47,133.03 173.28,133.03 172.55,133.77 v3(172.55,134.79)
  IN3 w0.254: v1(148.23,139.66) 148.92,140.35 150.53,140.35 150.88,140.71 153.04,140.71 153.09,140.65 155.23,140.65 155.63,141.06 158.25,141.06 159.59,139.71 160.13,139.71 161.75,138.09 161.75,137.34 166.01,133.09 169.7,133.09 171.2,134.58 172.35,134.58 v3(172.55,134.79)
  BOTTOM w0.114: v4(212.91,142.33) 212.88,142.33 v3(212.27,142.94)
  BOTTOM w0.254: v3(212.27,142.94) 212.1,143.12 PR621.1 ; UV1.AF28 148.23,140.79 v1(148.23,139.66)
VDDPALW_PWRGD: length 2.9
  TOP w0.254: v4(139.58,47.51) 138.69,47.51 v3(138.64,47.56)
  BOTTOM w0.203: PR704.1 138.28,47.44
VIN_1.00VS: length 2.1
  TOP w0.254: PC714.1 v3(143.16,54.29) v4(143.85,54.29) ; v3(143.11,53.43) 143.08,53.41 PC706.1
VIN_+1.8VSP:
  vias: v4(188.5,180.99)
VSS_SENSE: length 27.9
  TOP w0.254: RC143.1 97.97,117.57 v3(97.97,116.88) 97.97,116.63 98.42,116.18 RC142.2
  IN1 w0.254: v3(97.97,116.88) 97.97,116.69 97.12,115.83 81.76,115.83 80.85,114.92 77.9,114.92 77.59,115.23 v1(77.59,115.42)
  BOTTOM w0.114: v2(78.75,115.13) 78.52,114.9 78.11,114.9 v1(77.59,115.42)
  BOTTOM w0.203: v1(77.59,115.42) 77.59,115.77 PC406.1 76.46,116.91 PR416.1 PC407.1
VSSGT_SENSE: length 19.7
  TOP w0.254: v3(63.89,124.37) 63.89,121.64 62.56,120.31 61.67,120.31 61.02,119.65 61.02,115.09 59.34,113.41 RC184.1 59.34,111.01 RC183.1
  BOTTOM w0.114: v2(62.69,125.06) 63.38,124.37 v3(63.89,124.37)
  BOTTOM w0.203: PC415.1 PR424.1 63.91,125.06 PC413.1 v3(63.89,124.37)
VSSIO_SENSE: length 3
  TOP w0.254: RC189.1 97.26,82.51 97.47,82.72 97.47,84.24 v2(97.28,84.43)
  BOTTOM w0.254: UC1.AM22 96.57,88.31 v3(96.51,88.31)
VSSSA_SENSE: length 57.6
  TOP w0.254: v3(103.36,124.17) 102.06,122.87 v4(102.06,119.95) 102.06,119.01 100.56,117.51 RC374.1 RC185.2
  IN1 w0.254: v3(103.36,124.17) 102.42,125.11 99.24,125.11 97.9,126.45 92.32,126.45 91.84,125.97 80.54,125.97 78.89,124.32 77.36,124.32 76.47,125.2 76.44,125.2 76.43,125.22 72.79,125.22 72.32,124.75 68.84,124.75 67.66,123.57 66.4,123.57 64.79,121.95 64.18,121.95 63.1,120.87 v3(62.16,120.87)
  BOTTOM w0.254: PR437.1 PC426.1 62.92,121.07 PC425.1 62.72,120.87 v3(62.16,120.87)
18PWRON_R: length 7
  TOP w0.114: UV12.3 172.41,174.6 v4(171.84,175.17) 171.84,176.04 172.37,176.57 CV240.1 DV7.2 174.4,176.91 RV153.2
+CRD_POWER: length 1
  TOP w0.203: v3(47.07,31.23) 47.24,31.39 UW1.12
  vias: v3(46.67,30.67) v4(34.55,35.22)
+DCPDSW: length 13.8
  TOP w0.508: CC60.1 120.12,87.21 v3(120.01,87.1)
  IN2 w0.305: v3(112.58,87.03) 113.09,87.54 115.37,87.54 116.83,86.08 118.99,86.08 v3(120.01,87.1)
  BOTTOM w0.152: UC1.AL1 110.76,88.86 v3(112.58,87.03)
+DCPRTC: length 0.9
  BOTTOM w0.203: v3(104.06,81.83) 104.12,81.9 UC1.BB10
  vias: v4(104.7,82.15)
+FBA_VREFC0: length 5.2
  BOTTOM w0.114: v4(118.98,138.5) 118.08,138.5 RV30.2
  BOTTOM w0.254: RV30.2 CV79.1 RV32.1 116.26,138.56 114.12,138.56 UV6.J14
+FBA_VREFC1: length 7.1
  BOTTOM w0.254: UV5.J14 114.04,160.11 114.96,160.11 115.22,160.36
  BOTTOM w0.381: RV43.2 RV45.1 117.37,163.59 CV106.1 v4(116.46,162.17) 116.46,161.6 115.22,160.36
+FBA_VREFD0: length 21.9
  TOP w0.381: v3(109.63,133.08) 109.47,133.23 109.47,134.33 109.12,134.68 v4(109.12,143.5) 109.12,143.8 109.71,144.39 CV80.1 111.11,145.13 v1(111.11,145.16)
  BOTTOM w0.254: UV6.U10 v1(111.11,145.16)
  BOTTOM w0.381: UV6.A10 111.94,130.73 RV33.1 RV31.2 110.95,130.51 109.63,131.83 v3(109.63,133.08)
+FBA_VREFD1: length 24.3
  TOP w0.381: v1(111.11,166.78) 111.43,167.1 CV107.1 109.86,167.45 v4(109.78,167.37) 109.47,167.07 109.47,157.45 109.68,157.24 109.68,154.57 v3(109.27,154.16)
  BOTTOM w0.254: UV5.U10 v1(111.11,166.78)
  BOTTOM w0.381: v3(109.27,154.16) 109.27,153.91 111.66,151.52 RV44.2 RV46.1 112.52,151.7 110.71,153.5 UV5.A10
+FBB_VREFC0: length 5.3
  BOTTOM w0.114: RV55.2 133.18,169.15 v4(133.15,169.13)
  BOTTOM w0.254: UV7.J14 133.2,174.09 133.2,171.95 CV133.1 RV57.1 RV55.2
+FBB_VREFC1: length 5.3
  BOTTOM w0.114: RV68.2 155.15,169.46 v4(154.87,169.18)
  BOTTOM w0.254: UV8.J14 155.13,174.16 CV160.1 155.15,171.95 RV70.1 RV68.2
+FBB_VREFD0: length 24.4
  TOP w0.381: v3(131.48,178.58) 132.54,179.64 134.5,179.64 135.41,178.73 139.91,178.73 v4(139.91,178.72) 140.47,178.17 CV134.1 140.12,176.77 v1(139.8,177.09)
  BOTTOM w0.254: UV7.U10 v1(139.8,177.09)
  BOTTOM w0.381: UV7.A10 125.37,176.27 RV58.1 RV56.2 125.15,177.26 126.47,178.58 v3(131.48,178.58)
+FBB_VREFD1: length 24.6
  TOP w0.381: v3(153.4,178.63) 153.6,178.83 161.88,178.83 v4(162.22,178.49) 162.79,177.92 162.79,176.67 CV161.1 162.24,176.65 v1(161.8,177.09)
  BOTTOM w0.254: UV8.U10 v1(161.8,177.09)
  BOTTOM w0.381: UV8.A10 148.53,177.49 146.72,175.68 RV71.1 RV69.2 146.54,176.54 148.62,178.63 v3(153.4,178.63)
+LCDVDD_CON: length 5.8
  TOP w0.203: JLCD.7 97.36,138.5 96.75,139.1 96.32,139.1 ; JLCD.8 97.09,138.23 96.75,138.57 96.5,138.57 96.17,138.9 96.12,138.9
  TOP w0.508: v3(94.06,136.87) 94.06,136.84 96.32,139.1
  vias: v2(91.98,134.08) v3(93.66,137.38)
+LEDVDD: length 3.6
  TOP w0.254: JLCD.1 99.07,140.19 99.83,139.44 ; JLCD.3 98.51,139.63 99.35,138.8 ; JLCD.2 99.73,138.98
  vias: v4(99.98,136.84)
+MICBIASB: length 13.7
  TOP w0.203: UA1.34 212.36,20.19 212.76,20.59
  TOP w0.254: 212.76,20.59 212.93,20.77 214.61,20.77 215.25,21.4 217.91,21.4 v4(218.4,20.92) 218.57,20.74 DA7.2 DA6.2
+PCH_CORE: length 10.2
  IN2 w0.381: v3(98.63,91.56) 97.36,91.56 96.68,92.24 96.68,94.35 v3(97.21,94.88) 97.21,95.67 v3(97.24,95.7)
  BOTTOM w0.254: v3(97.24,95.7) 97.6,95.34 UC1.V21 ; UC1.V21 97.75,95.24 98.21,95.24 UC1.V20 98.31,95.29 97.9,94.88 v3(97.21,94.88) 97.21,94.89 UC1.V21 ; UC1.AF18 v3(99.28,91.56) ; UC1.AF19 v3(98.63,91.56)
  vias: v4(118.07,91.76)
+RTCBATT: length 197.7
  TOP w0.381: RC11.1 119.06,74.14 118.64,73.73 v3(118.57,73.73)
  TOP w0.508: PD6.1 231.43,152.9 v3(232.65,152.9) ; v3(221.1,128.75) 216.51,124.16 216.51,116.34 v4(212.22,112.05) 205.16,112.05 v3(197.06,103.95) ; v3(151.95,71.29) 151.95,69.61 155.61,65.95 155.61,60.36 v3(153.73,58.49)
  IN1 w0.508: v3(153.73,58.49) 151.92,60.29 150.98,60.29 147.83,63.44 140.57,63.44 136.73,67.27 131.07,67.27 130.31,68.04 128.98,68.04 126.6,70.42 122.21,70.42 120.41,72.23 119.51,72.23 118.57,73.17 v3(118.57,73.73)
  IN2 w0.508: v3(221.1,128.75) 221.1,133.76 228.83,141.49 228.83,147.77 232.44,151.37 232.44,152.69 v3(232.65,152.9)
  IN3 w0.508: v3(151.95,71.29) 152.79,70.45 157.49,70.45 163.33,76.29 163.33,92.49 173.56,102.73 176.36,102.73 177.27,103.64 196.75,103.64 v3(197.06,103.95)
  BOTTOM w0.508: D6.1 v3(232.65,152.9)
+RTCVCC: length 1.7
  BOTTOM w0.178: UC1.BB14 101.7,81.8 v3(101.69,81.78)
  BOTTOM w0.254: UC1.AK19 v3(98.34,88.93)
  vias: v2(118.04,75.35)
+USB_VCCA: length 1.4
  TOP w0.508: v3(18.29,50.13) 17.91,50.13 17.66,49.87 D7.5
  vias: v3(22.26,46.6) v3(22.28,45.89) v3(22.94,46.62) v3(22.85,25.25) v3(22.97,45.91) v3(23.23,24.68) v3(23.48,47.16) v3(23.55,25.25) v3(23.93,24.68) v3(24.25,25.25) v4(20.1,45.61)
+V_DDR_REFA: length 7.7
  TOP w0.305: v5(60.15,38.75) 61.09,38.75 61.64,38.2 CD1.1 CD3.1 RD3.1 RD1.2 58.86,37.72 RD2.2
  BOTTOM w0.305: v5(60.15,38.75) 59.92,38.52 JDIMM1.1
+V_DDR_REFB: length 8.7
  TOP w0.305: RD17.2 58.27,50.87 RD15.2 RD16.1 60.05,50.86 CD32.1 CD33.1 61.12,50.87 61.47,50.51 61.47,49.57 60.86,48.96 v5(59.67,48.96)
  BOTTOM w0.305: JDIMM2.1 59.92,49.21 v5(59.67,48.96)
+VCOREVCC: length 3.7
  TOP w0.114: UE1.12 202.83,48.87 203.06,48.63 CE7.2 204.07,48.57 v2(204.07,47.72)
+VGA_B+:
  vias: v3(197.08,153.3) v3(197.08,152.59) v3(197.06,143.93) v3(197.06,143.22) v3(197.08,142.53) v4(198.81,141.72)
+VGA_CORE: length 332.7
  TOP w0.114: 167.71,150.57 v3(167.62,150.48)
  TOP w0.203: 141.79,157.9 143,156.69 143,155.55 143.5,155.04 143.5,154.22 143.76,153.96
  TOP w0.254: v3(210.57,141.39) 212.92,139.04 215.89,139.04 218.18,141.33 218.18,144.06 221.67,147.55 221.67,151.93 219.39,154.22 218.69,154.22 217.67,155.23 217.67,156.76 216.46,157.96 212.02,157.96 210.29,159.7 202.77,159.7 199.99,162.47 182.02,162.47 180.94,161.39 174.87,161.39 172.14,164.12 170.36,164.12 167.95,166.54 160.74,166.54 154.84,160.63 142.71,160.63 141.79,159.71 141.79,157.9
  IN3 w0.254: v1(215.75,142.43) 214.53,142.43 206.83,134.72 202.55,134.72 201.38,133.55 192.88,133.55 192.87,133.55 180.28,133.55 178.54,135.29 178.54,137.86 v3(179.3,138.62) ; v1(215.83,143.19) 215.83,143.42 216.41,144.01 216.41,146.79 217.35,147.73 217.35,149.44 217.81,149.9 217.81,156.55 216.95,157.42 210.9,157.42 205.31,163.01 189.24,163.01 188.17,161.94 181.16,161.94 179.57,160.35 179.57,157.1 v3(179.03,156.55)
  BOTTOM w0.203: v1(150.09,145.81) v1(150.09,143.83) 150.09,143.63 150.09,143.63 150.09,142.61 v1(150.07,142.58)
  BOTTOM w0.254: PR618.2 215.17,143.02 v1(215.75,142.43) ; v3(210.57,141.39) 210.32,141.39 209.86,141.85 PR622.1 ; PL604.2 178.47,157.11 v3(179.03,156.55) ; v1(215.83,143.19) 215.83,143.38 216.03,143.58 PR636.2
  BOTTOM w0.356: v1(150.09,145.81) 150.44,146.16 UV1.AH22 ; UV1.R16 139.6,151.14 v1(139.12,150.66) 138.62,150.16 UV1.N17
  BOTTOM w0.381: UV1.N17 138.6,150.1 137.66,149.16 UV1.M18 ; UV1.T15 140.6,152.12 140.13,151.64 v1(140.13,151.63) 139.65,151.16 UV1.R16 ; UV1.AC15 146.6,152.16 ; 146.6,152.16 147.06,151.7 v1(147.07,151.7) 147.07,151.69 147.6,151.16 UV1.AD16 ; 146.6,152.16 146.6,152.17 147.01,152.58 v1(147.01,152.64) 147.01,152.66 147.51,153.16 UV1.AD13 147.1,153.66 v1(147.1,153.66) 146.6,154.16 UV1.AC12 UV1.AB13 UV1.AA13 ; UV1.AC24 146.85,144.41 146.9,144.41 v1(147.1,144.61) 147.6,145.11 UV1.AD23 147.6,145.29 148.07,145.76 148.14,145.76 v1(148.14,145.76) 148.14,145.83 148.47,146.16 UV1.AF22 148.6,146.17 v1(149.08,146.65) ; UV1.AC24 146.51,144.16 v1(146.08,144.59) ; UV1.AC24 146.12,143.68 v1(146.08,143.68) 146.08,143.64 UV1.AB26 145.44,143.16 v1(144.95,142.67) 144.6,142.32 UV1.AA27 144.6,142.13 143.63,141.16 UV1.Y28 ; UV1.AA13 UV1.AA15 UV1.Y16 143.1,150.66 143.07,150.66 v1(143.02,150.62) 143.02,150.6 142.6,150.18 UV1.V17 142.6,150.14 141.62,149.16 UV1.U18 141.6,149.15 141.05,148.59 141.04,148.59 v1(141,148.64) 141,148.57 140.6,148.17 UV1.T20 140.57,148.16 139.6,147.19 UV1.R21 ; UV1.AA13 v1(144.1,153.66) 143.6,153.16 UV1.Y13 143.6,153.13 v3(143.15,152.68) 142.63,152.16 UV1.V15 142.6,152.13 v3(142.15,151.68) ; UV1.AB16 145.54,151.16 v1(145.01,150.64) 144.6,150.22 UV1.AA17 144.6,150.11 144.19,149.7 144.14,149.7 UV1.Y18 143.52,149.16 v1(142.99,148.63) 142.6,148.24 UV1.V20 142.57,148.16 141.6,147.19 UV1.U21 141.14,146.7 v1(141.03,146.7) 140.97,146.7 140.6,146.33 UV1.T22 140.6,146.12 140.21,145.74 140.21,145.65 140.12,145.65 139.64,145.16 UV1.R23 UV1.N24 138.6,144.02 138.31,143.73 138.26,143.73 138.18,143.65 138.18,143.6 137.74,143.16 UV1.M26 ; UV1.AH27 150.91,142.16 v1(151.16,142.41) ; UV1.AH27 UV1.AH28 ; UV1.AH27 150.49,142.16 v1(150.07,142.58) ; UV1.M16 UV1.M15 ; v1(140.13,153.67) 140.11,153.67 UV1.R13 v1(139.09,152.65) ; v1(140.13,153.67) 140.13,153.69 UV1.T12 ; v1(140.13,153.67) 139.64,154.16 UV1.R12 ; UV1.AG18 149.6,149.13 149.08,148.61 v1(149.08,148.58) 149.02,148.58 UV1.AF20 148.54,148.16 147.6,147.22 UV1.AD21 147.56,147.16 147.1,146.7 v1(147.1,146.63) 146.63,146.16 UV1.AC22 146.5,146.16 145.64,145.3 145.64,145.2 UV1.AB23 145.11,144.67 v1(145.07,144.67) 144.98,144.58 144.98,144.54 UV1.AA24 144.6,144.14 144.19,143.73 144.17,143.73 UV1.Y26 143.55,143.16 v1(143.09,142.69) 142.6,142.21 UV1.V27 ; v3(179.3,138.62) 178.85,138.17 PL603.2 ; v1(139.09,152.65) UV1.N15 ; v1(139.09,152.65) 138.6,153.14 UV1.N13 ; UV1.U16 141.6,151.16 141.05,150.61 v1(141.05,150.61) 141.03,150.58 141.03,150.51 140.68,150.16 UV1.T17 140.56,150.16 140.15,149.75 140.15,149.7 139.61,149.16 UV1.R18 ; v1(147.11,150.6) 146.67,150.16 UV1.AC17 146.6,150.14 146.16,149.7 146.12,149.7 145.6,149.17 UV1.AB18 145.47,149.16 145.07,148.76 v1(145.07,148.68) 144.99,148.6 144.99,148.55 UV1.AA20 144.57,148.16 144.15,147.74 144.15,147.71 UV1.Y21 143.13,146.69 v1(143.13,146.65) 142.64,146.16 UV1.V22 142.6,146.1 141.66,145.16 UV1.U23 141.43,145.16 141.05,144.78 v1(141.05,144.67) 140.94,144.55 140.94,144.5 UV1.T24 140.6,144.16 140.23,143.78 140.23,143.65 139.74,143.16 UV1.R26 ; UV1.M23 UV1.N22 138.6,146.16 v1(139.1,146.66) ; v3(139.03,148.69) 138.6,148.26 UV1.N20 ; UV1.AB28 145.61,141.16 146.6,142.15 UV1.AC27 146.61,142.16 147.15,142.7 147.15,142.71 v1(147.16,142.72) 147.15,142.73 147.15,142.74 147.57,143.16 UV1.AD26 ; UV1.AG16 v3(149.12,150.68) UV1.AF17 148.16,149.72 148.15,149.72 148.15,149.71 UV1.AD18 147.49,149.16 146.98,148.65 v1(146.97,148.65) 146.97,148.59 146.6,148.21 UV1.AC20 146.54,148.16 146.08,147.71 146.08,147.7 146.07,147.68 146.06,147.68 145.6,147.22 UV1.AB21 145.11,146.67 v1(145.07,146.67) 144.6,146.21 UV1.AA22 144.23,145.79 144.23,145.69 144.13,145.69 UV1.Y23 143.56,145.16 v1(143.02,144.62) 142.6,144.2 UV1.V24 142.24,143.8 142.12,143.8 142.12,143.68 UV1.U26 141.46,143.02 141.46,143.01 v1(141.1,142.66)
  vias: v1(138.18,152.67) v1(138.16,151.65) v1(138.18,148.66) v1(150.04,149.75) v1(150.02,147.59) v1(150.13,152.73) v1(150.09,140.91) v3(153.19,145.95) v3(154.82,147.25) v3(165.54,148.6) v3(165.54,146.22) v3(165.51,144.85) v3(165.64,149.82) v3(165.61,147.44) v3(165.79,145.58) v3(165.89,149.21) v3(165.92,147.99) v3(165.92,146.85) v3(166.02,144.31) v3(166.17,148.63) v3(166.17,146.22) v3(166.17,144.95) v3(166.27,150.53) v3(166.3,149.87) v3(166.3,147.36) v3(166.48,145.58) v3(166.55,149.26) v3(166.6,147.97) v3(166.63,146.78) v3(166.78,144.31) v3(166.93,149.85) v3(166.91,148.58) v3(166.93,147.39) v3(166.91,146.19) v3(166.88,144.97) v3(166.96,150.51) v3(167.24,147.97) v3(167.19,145.58) v3(167.16,143.75) v3(167.27,149.19) v3(167.27,146.78) v3(167.54,148.58) v3(167.54,146.19) v3(167.52,144.97) v3(167.54,144.31) v3(167.57,149.8) v3(167.57,147.39) v3(167.9,149.19) v3(167.87,147.97) v3(167.9,146.78) v3(167.87,145.58) v3(167.93,143.73) v3(168.2,149.8) v3(168.18,148.58) v3(168.2,147.39) v3(168.18,146.19) v3(168.15,144.97) v3(168.18,144.34) v3(168.28,150.48) v3(168.54,149.19) v3(168.51,147.97) v3(168.54,146.78) v3(168.51,145.58) v3(168.61,143.68) v3(168.84,149.8) v3(168.81,148.58) v3(168.84,147.39) v3(168.81,146.19) v3(168.81,144.97) v3(168.92,144.26) v3(169.17,149.19) v3(169.17,147.97) v3(169.2,146.78) v3(169.17,145.58) v3(169.45,144.97) v3(169.47,149.8) v3(169.47,148.58) v3(169.5,147.39) v3(169.47,146.19) v3(169.83,149.19) v3(169.81,147.97) v3(169.83,146.78) v3(169.81,145.58) v3(170.14,149.8) v3(170.11,148.58) v3(170.14,147.39) v3(170.11,146.19) v3(170.08,144.97) v3(170.44,147.99) v3(170.44,145.61) v3(170.47,149.19) v3(170.47,146.8) v3(170.74,148.6) v3(170.74,146.22) v3(170.72,145) v3(170.77,149.8) v3(170.77,147.41) v3(171.1,149.21) v3(171.08,147.99) v3(171.1,146.8) v3(171.08,145.61) v3(171.41,149.82) v3(171.38,148.6) v3(171.41,147.41) v3(171.38,146.22) v3(171.35,145) v3(171.74,149.21) v3(171.74,147.99) v3(171.74,145.61) v3(171.76,146.8) v3(172.04,149.82) v3(172.04,148.6) v3(172.04,146.22) v3(172.01,145) v3(172.07,147.41) v3(172.22,144.34) v3(172.4,149.21) v3(172.37,147.99) v3(172.4,146.8) v3(172.37,145.61) v3(172.7,149.82) v3(172.68,148.6) v3(172.7,147.41) v3(172.68,146.22) v3(172.65,145) v3(172.75,143.78) v3(172.95,144.41) v3(173.11,150.51) v3(173.08,149.19) v3(173.08,148.02) v3(173.11,146.78) v3(173.06,145.58) v3(173.44,146.12) v3(173.41,144.92) v3(173.41,143.88) v3(173.46,149.85) v3(173.51,148.6) v3(173.46,147.41) v3(173.74,150.48) v3(173.74,146.78) v3(173.74,145.56) v3(173.84,149.19) v3(173.84,148.02) v3(173.79,144.41)
+VREF_CA: length 31.9
  TOP w0.381: v3(99.16,44.94) 99.43,44.94 99.79,44.57 99.79,43.94 100.39,43.35 CD49.1
  TOP w0.508: RD10.1 RD11.1 RD9.2 CD18.1 CD17.1 99.75,26.2 99.91,26.36 v3(99.91,27.2) ; CD49.1 100.87,42.79 v4(101.61,42.05) 101.62,42.05 102.34,41.33 102.34,40.18 102.74,39.79 102.74,37.44 101.34,36.04 101.34,33.12 101.85,32.62 v3(102.04,32.62)
  IN1 w0.508: v3(99.91,27.2) 101.21,28.5 101.21,32.06 101.77,32.62 v3(102.04,32.62)
  BOTTOM w0.254: v3(99.91,27.2) 99.82,27.29 JDIMM1.126
  BOTTOM w0.305: JDIMM2.126 99.82,42.15 99.82,44.66 99.54,44.94 v3(99.16,44.94)
AC_PRESENT: length 139.4
  TOP w0.114: v3(120.78,65.43) 120.78,66.09 120.26,66.61 119.71,66.61 118.86,67.46 116.25,67.46 115.65,68.06 113.92,68.06 112.93,67.07 112.48,67.07 110.26,64.85 110.26,64.22 RPC18.8 ; UE1.128 199.71,41.86 v5(200.59,40.98)
  IN2 w0.14: v3(120.78,65.43) 122.43,65.43 123.52,64.34 132.54,64.34 134.55,62.33 137.73,62.33 139.19,60.87 141.42,60.87 143.26,59.04 152.12,59.04 158.79,52.38 161.89,52.38 168.32,45.95 171.95,45.95 v1(172.21,46.2)
  BOTTOM w0.076: UC1.AY15 100.82,83.18 100.82,82.9 100.71,82.79 100.71,81.27 103.66,78.31 103.66,77.92
  BOTTOM w0.114: v1(172.21,46.2) 172.52,46.52 173.79,46.52 176.78,43.53 179.78,43.53 180.98,42.33 199.24,42.33 v5(200.59,40.98) ; 103.66,77.92 103.66,73.6 108.92,68.34 110.59,68.34 113.1,65.83 118.04,65.83 118.83,65.04 120.25,65.04 120.65,65.43 v3(120.78,65.43)
ACIN: length 8.9
  TOP w0.114: RE33.1 RE43.1 ; RE33.1 CE12.1 193.48,37.52 DEV1.2 ; RE33.1 191.22,37.52 191.22,39.12 191.17,39.17 191.17,40.81 v2(191.5,41.14) 191.5,41.42 191.71,41.63 UE1.108
ACN: length 5.4
  BOTTOM w0.254: PC109.1 PR108.1 180.78,166.97 PR106.2 180.12,167.32 180.96,168.16 v4(180.96,168.29) 180.78,168.47 179.91,168.47 179.33,169.05
ACOFF: length 199
  TOP w0.114: v3(188.17,44.79) 187.71,44.34 UE1.98
  IN1 w0.14: v3(188.17,44.79) 188.27,44.79 189.36,43.7 195.05,43.7 195.8,44.45 195.8,51.54 196.98,52.72 196.98,60.82 198.99,62.83 200.06,62.83 200.97,63.74 200.97,65.5 201.54,66.06 201.54,69.18 207.26,74.9 207.26,81.3 205.64,82.91 205.64,95.86 204.95,96.56 204.95,102.57 206.48,104.1 206.48,108.96 205.87,109.56 205.87,118.57 207.32,120.01 207.32,126.68 210.11,129.47 v3(210.11,134.91)
  IN2 w0.14: v3(210.11,134.91) 210.93,134.91 211.28,135.27 211.28,137.36 212.78,138.85 214.18,138.85 223.79,148.47 223.79,157.43 221.78,159.44 212.74,159.44 208.11,164.07 183.42,164.07 181.44,166.04 173.22,166.04 v3(172.73,166.54)
  BOTTOM w0.254: PR109.1 v4(169.4,165.7) 170.24,166.54 v3(172.73,166.54)
ACP: length 3.5
  BOTTOM w0.203: PR107.2 179.23,168.26 v4(179.2,168.29) 179.05,168.44 178.62,168.44 178.09,168.97 PU101.2
ACPRN: length 195.2
  TOP w0.114: v3(189.41,37.38) 189.41,37.12 189.94,36.6 RE43.2 190.2,35.94 190.79,35.35 v4(191.83,35.35) DEV1.1
  IN1 w0.14: v3(189.41,37.38) 189.41,38.6 191.55,40.73 192.79,40.73 196.07,44.01 196.07,51.4 197.34,52.67 197.34,60.59 199.12,62.37 199.98,62.37 201.24,63.63 201.24,65.39 201.8,65.95 201.8,69.07 207.52,74.79 207.52,81.41 206,82.94 206,95.9 207.02,96.92 207.12,96.92 207.3,97.09 207.3,108.7 206.14,109.86 206.14,118.45 207.65,119.97 207.65,126.63 210.38,129.36 210.38,134.3 210.75,134.67 v3(210.75,135.42)
  IN2 w0.14: v3(210.75,135.42) 210.75,137.2 213.37,139.82 214.76,139.82 223.53,148.58 223.53,155.92 220.27,159.17 212.63,159.17 208,163.8 183.3,163.8 181.33,165.77 176.36,165.77 v3(175.88,165.29)
  BOTTOM w0.254: PR118.1 v3(175.88,165.29)
ADAPTER_ID_ON: length 5.1
  BOTTOM w0.114: v4(242.4,160.42) 242.4,159.78 PR8.1 PR5.2 242.44,158.22 PQ4.3 241.22,158.22 241.02,158.41 241.02,158.89 241.1,158.97 PQ4.2
ADAPTER_ID_ON#: length 154.4
  TOP w0.084: 195.71,43.65 UE1.118
  TOP w0.114: v3(190.89,47.07) 191.38,47.56 193.15,47.56 195.71,45 195.71,43.65
  IN1 w0.14: v3(190.89,47.07) 190.89,59.22 196.73,65.06 196.73,67.28 204.11,74.67 204.11,94.97 203.53,95.55 203.53,103.06 204.53,104.05 204.53,119.29 205.72,120.49 205.72,127.07 207.42,128.77 207.42,130.72 208.85,132.15 208.85,136.67 212.96,140.78 212.96,145.02 214.06,146.13 216.68,146.13 217.8,147.25 217.8,152.68 219.33,154.22 221.06,154.22 221.57,154.73 v3(221.57,155.56)
  BOTTOM w0.114: v3(221.57,155.56) 222.56,154.57 223.25,154.57 224.78,156.11 227.65,156.11 228.5,155.26 230.09,155.26 230.57,155.74 232.42,155.74 232.9,155.26 234.91,155.26 236.31,156.65 237.9,156.65 v4(238.77,157.52) 238.77,158.15 239.58,158.97 PQ4.5
ADDR_SEL: length 4.2
  TOP w0.254: RG5.1 RG8.2 205.29,71.54 v4(205.78,71.05) UGSEN1.7
ADP_I: length 178.9
  TOP w0.114: UE1.71 187.33,54.47 v3(187.38,54.52)
  IN1 w0.14: v3(207.27,131.64) 207.27,131.41 206.69,130.82 206.69,128.97 205.11,127.4 205.11,120.64 203.98,119.51 203.98,104.29 203,103.31 203,95.33 203.58,94.75 203.58,74.89 195.23,66.54 195.23,65.75 187,57.52 187,54.9 v3(187.38,54.52)
  IN2 w0.14: v3(207.27,131.64) 209.51,133.87 209.51,136.46 213.19,140.15 214.68,140.15 222.57,148.04 222.57,156.01 219.68,158.9 212.49,158.9 207.88,163.51 183.21,163.51 181.22,165.51 176.96,165.51 176.24,164.8 173.3,164.8 171.89,166.2 v3(171.89,167.43)
  BOTTOM w0.254: PR122.1 PC125.2 v4(171.23,167.81) 171.61,167.43 v3(171.89,167.43)
ADP_ID: length 161.4
  TOP w0.114: UE1.73 188.43,53.67 v3(189.29,54.52)
  TOP w0.254: v3(243.13,162.73) 242.95,162.73 PD4.2
  IN1 w0.14: v3(238.61,163.44) 238.54,163.37 238.54,161.81 235.51,158.79 235.51,156.07 234.27,154.83 234.27,153.28 227.48,146.49 227.48,138.94 223.27,134.73 223.27,123.56 215.47,115.76 215.47,107.13 214.76,106.42 214.76,69.7 216.51,67.94 216.51,60.63 v3(217.3,59.83)
  IN3 w0.114: v3(212.22,54.32) 213.21,55.31 213.21,55.74 v3(217.3,59.83)
  BOTTOM w0.114: v3(212.22,54.32) 210.93,53.02 207.91,53.02 206.93,52.05 205.72,52.05 205.07,51.39 202.93,51.39 198.43,55.89 190.91,55.89 189.54,54.52 v3(189.29,54.52)
  BOTTOM w0.254: v3(238.61,163.44) 238.81,163.64 v4(239.86,163.64) 239.86,163.34 240.47,162.73 v3(243.13,162.73) 243.52,162.35 PD5.1 242.49,161.51 PR7.2
ALL_PWRGD: length 6.1
  TOP w0.114: v4(206.43,54.47) 206.43,54.95 RE41.1 205.39,56 203.08,56 202.75,55.67 UE1.29
AOU_CTL1: length 210.4
  TOP w0.114: UE1.84 198.12,49.27 v3(198.58,48.81) ; AOU1.6 34.65,21.14 v5(34.83,21.33)
  IN3 w0.114: v5(34.83,21.33) 34.83,20.92 35.69,20.06 35.69,16.44 38.86,13.28 75.2,13.28 75.98,14.06 116.82,14.06 120.81,10.07 138.43,10.07 141.77,13.41 148.85,13.41 153.52,18.09 158.16,18.09 158.88,17.36 170.82,17.36 173.67,20.21 177.87,20.21 179.93,22.26 184.33,22.26 186.16,24.09 186.85,24.09 190.04,27.29 190.04,28.58 198.44,36.98 198.44,38.61 199.11,39.28 199.11,48.28 v3(198.58,48.81)
AOU_CTL3: length 209.7
  TOP w0.114: v3(193.38,56.66) 193.71,56.99 UE1.48 ; AOU1.8 33.65,20.98 v5(33.33,21.3)
  IN3 w0.114: v5(33.33,21.3) 33.84,21.81 35.67,21.81 36.35,21.12 36.35,16.47 39.06,13.76 72.48,13.76 73.26,14.54 117.04,14.54 121.02,10.56 138.22,10.56 141.56,13.9 147.71,13.9 152.66,18.84 169.96,18.84 173.01,21.88 177.59,21.88 179.35,23.65 183.03,23.65 183.75,24.37 183.75,24.73 187.08,28.06 187.51,28.06 193.41,33.96 193.41,37.33 195.27,39.18 197.47,39.18 198.53,40.25 198.53,45.61 197.41,46.73 197.41,52.62 v3(193.38,56.66)
AOU_EN: length 209.9
  TOP w0.114: AOU1.5 35.15,20.55 35.34,20.74 36.05,20.74 36.33,21.02 v4(36.33,21.25) 36.18,21.4 35.62,21.4 v3(35.49,21.27) ; UE1.85 197.86,48.87 v3(198.56,48.17)
  IN3 w0.114: v3(198.56,48.17) 198.87,47.86 198.87,40.24 197.57,38.94 195.37,38.94 193.66,37.23 193.66,33.82 187.65,27.81 187.19,27.81 184.03,24.65 184.03,24.31 183.13,23.41 179.45,23.41 177.63,21.58 173.23,21.58 170.26,18.6 153.7,18.6 148.75,13.65 141.66,13.65 138.32,10.31 120.92,10.31 116.93,14.3 73.53,14.3 72.75,13.52 38.96,13.52 36.05,16.43 36.05,20.72 v3(35.49,21.27)
AOU_IFG#: length 217.4
  TOP w0.114: v4(208.13,58.08) 207.8,57.75 v3(207.02,57.75) 207.02,58.16 207.32,58.46 RPE1.7 ; UE1.25 202.66,54.07 v3(202.84,53.89) 203.42,53.3 205.47,53.3 v3(205.92,53.76)
  TOP w0.254: AOU1.9 v3(31.94,19.35)
  IN1 w0.14: v3(207.02,57.75) 207.02,56.73 206.33,56.05 206.33,54.17 v3(205.92,53.76)
  IN3 w0.114: v3(31.94,19.35) 32.07,19.35 35.69,15.73 35.72,15.73 38.66,12.8 117.18,12.8 120.38,9.59 138.63,9.59 141.87,12.83 148.95,12.83 153.69,17.57 157.77,17.57 158.45,16.88 180.75,16.88 183.43,19.56 183.43,20.89 183.93,21.39 185.26,21.39 190.53,26.66 190.53,27.03 200.15,36.65 200.15,38.52 200.09,38.58 200.09,48.9 201.26,50.08 201.26,52.32 v3(202.84,53.89)
APDIN: length 3.6
  TOP w0.508: v3(232.93,173.18) v4(233.59,173.18) ; v3(235.74,168.47) 234.83,169.38 v4(234.83,170.35) ; v4(233.7,162.2) v3(233.02,162.2)
AUXN: length 3.4
  TOP w0.114: CVG19.2 33.53,86.98 33.2,86.98 32.65,87.54 31.66,87.54 31.52,87.67 UVG2.3
AUXP: length 3.4
  TOP w0.114: UVG2.2 31.52,87.17 31.66,87.31 v3(32.14,87.31) 32.56,87.31 33.11,86.76 33.54,86.76 CVG20.2
B+: length 108.8
  TOP w0.254: PD3.2 74.35,12.51 74.96,13.12 74.96,16.73 v3(72.35,19.34)
  IN1 w0.254: v1(181.16,164.38) 181.29,164.25 182.43,164.25 184.4,166.22 186.49,166.22 187.45,165.27 211.35,165.27 219.41,173.32 v3(219.41,177.28)
  IN2 w0.254: v3(102.93,133.39) 101.7,133.39 100.62,134.48 97.26,134.48 94,131.23 92.08,131.23 90.99,132.32 87.68,132.32 84.57,129.21 77.64,129.21 v3(76.61,128.18)
  IN3 w0.305: v3(56.29,19.12) 56.65,18.76 71.76,18.76 v3(72.35,19.34)
  BOTTOM w0.254: PR106.1 180.12,165.37 PC105.1 PC106.1 181.31,164.53 v1(181.16,164.38) ; v3(219.41,177.28) 219.84,177.71 PR101.2 ; v3(76.61,128.18) 77.15,127.65 PR401.1
  vias: v3(35.43,46.08) v3(35.43,45.38) v3(35.43,44.68) v3(35.43,43.98) v3(35.43,43.28) v3(35.43,42.58) v3(36.12,46.08) v3(36.12,45.38) v3(36.12,44.68) v3(36.12,43.98) v3(36.12,43.28) v3(36.12,42.58) v3(36.82,46.08) v3(36.82,45.38) v3(36.82,44.68) v3(36.82,43.98) v3(36.82,43.28) v3(36.82,42.58) v3(102.5,132.32) v3(102.96,132.76) v3(103.94,133.97) v3(145.47,29.12) v3(145.5,28.39) v3(145.52,27.6) v3(146.16,28.72) v3(146.18,27.98) v3(147.1,124.81) v3(147.2,124.12) v3(147.77,124.76) v3(147.76,58) v3(147.76,57.37) v3(147.91,124.09) v3(148.39,58) v3(148.39,57.37) v3(150.42,50.2) v3(150.68,50.84) v3(150.93,51.47) v3(151.06,50.2) v3(151.31,50.84) v3(151.57,51.47) v3(151.75,73.7) v3(151.75,73.01) v3(151.72,72.28) v3(151.69,50.2) v3(151.95,50.84) v3(152.2,51.47) v3(152.33,73.34) v3(152.28,72.58) v3(152.25,71.9) v3(152.33,50.2) v3(152.58,50.84) v3(152.84,51.47) v3(152.96,50.2) v3(153.22,50.84) v3(153.47,51.47) v3(153.85,50.97) v3(154.23,99.2) v3(154.29,98.52) v3(154.29,97.75) v3(154.34,96.97) v3(154.82,99.58) v3(154.84,98.87) v3(154.84,98.08) v3(154.84,97.4) v3(155.43,99.89) v3(155.4,99.23) v3(155.4,98.46) v3(155.43,97.73) v3(176.82,9.59) v3(176.82,8.96) v3(176.82,8.32) v3(176.82,7.66) v3(176.79,7) v3(177.6,9.13) v3(177.6,8.5) v3(177.6,7.86) v3(177.6,7.2) v3(178.36,9.08) v3(178.77,9.82) v3(179.1,9.11) v3(179.41,9.82) v3(179.74,9.11) v3(180.04,9.82) v3(180.37,9.11) v3(180.7,9.82) v3(181.03,9.11) v3(188.8,168.37) v3(189.08,168.95) v3(189.34,170.14) v3(189.44,169.51) v3(189.44,168.37) v3(189.77,168.95) v3(190.07,169.53) v3(190.07,168.39) v3(190.35,170.12) v3(190.4,168.98) v3(190.71,169.53) v3(190.71,168.39) v3(191.04,168.98) v3(191.06,170.14) v3(191.34,169.53) v3(191.34,168.39) v3(199.57,119.67) v3(199.57,118.91) v3(202.07,141.97) v3(202.06,141.31) v3(202.67,144.95) v3(202.67,144.31) v3(202.67,143.6) v3(202.67,142.91) v3(202.7,141.98) v3(202.7,141.31) v3(203.28,145.3) v3(203.31,144.64) v3(203.31,144.01) v3(203.31,143.37) v3(203.33,142.74) v3(203.34,141.97) v3(203.38,141.34) v3(203.99,144.46) v3(203.99,143.75) v3(203.97,142.97) v3(220.61,180.63) v3(221.27,180.61) v3(221.29,179.44) v3(221.6,180.02) v3(221.62,178.88) v3(221.93,180.61) v3(221.95,179.44) v3(221.98,178.27) v3(222.26,180.02) v3(222.28,178.88) v3(222.59,180.61) v3(222.61,179.44) v3(222.64,178.27) v3(222.92,180.02) v3(222.94,178.88)
B+_1.35V: length 23.5
  TOP w0.254: v4(135.74,28.51) 135.74,29.15 v3(135.72,29.17)
  IN1 w0.381: v3(142.78,28.46) 143.11,28.46 146.79,32.15 146.79,35.93 144.81,37.91 141.99,37.91 141.05,38.85 140.09,38.85 137.62,41.31 v3(137.62,42.69)
  BOTTOM w0.254: PR309.1 v3(137.62,42.69)
  vias: v3(136.35,29.17)
BATLOW#: length 45
  TOP w0.114: v3(110.77,64.51) 111.17,64.11 RPC18.7
  IN1 w0.076: v3(101.99,85.12) 101.99,84.96 104.11,82.84 104.65,82.84 105.44,82.06 106.87,82.06 112.24,76.69
  IN1 w0.14: v3(121.55,68.87) 120.92,69.5 120.02,69.5 119.23,70.29 119.23,71.12 117.66,72.68 116.24,72.68 112.24,76.69
  BOTTOM w0.076: v3(101.99,85.12) 102.33,85.45 UC1.AU13
  BOTTOM w0.114: v3(121.55,68.87) 121.67,68.75 121.67,65.06 121.21,64.6 121.21,63.64 120.94,63.37 119.09,63.37 118.92,63.2 112.09,63.2 v3(110.77,64.51)
BATT+: length 34.2
  IN3 w0.254: v3(183.45,175.07) 183.27,175.25 183.27,176.19 185.58,178.5 193.1,178.5 193.4,178.81 208.34,178.81 v3(208.49,178.65)
  BOTTOM w0.254: PR128.1 180.65,177.01 181.11,177.01 PC123.1 181.46,177.01 181.97,177.01 PC124.2 182.38,177.01 182.87,177.01 183.25,176.63 183.25,175.26 v3(183.45,175.07) ; PR117.2 208.16,178.98 v3(208.49,178.65)
BATT_TEMP: length 222
  TOP w0.114: CE16.1 183.7,56.9 183.7,56.19 v2(184.22,55.67) UE1.68 v3(187.46,55.67)
  TOP w0.254: PR17.2 203.18,184.44 v3(202.49,184.44)
  IN1 w0.14: v3(207.27,132.32) 207.73,131.87 207.73,131.41 207.02,130.7 207.02,128.82 205.42,127.22 205.42,120.57 204.25,119.4 204.25,104.18 203.26,103.2 203.26,95.44 203.85,94.86 203.85,74.78 196.46,67.39 196.46,65.41 187.46,56.4 v3(187.46,55.67)
  IN1 w0.254: v3(175.95,174.54) 175.95,175.3 177.17,176.52 186.12,176.52 191.86,182.26 196.88,182.26 199.07,184.44 v3(202.49,184.44)
  IN2 w0.14: v3(207.27,132.32) 209.2,134.25 209.2,136.56 215.14,142.51 215.14,143.16 215.65,143.66 217.54,143.66 222.31,148.43 222.31,155.9 219.57,158.64 212.38,158.64 207.77,163.25 183.1,163.25 181.16,165.19 177.01,165.19 176.35,164.53 173.19,164.53 171.04,166.67 171.04,170.9 174.1,173.95 175.37,173.95 v3(175.95,174.54)
  BOTTOM w0.254: PU101.15 176.09,174.4 v3(175.95,174.54)
BEEP#: length 39.1
  TOP w0.114: UE1.32 202.55,56.87 v3(202.62,56.94) ; v3(192.64,29.99) v4(193.06,30.41) DA1.2 196.76,29.12 CA22.1
  IN3 w0.114: v3(192.64,29.99) 193.07,29.99 199.9,36.82 199.9,38.42 199.85,38.48 199.85,49 201.02,50.18 201.02,55.34 v3(202.62,56.94)
BKOFF#: length 180.7
  TOP w0.114: v2(99.04,130.42) 98.71,130.42 R26.1 98.38,131.26 98.38,131.46 97.65,132.19 97.65,133.02 v3(97.85,133.21) 97.85,133.52 97.62,133.75 97.62,134.43 97.16,134.89 97.16,136.45 JLCD.11 ; v3(196.6,47.64) 196.11,47.15 UE1.119
  IN2 w0.14: v3(97.85,133.21) 99.3,133.21 103.23,129.28 117.38,129.28 118.75,127.91 138.38,127.91 143.73,122.56 153.96,122.56 157.87,118.66 157.87,111.85 160.57,109.15 160.57,96.53 160.31,96.27 160.31,93.46 157.99,91.15 157.99,87.54 160.25,85.28 160.25,75.2 160.86,74.59 160.86,73.37 172.13,62.1 183.55,62.1 184.37,61.28 189.53,61.28 194.22,56.58 194.77,56.58 195.23,57.04 196.3,57.04 196.88,56.45 196.88,47.92 v3(196.6,47.64)
BOARD_ID: length 4.4
  TOP w0.114: UE1.69 184.56,55.27 184.02,54.73 v2(183.32,54.73) 183.2,54.84 RE3.1 RE7.1
BQ24780_BATDRV: length 43.1
  IN1 w0.254: v3(177.6,175.58) 177.93,175.25 179.93,175.25 180.8,176.11 186.25,176.11 189.03,178.9 191.35,178.9 193.29,180.84 210.55,180.84 211.28,181.57 v3(212.17,181.57) 214.59,181.57 v3(214.74,181.42)
  BOTTOM w0.203: v4(177.17,176.6) 177.6,176.16 v3(177.6,175.58) 177.6,175.53 177.6,175.52 177.6,174.96 177.29,174.66 PU101.18
BQ24780_VDD: length 1.4
  BOTTOM w0.114: v4(181.84,174.23) 181.84,172.89 PC116.1
BT_ON: length 277.4
  TOP w0.114: v3(150.55,69.38) 150.45,69.48 v4(150.45,70.25) ; RPC9.4 148.41,91.19 148.11,90.9 147.58,90.9 v3(147.38,91.1)
  IN1 w0.076: 111.95,80.25 111.02,81.18 111.02,82.07 108.73,84.36 107.25,84.36 106.86,84.75 106.41,84.75 106.18,84.98 106.18,86.64 v3(106.57,87.02)
  IN1 w0.14: v3(150.55,69.38) 150.55,68.77 149.99,68.21 147.68,68.21 146.31,69.59 134.91,69.59 134.2,70.29 130.26,70.29 129.01,71.54 129.01,73.17 126.98,75.2 125.35,75.2 123.49,77.06 118.46,77.06 117.95,77.56 117.68,77.56 114.99,80.25 111.95,80.25
  IN2 w0.14: v3(240.7,170.88) 241.48,171.67 243.44,171.67 243.87,172.1 v3(248.21,172.1)
  IN3 w0.114: v3(248.21,172.1) 248.34,172.1 249.79,170.65 249.79,161.91 248.98,161.1 248.98,147.22 238.6,136.84 231.15,136.84 227,132.69 227,130.92 220.57,124.48 220.57,109 207.98,96.41 207.98,94.99 207.42,94.43 202.71,94.43 193.93,103.2 177.45,103.2 176.54,102.29 173.74,102.29 163.77,92.31 163.77,76.11 156.73,69.08 150.86,69.08 v3(150.55,69.38)
  BOTTOM w0.076: UC1.AP5 106.95,87.4 v3(106.57,87.02)
  BOTTOM w0.114: R239.2 240.59,170.98 v3(240.7,170.88) ; v3(147.38,91.1) 147.83,90.64 148.67,90.64 149.19,90.13 149.19,89.42 148.8,89.03 148.8,85.23 149.27,84.76 149.27,82.37 148.39,81.5 148.39,78.6 150.32,76.67 150.32,72.15 150.76,71.72 150.76,69.59 v3(150.55,69.38)
BT_ON_R: length 16
  IN2 w0.14: v3(247.96,169.92) 246.89,168.85 239.55,168.85 v3(239.32,168.62)
  BOTTOM w0.114: JWLBT.54 248.2,170.15 v3(247.96,169.92) ; R151.2 R239.1 v4(239.12,169.71) 239.12,168.82 v3(239.32,168.62) 240.09,167.86 R90.1
BYPASS_PAD: length 6
  TOP w0.114: R105.2 31.71,104.46 31.8,104.37 R61.2 31.8,103.21 R66.2 32.16,103.16 33.16,102.17 v4(33.16,101.72) 33.41,101.48 33.41,101.13 33.84,100.7 34.54,100.7 JCP.12
CEC: length 2.4
  TOP w0.084: TPV16.1 145.07,139.38 v1(145.68,139.99)
  BOTTOM w0.084: v1(145.68,139.99) 146.11,139.56 UV1.AC30
CFG0: length 12.4
  BOTTOM w0.076: TC30.1 67.49,109.29 67.49,107.65 68.93,106.21 71.38,106.21 71.75,105.85 71.75,105.49 71.9,105.34 71.9,105.19 71.9,105.19 71.9,104.83 71.87,104.73 71.87,104.59 71.88,104.5 71.9,104.42 71.9,104.36 71.9,104.25 71.9,104.24 71.9,104.2 71.85,104.05 71.8,103.87 71.76,103.61 71.69,103.34 UC1.E68
  BOTTOM w0.114: RC201.2 66.88,110.53 RC105.2 66.83,109.95 TC30.1
CFG1: length 12.4
  BOTTOM w0.076: 66.11,108.26 66.89,107.48 67.23,107.48 68.94,105.78 70.42,105.78 70.94,105.26 70.94,105.26 71.11,105.09 71.11,104.85 71.47,104.5 UC1.B67
  BOTTOM w0.114: 66.11,108.26 66.11,110.13 65.59,110.66 65.59,111.65 66.38,112.43 TC43.1
CFG1_DP: length 4.2
  TOP w0.381: RVG132.2 27.39,93.51 RVG134.1 28.25,92.9 v4(27.62,92.27) 27.97,91.91 28.2,91.91 28.58,91.53 UVG2.12
CFG2: length 9.1
  BOTTOM w0.076: UC1.D65 72.6,103.34 72.53,103.61 72.53,103.72 72.39,104.2 72.39,104.45 72.42,104.54 72.42,104.73 72.39,104.83 72.39,105.19 72.56,105.36 72.56,105.79 71.99,106.37 68.99,106.37 68,107.36 TC44.1
CFG2_DP: length 4.5
  TOP w0.305: RVG133.2 26.47,92.9 v4(25.86,92.29) 26.24,91.91 26.73,91.91 27.08,91.56 UVG2.15
  TOP w0.381: RVG133.2 26.45,93.51 RVG135.1
CFG3: length 8.3
  BOTTOM w0.076: TC33.1 66.73,108.2 68.89,106.03 71.33,106.03 71.59,105.78 71.59,105.42 71.74,105.27 71.74,104.86 71.68,104.74 71.68,104.59 71.74,104.4 71.74,104.23 71.65,103.97 UC1.D67
CFG4: length 10.3
  TOP w0.114: RC104.2 67.52,110.73 RC144.2 66.78,110 TC34.1 66.78,108.83 67.16,108.45 v3(67.16,105.32)
  BOTTOM w0.076: UC1.E70 69.43,102.66 69.23,102.86 68.9,102.86 68.71,103.05 68.64,103.05 67.32,104.37 67.32,105.17 v3(67.16,105.32)
CFG5: length 9.4
  TOP w0.114: v3(66.52,105.31) 65.84,105.98 65.84,106.49 65.64,106.69 65.64,108.64 TC35.1
  IN1 w0.14: v3(70.24,103.82) 69.73,104.33 68.1,104.33 67.52,104.92 66.91,104.92 v3(66.52,105.31)
  BOTTOM w0.076: UC1.C68 v3(70.24,103.82)
CFG6: length 15.2
  TOP w0.114: TC36.1 64.09,113.86 64.09,108.96 64.76,108.28 64.76,106.79 65.33,106.22 65.33,104.99 65.69,104.64 v3(66.38,104.64)
  IN1 w0.14: v3(66.38,104.64) 67.47,104.64 68.31,103.8 68.94,103.8 v3(69.59,103.15)
  BOTTOM w0.076: UC1.D68 v3(69.59,103.15)
CFG7: length 10.4
  TOP w0.114: TC47.1 65.14,109.96 66.17,108.93 66.17,106.42 v3(66.66,105.93)
  IN1 w0.14: v3(70.86,104.46) 69.39,105.93 v3(66.66,105.93)
  BOTTOM w0.076: UC1.C67 v3(70.86,104.46)
CFG8: length 13.4
  BOTTOM w0.076: 64.77,106.67 65.28,106.16 65.28,104.95 68.14,102.1 69.44,102.1 UC1.F71
  BOTTOM w0.114: 64.77,106.67 61.75,109.69 61.23,109.69 60.51,110.41 TC48.1
CFG9: length 16.4
  BOTTOM w0.076: UC1.G69 70.25,101.21 70,101.21 69.78,101.13 69.65,101.13 69.42,101.2 69.28,101.2 69.16,101.14 68.9,101.14 68.62,101.42 67.78,101.42 64.57,104.63
  BOTTOM w0.114: TC39.1 58.63,108.72 61.35,108.72 64.4,105.68 64.4,104.8 64.57,104.63
CFG10: length 21.3
  BOTTOM w0.076: UC1.F70 69.83,102.3 69.23,102.3 69.21,102.28 68.17,102.28 65.46,104.99 65.46,106.32 64.95,106.84
  BOTTOM w0.114: 64.95,106.84 61.74,110.05 61.74,110.62 61.04,111.32 55.17,111.32 TC49.1
CFG11: length 20.8
  BOTTOM w0.076: UC1.G68 70.47,101.58 70.4,101.6 69.93,101.6 69.86,101.68 69.6,101.68 69.04,101.92 68.1,101.92 65.08,104.94 65.08,106.02 64.6,106.5
  BOTTOM w0.114: 64.6,106.5 61.65,109.45 61.13,109.45 60.47,110.11 60.38,110.11 59.41,111.08 57.03,111.08 56.01,110.06 TC40.1
CFG12: length 14.1
  TOP w0.114: v3(63.68,105.53) 63.3,105.91 63.3,107.43 62.16,108.57 TC41.1
  BOTTOM w0.076: UC1.H70 69.8,100.51 69.57,100.51 69.44,100.46 69.33,100.46 69.19,100.51 68.61,100.51 68.54,100.44 68.12,100.44 67.7,100.86 67.62,100.86 64.57,103.9
  BOTTOM w0.114: 64.57,103.9 64.32,104.15 64.27,104.15 64.01,104.41 63.59,104.41 63.48,104.52 63.48,105.32 v3(63.68,105.53)
CFG13: length 14.4
  BOTTOM w0.076: 64.57,105.84 64.6,105.82 64.6,104.94 67.95,101.59 68.88,101.59 UC1.G71
  BOTTOM w0.114: 64.57,105.84 61.45,108.97 60.93,108.97 60.27,109.62 60.14,109.62 59.37,110.4 TC42.1
CFG14: length 15.4
  TOP w0.114: TC52.1 62.84,110.43 62.84,108.25 63.56,107.54 63.56,106.29 64.13,105.72 64.13,105.14 v3(63.93,104.93)
  BOTTOM w0.076: 64.57,104.28 67.63,101.23 68.54,101.23 68.79,100.98 69.2,100.98 69.31,101.02 69.43,101.02 69.65,100.96 69.79,100.96 69.95,101.02 70.41,101.02 UC1.H69
  BOTTOM w0.114: 64.57,104.28 v3(63.93,104.93)
CFG15: length 17.4
  BOTTOM w0.076: 64.57,106.19 64.85,105.91 64.85,104.96 68.06,101.75 69,101.75 69.42,101.55 69.56,101.41 UC1.G70
  BOTTOM w0.114: TC54.1 57.56,110.83 59.31,110.83 60.28,109.87 60.37,109.87 61.03,109.21 61.55,109.21 64.57,106.19
CFG16: length 18.8
  TOP w0.114: v3(65.87,105.17) 65.59,105.45 65.59,106.36 65,106.95 65,108.38 64.45,108.94 64.45,112.37 TC57.1
  IN1 w0.14: v3(73.55,102.47) 73.55,102.74 72.07,104.21 71.83,104.21 69.65,106.39 66.4,106.39 65.87,105.86 v3(65.87,105.17)
  BOTTOM w0.076: UC1.E63 v3(73.55,102.47)
CFG17: length 11.5
  TOP w0.114: TC59.1 71.94,111.24 72.57,110.61 72.57,108.29 v3(72.73,108.14)
  IN1 w0.14: v3(72.73,108.14) 72.39,107.81 72.39,106.64 72.83,106.2 72.83,103.88 73.97,102.75 73.97,102.25 v3(73.55,101.83)
  BOTTOM w0.076: UC1.F63 v3(73.55,101.83)
CFG18: length 19.3
  TOP w0.114: v3(66.83,104.18) 65.79,104.18 65.09,104.88 65.09,106.12 64.52,106.69 64.52,108.08 63.85,108.75 63.85,115.13 TC61.1
  IN1 w0.14: v3(71.51,102.47) 71.22,102.17 69.92,102.17 68.63,103.46 68.32,103.46 67.6,104.18 v3(66.83,104.18)
  BOTTOM w0.101: UC1.E66 v3(71.51,102.47)
CFG19: length 20
  TOP w0.076: v3(67.32,103.72) 66.97,103.72
  TOP w0.114: 66.97,103.72 65.87,103.72 64.85,104.74 64.85,106.02 64.28,106.59 64.28,107.98 63.61,108.65 63.61,113.97 TC63.1
  IN1 w0.14: v3(71.51,101.83) 69.84,101.83 68.56,103.11 67.93,103.11 v3(67.32,103.72)
  BOTTOM w0.101: UC1.F66 v3(71.51,101.83)
CFG_RCOMP: length 9.9
  TOP w0.254: v3(73.84,107.71) 73.29,108.27 73.29,108.52 72.89,108.92 72.89,110.39 RC152.1
  IN1 w0.254: v3(73.84,107.71) 73.87,107.71 75.6,105.98 75.6,102.58 v3(75.48,102.47)
  BOTTOM w0.254: v3(75.48,102.47) 75.56,102.43 UC1.E60
CHG: length 74.5
  IN1 w0.254: v3(176.89,175.45) 177.48,174.87 180.09,174.87 180.96,175.73 186.41,175.73 189.19,178.52 191.51,178.52 193.45,180.46 211.08,180.46 v3(212.17,179.36)
  IN3 w0.254: v3(182.63,175.07) 182.86,175.3 182.86,176.42 185.32,178.88 192.86,178.88 193.17,179.19 208.26,179.19 v3(208.49,179.41)
  BOTTOM w0.114: v4(213.19,178.65) 213.24,178.65 213.26,178.68
  BOTTOM w0.203: v3(176.89,175.45) PU101.17
  BOTTOM w0.254: v3(208.49,179.41) 208.92,178.98 PR117.1 ; v3(182.63,175.07) 182.87,175.32 182.87,176.43 182.75,176.56 182.43,176.56 PC124.1 181.91,176.57 181.53,176.57 PC122.1 181.11,176.51 180.71,176.51 PR125.1
CL_CLK_WLAN: length 205.6
  IN3 w0.114: v3(112.07,102.86) 112.71,102.22 116.24,102.22 117.33,101.13 117.61,101.13 118.29,100.45 119.84,100.45 120.25,100.04 125.43,100.04 126.63,98.85 126.63,95.19 127.07,94.74 130.85,94.74 131.59,94.01 133.89,94.01 136.28,96.4 147.31,96.4 147.96,95.75 149.05,95.75 149.37,96.06 149.85,96.06 154.54,100.75 159.95,100.75 164.19,104.99 169.54,104.99 172.39,107.85 215.26,107.85 217.02,109.62 217.02,127.82 222.23,133.02 223.29,133.02 231.99,141.72 233.58,141.72 234.07,142.2 235.13,142.2 235.39,142.46 235.39,145.23 237.75,147.59 238.74,147.59 244.81,153.66 244.81,155.69 243.8,156.71 243.8,161.23 245.31,162.74 245.31,165.89 244.66,166.54 244.66,172.05 v3(246.03,173.42)
  BOTTOM w0.076: UC1.G3 108.59,101.45 108.85,101.72 109.14,101.72 109.55,101.88 111.1,101.88 v3(112.07,102.86)
  BOTTOM w0.114: v3(246.03,173.42) 246.44,173.01 246.92,173.01 247.06,173.15 JWLBT.42
CL_DATA_WLAN: length 220
  TOP w0.114: v1(213.54,135.87) 211.96,134.28 204.59,134.28 201.61,131.29 200.91,131.29 198.11,128.5 198.11,125.2 198.68,124.63 198.68,122.59 196.4,120.31 194.18,120.31 191.7,117.83 191.7,109.96 191.13,109.39 190.55,109.39 188.26,111.67 186.56,111.67 184.08,109.2 176.71,109.2 175.82,110.09 172.84,110.09 171.57,108.82 166.13,108.82 163.02,105.7 158.68,105.7 155.99,103.01 v1(154.11,103.01)
  IN1 w0.14: v3(112.78,102.91) 112.91,102.91 118.22,108.22 120.86,108.22 122.17,109.53 122.17,112.79 121.94,113.02 121.94,114.87 122.17,115.1 131.17,115.1 132.14,116.08 134.52,116.08 137.69,112.91 150.08,112.91 151.11,111.88 151.11,106.25 154.11,103.26 v1(154.11,103.01) ; v3(231.01,139.8) 231.01,141.76 239.27,150.03 239.27,159.68 242.6,163.01 242.6,165.95 v3(243.54,166.89)
  IN2 w0.14: v3(246.74,173.47) 245.65,172.38 243.74,172.38 243.31,171.95 241.08,171.95 v3(240.67,171.54)
  IN3 w0.114: v3(246.74,173.47) 246.34,173.88 245.69,173.88 244.25,172.44 244.25,167.6 v3(243.54,166.89)
  BOTTOM w0.076: UC1.G2 109.18,101.45 109.32,101.59 109.61,101.73 111.6,101.73 111.66,101.79
  BOTTOM w0.102: 111.66,101.79 v3(112.78,102.91)
  BOTTOM w0.114: v3(240.67,171.54) 240.34,171.87 R151.1 ; JWLBT.40 246.92,173.65 v3(246.74,173.47) ; v3(231.01,139.8) 225.61,134.41 218.94,134.41 218.5,134.85 v2(214.56,134.85) v1(213.54,135.87)
CL_RST_WLAN#: length 203.8
  TOP w0.114: v3(240.67,172.76) 240.67,172.2 240.16,171.69 240.16,170.47 238.85,169.17 238.85,166.47 v4(240.04,165.29) v3(240.04,164.61)
  IN1 w0.14: v3(151.59,100.27) 146.41,100.27 144.15,98.01 128.25,98.01 122.51,103.75 122.51,106.42 121.14,107.79 118.12,107.79 113.49,103.16 v3(113.49,102.88) ; v3(216.08,110.12) 215.75,110.45 215.75,115.66 223.54,123.45 223.54,134.62 227.75,138.83 227.75,140.48 237.94,150.67 237.94,160.23 239.96,162.25 239.96,164.53 v3(240.04,164.61)
  IN2 w0.14: v3(248.24,174.15) 245.04,174.15 243.92,173.04 240.95,173.04 v3(240.67,172.76)
  IN3 w0.114: v3(216.08,110.12) 214.42,108.46 172.14,108.46 169.28,105.6 163.94,105.6 159.78,101.45 154.17,101.45 152.99,100.27 v3(151.59,100.27)
  BOTTOM w0.076: v3(113.49,102.88) 113.36,102.88 112.06,101.58 109.81,101.58 UC1.G1
  BOTTOM w0.114: R152.1 v3(240.67,172.76) ; JWLBT.38 v3(248.24,174.15)
CLK_PCI_EC: length 115.6
  TOP w0.114: UE1.13 202.6,49.27 202.85,49.52 v5(203,49.52) RE38.2 ; RC24.2 108.95,68.37 108.95,67.45 108.21,66.71 108.21,66.13 108.9,65.44 110.14,65.44 112.27,67.58 112.73,67.58 113.72,68.57 115.88,68.57 116.49,67.96 119.06,67.96 119.91,67.11 120.47,67.11 120.78,66.79 v3(120.96,66.79)
  IN3 w0.114: v3(120.96,66.79) 121.16,66.79 122.08,65.88 122.08,64.99 122.9,64.16 123.66,64.16 124.01,63.82 126.21,63.82 127.95,62.08 134.74,62.08 138.04,58.78 140.95,58.78 154.98,44.74 v1(176.59,44.74)
  BOTTOM w0.114: v5(203,49.52) 202.75,49.27 196.78,49.27 193.45,45.94 188.27,45.94 186.95,47.26 179.1,47.26 v1(176.59,44.74)
CLK_PCIE_CR: length 164.9
  TOP w0.114: UW1.5 49.89,33.92 49.8,34.01 49.8,34.38 50.74,35.32 50.74,37.02 50.43,37.33 50.22,37.33 v5(49.97,37.58)
  IN3 w0.076: 83.16,104.56 83.16,104.54 83.16,104.54 83.16,100.97 83.62,100.52 87.59,100.52 87.9,100.83 87.9,101.68 87.9,101.68 87.9,102.06 87.73,102.23 87.6,102.23 87.37,102.47 v3(87.36,102.47)
  IN3 w0.114: 83.16,104.56 83.16,104.7 82.99,104.87 82.01,104.87 81.41,105.47 81.41,112.12 79.96,113.57 70.58,113.57 70.39,113.76 65.66,113.76 64.84,114.57 59.6,114.57 59.02,115.15 55.65,115.15 50.43,109.93 50.43,109.47 34.55,93.6 34.55,89.49 28.58,83.52 28.58,79.84 26.61,77.86 26.61,70.33 28.47,68.47 30.5,68.47 32.59,66.37 32.59,65.28 33.2,64.67 33.2,55.35 31.3,53.44 31.3,39.5 34.26,36.54 45.92,36.54 46.66,37.28 49.64,37.28 49.94,37.58 v5(49.97,37.58)
  BOTTOM w0.076: v3(87.36,102.47) 87.59,102.24 UC1.E38
CLK_PCIE_CR#: length 164.9
  TOP w0.114: v3(49.94,36.87) 50.18,37.1 50.34,37.1 50.51,36.93 50.51,36.3 v3(50.48,36.26) 50.51,36.22 50.51,35.37 49.61,34.46 49.61,33.94 49.49,33.83 UW1.6
  IN3 w0.076: v3(87.36,101.83) 87.36,101.93 87.51,102.07 87.66,102.07 87.74,101.99 87.74,101.61 87.74,101.61 87.74,100.9 87.52,100.68 83.69,100.68 83.33,101.04 83.33,104.47 83.36,104.51 83.36,104.53
  IN3 w0.114: v3(49.94,36.87) 49.74,37.07 46.74,37.07 46.01,36.34 34.18,36.34 31.1,39.42 31.1,53.53 33,55.43 33,64.58 32.39,65.19 32.39,66.29 30.42,68.26 28.38,68.26 26.4,70.25 26.4,77.95 28.38,79.92 28.38,83.61 34.35,89.58 34.35,93.68 50.22,109.56 50.22,110.02 55.56,115.36 59.11,115.36 59.69,114.77 64.93,114.77 65.74,113.96 70.48,113.96 70.67,113.77 80.05,113.77 81.62,112.2 81.62,105.55 82.1,105.07 83.08,105.07 83.36,104.78 83.36,104.53
  BOTTOM w0.076: UC1.E40 87.06,102.24 87.36,101.94 v3(87.36,101.83)
CLK_PCIE_LAN: length 55.4
  TOP w0.114: UL1.44 51.24,118.15 51.34,118.25 53.61,118.25 55.05,116.81 55.05,115.95 55.45,115.54 55.45,113.22 v3(55.43,113.2) 55.45,113.17 55.45,111.4 56.06,110.79 56.06,109.24 56.64,108.66 56.64,108.44 v3(56.47,108.27)
  IN1 w0.14: v3(56.47,108.27) 56.48,108.27 57.64,108.27 58.22,108.85 58.22,109.38 60.23,111.39 68.72,111.39 68.92,111.6 71.48,111.6 71.78,111.29 74.74,111.29 75.5,112.05 78.7,112.05 78.85,111.9 79.27,111.9 79.42,112.05 79.69,112.05 80.07,112.43 81.11,112.43 81.26,112.28 81.68,112.28 81.83,112.43 82.25,112.43 82.4,112.28 82.82,112.28 82.97,112.43 83.94,112.43 84.09,112.28 v3(84.09,112.23)
  BOTTOM w0.076: 86.43,106.78 86.43,106.74 86.46,106.72 86.46,105.27 86.6,105.13 86.6,104.86 86.55,104.74 86.55,104.59 86.6,104.4 86.6,104.23 86.52,103.97 UC1.C40
  BOTTOM w0.114: v3(84.09,112.23) 84.12,112.23 84.55,112.66 84.72,112.66 84.88,112.51 84.88,111.18 86.57,109.49 86.57,107.2 86.43,107.07 86.43,106.78
