# Allegro board Lenovo ThinkPad E460 E560 BE560 NM-A561 boardview.brd (continued)
## Nets (continued)
GND: AOU1.14(GND) AOU1.17(GND_PAD) C1.2 C8.2 C9.2 C10.2 C11.2 C12.2 C19.2 C20.2 C21.2 C22.2 C23.2 C44.2 C45.2 C50.2 C51.2 C52.2 C69.2 C70.2 C71.2 C72.2 C73.2 C74.2 C75.2 C115.2 C116.2 C119.2 C122.2 C123.2 C131.2 C132.2 C171.2 C172.2 C202.2 C203.2 C204.2 C205.2 C747.1 C749.1 C750.2 C751.2 C8496.2 C8497.2 C8498.2 C8499.2 C8528.2 C8531.2 C8532.2 C8533.1 C8534.2 C8536.2 C8537.2 C8540.2 C8541.2 C8542.2 C8543.2 C8544.2 C8545.2 CA1.2 CA2.2 CA3.2 CA4.2 CA5.2 CA6.1 CA7.2 CA12.2 CA13.2 CA14.2 CA15.2 CA18.2 CA19.1 CA25.1 CA26.1 CA27.1 CA28.1 CA40.2 CA42.2 CA43.2 CC1.2 CC2.2 CC3.2 CC4.2 CC5.2 CC6.2 CC7.2 CC9.2 CC22.2 CC25.2 CC26.2 CC46.2 CC47.2 CC49.2 CC50.2 CC52.2 CC58.2 CC59.2 CC60.2 CC61.2 CC68.2 CC69.2 CC70.2 CC94.2 CC95.2 CC96.2 CC97.2 CC99.2 CC102.2 CC104.2 CC105.2 CC106.2 CC107.2 CC108.2 CC109.2 CC123.2 CC129.2 CC130.2 CC131.2 CC133.2 CC136.2 CC137.2 CC138.2 CC139.2 CC140.2 CC141.2 CC142.2 CC143.2 CC144.2 CC145.2 CC146.2 CC147.2 CC148.2 CC149.2 CC150.2 CC151.2 CC152.2 CC153.2 CC154.2 CC155.2 CC156.2 CC157.2 CC158.2 CC159.2 CC160.2 CC161.2 CC170.2 CC171.2 CC172.2 CC173.2 CC174.2 CC175.2 CC176.2 CC177.2 CC178.2 CC179.2 CC190.2 CC191.2 CC192.2 CC193.2 CC194.2 CC195.2 CC196.2 CC197.2 CC198.2 CC199.2 CC200.2 CC201.2 CC202.2 CC203.2 CC204.2 CC205.2 CC206.2 CC207.2 CC208.2 CC209.2 CC218.2 CC221.2 CC222.2 CC223.2 CC224.2 CC225.2 CC226.2 CC227.2 CC228.2 CC229.2 CC230.2 CC231.2 CC232.2 CC233.2 CC234.2 CC235.2 CC236.2 CC237.2 CC239.2 CC241.2 CC244.2 CC245.2 CC247.2 CC249.2 CC250.2 CC251.2 CC252.2 CC253.2 CC254.2 CC255.2 CC256.2 CC257.2 CC258.2 CC259.2 CC260.2 CC261.2 CC262.2 CC263.2 CC264.2 CC271.2 CC272.2 CC273.2 CC274.2 CD1.2 CD3.2 CD8.2 CD9.2 CD10.2 CD11.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD29.2 CD30.2 CD32.2 CD33.2 CD38.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD44.2 CD45.2 CD46.2 CD47.2 CD48.2 CD49.2 CD51.2 CD52.2 CD53.2 CD54.2 CD55.2 CD56.2 CD57.2 CD58.2 CD59.2 CD60.2 CE1.2 CE4.2 CE5.2 CE6.2 CE7.1 CE8.2 CE9.2 CE10.2 CE11.2 CE12.2 CE13.1 CE14.2 CE15.1 CE16.2 CE17.2 CG3.2 CG4.2 CG5.2 CG6.2 CL3.2 CL4.2 CL5.2 CL6.1 CL7.2 CL8.2 CL9.2 CL11.2 CL12.2 CL13.2 CL17.2 CRF1.2 CRF2.2 CRF3.2 CRF4.2 CRF5.2 CRF6.2 CRF7.2 CRF8.2 CRF9.2 CRF10.2 CRF11.2 CRF12.2 CRF13.2 CRF14.2 CRF15.2 CRF16.2 CRF17.2 CRF18.2 CRF21.2 CRF22.2 CT24.2 CT25.2 CT26.2 CT27.2 CT28.2 CT29.2 CT31.1 CV17.2 CV18.2 CV19.2 CV20.2 CV21.2 CV22.2 CV23.2 CV24.2 CV25.2 CV26.2 CV27.2 CV28.2 CV29.2 CV30.2 CV31.2 CV32.2 CV33.2 CV34.2 CV35.2 CV36.2 CV37.2 CV38.2 CV39.2 CV40.2 CV41.2 CV42.2 CV43.2 CV44.2 CV45.2 CV46.2 CV47.2 CV48.2 CV49.2 CV50.2 CV51.2 CV52.2 CV53.2 CV54.2 CV55.2 CV56.2 CV57.2 CV58.2 CV59.2 CV60.2 CV61.2 CV62.2 CV63.2 CV64.2 CV65.2 CV66.2 CV67.2 CV68.2 CV69.2 CV70.2 CV71.2 CV72.2 CV73.2 CV74.2 CV75.2 CV76.2 CV77.2 CV78.2 CV79.2 CV80.2 CV83.2 CV84.2 CV85.2 CV86.2 CV87.2 CV88.2 CV96.2 CV97.2 CV98.2 CV99.2 CV100.2 CV106.2 CV107.2 CV111.2 CV112.2 CV113.2 CV114.2 CV115.2 CV116.2 CV117.2 CV118.2 CV119.2 CV120.2 CV121.2 CV122.2 CV123.2 CV124.2 CV125.2 CV126.2 CV127.2 CV128.2 CV129.2 CV130.2 CV131.2 CV132.2 CV133.2 CV134.2 CV137.2 CV138.2 CV139.2 CV140.2 CV141.2 CV142.2 CV150.2 CV151.2 CV152.2 CV153.2 CV154.2 CV160.2 CV161.2 CV163.2 CV165.2 CV166.2 CV167.2 CV168.2 CV169.2 CV170.2 CV177.2 CV178.2 CV179.2 CV180.2 CV181.2 CV187.2 CV205.2 CV206.2 CV207.2 CV208.2 CV209.2 CV210.2 CV211.2 CV212.2 CV213.2 CV214.2 CV215.2 CV216.2 CV217.2 CV218.2 CV219.2 CV220.2 CV221.2 CV222.2 CV223.2 CV224.2 CV225.2 CV226.2 CV227.2 CV228.2 CV229.2 CV232.2 CV233.2 CV236.2 CV237.2 CV238.2 CV239.2 CV240.2 CV241.2 CVG32.2 CVG33.2 CVG34.2 CVG35.2 CVG36.2 CVG37.2 CVG38.2 CVG39.2 CVG40.2 CVG41.2 CVG42.2 CVG43.1 CVG44.2 CW1.2 CW2.2 CW3.2 CW4.2 CW5.2 CW6.2 CW7.2 CW8.2 CW11.2 CW12.2 CW13.2 CW14.2 CX2.1 CX11.2 CX12.2 CX13.2 CX14.2 D1.1 D4.1 D7.2(VN) D8.3(GND) D12.3(GND) D13.3(GND) D14.3(GND) D16.3(GND) D17.2(VN) DL1.3(GND) DL2.3(GND) DT1.2(VN) DT2.2(VN) H1.1 H2.1 H3.1 H4.1 H5.1 H6.1 H8.1 H9.1 H10.1 H11.1 H12.1 H13.1 H14.1 H15.1 H16.1 H17.1 H18.1 H19.1 H20.1 H22.1 H23.1 H24.1 H25.1 H27.1 H28.1 IT3.1 IT4.1 IT5.1 J1.1 JAUF.13(GND1) JAUF.14(GND2) JBATT1.6 JBATT1.7 JBATT1.8(G1) JBATT1.9(G2) JCMOS1.2 JCP.1 JCP.13(GND1) JCP.14(GND2) JCRT.5 JCRT.6 JCRT.7 JCRT.8 JCRT.16(GND1) JCRT.17(GND2) JDCIN1.5 JDCIN1.6 JDCIN1.7 JDCIN1.8(GND1) JDCIN1.9(GND2) JDIMM1.2(VSS1) JDIMM1.3(VSS2) JDIMM1.8(VSS3) JDIMM1.9(VSS4) JDIMM1.11(DM0) JDIMM1.13(VSS5) JDIMM1.14(VSS6) JDIMM1.19(VSS7) JDIMM1.20(VSS8) JDIMM1.25(VSS9) JDIMM1.26(VSS10) JDIMM1.28(DM1) JDIMM1.31(VSS11) JDIMM1.32(VSS12) JDIMM1.37(VSS13) JDIMM1.38(VSS14) JDIMM1.43(VSS15) JDIMM1.44(VSS16) JDIMM1.46(DM2) JDIMM1.48(VSS17) JDIMM1.49(VSS18) JDIMM1.54(VSS19) JDIMM1.55(VSS20) JDIMM1.60(VSS21) JDIMM1.61(VSS22) JDIMM1.63(DM3) JDIMM1.65(VSS23) JDIMM1.66(VSS24) JDIMM1.71(VSS25) JDIMM1.72(VSS26) JDIMM1.127(VSS27) JDIMM1.128(VSS28) JDIMM1.133(VSS29) JDIMM1.134(VSS30) JDIMM1.136(DM4) JDIMM1.138(VSS31) JDIMM1.139(VSS32) JDIMM1.144(VSS33) JDIMM1.145(VSS34) JDIMM1.150(VSS35) JDIMM1.151(VSS36) JDIMM1.153(DM5) JDIMM1.155(VSS37) JDIMM1.156(VSS38) JDIMM1.161(VSS39) JDIMM1.162(VSS40) JDIMM1.167(VSS41) JDIMM1.168(VSS42) JDIMM1.170(DM6) JDIMM1.172(VSS43) JDIMM1.173(VSS44) JDIMM1.178(VSS45) JDIMM1.179(VSS46) JDIMM1.184(VSS47) JDIMM1.185(VSS48) JDIMM1.187(DM7) JDIMM1.189(VSS49) JDIMM1.190(VSS50) JDIMM1.195(VSS51) JDIMM1.196(VSS52) JDIMM1.205(G1) JDIMM1.206(G2) JDIMM2.2(VSS_2) JDIMM2.3(VSS_1) JDIMM2.8(VSS_4) JDIMM2.9(VSS_3) JDIMM2.11(DM0) JDIMM2.13(VSS_5) JDIMM2.14(VSS_6) JDIMM2.19(VSS_7) JDIMM2.20(VSS_8) JDIMM2.25(VSS_9) JDIMM2.26(VSS_10) JDIMM2.28(DM1) JDIMM2.31(VSS_11) JDIMM2.32(VSS_12) JDIMM2.37(VSS_13) JDIMM2.38(VSS_14) JDIMM2.43(VSS_15) JDIMM2.44(VSS_16) JDIMM2.46(DM2) JDIMM2.48(VSS_18) JDIMM2.49(VSS_17) JDIMM2.54(VSS_20) JDIMM2.55(VSS_19) JDIMM2.60(VSS_22) JDIMM2.61(VSS_21) JDIMM2.63(DM3) JDIMM2.65(VSS_23) JDIMM2.66(VSS_24) JDIMM2.71(VSS_25) JDIMM2.72(VSS_26) JDIMM2.127(VSS_27) JDIMM2.128(VSS_28) JDIMM2.133(VSS_29) JDIMM2.134(VSS_30) JDIMM2.136(DM4) JDIMM2.138(VSS_32) JDIMM2.139(VSS_31) JDIMM2.144(VSS_34) JDIMM2.145(VSS_33) JDIMM2.150(VSS_35) JDIMM2.151(VSS_36) JDIMM2.153(DM5) JDIMM2.155(VSS_37) JDIMM2.156(VSS_38) JDIMM2.161(VSS_39) JDIMM2.162(VSS_40) JDIMM2.167(VSS_41) JDIMM2.168(VSS_42) JDIMM2.170(DM6) JDIMM2.172(VSS_44) JDIMM2.173(VSS_43) JDIMM2.178(VSS_46) JDIMM2.179(VSS_45) JDIMM2.184(VSS_48) JDIMM2.185(VSS_47) JDIMM2.187(DM7) JDIMM2.189(VSS_49) JDIMM2.190(VSS_50) JDIMM2.195(VSS_51) JDIMM2.196(VSS_52) JDIMM2.205(GND1) JDIMM2.206(GND2) JFAN.2 JFAN.6(G1) JFAN.7(G2) JFPB.4 JFPB.5 JFPB.7(GND1) JFPB.8(GND2) JHDD.1(GND1) JHDD.4(GND2) JHDD.7(GND3) JHDD.11(GND4) JHDD.13(GND6) JHDD.17(GND7) JHDD.18(RESERVED) JHDD.19(GND8) JHDD.23(GND9) JHDD.24(GND10) JHDMI.2(D2_SHIELD) JHDMI.5(D1_SHIELD) JHDMI.8(D0_SHIELD) JHDMI.11(CK_SHIELD) JHDMI.17(DDC/CEC_GND) JHDMI.20(GND1) JHDMI.21(GND2) JHDMI.22(GND3) JHDMI.23(GND4) JKB.30 JKB.33(GND1) JKB.34(GND2) JLCD.13 JLCD.16 JLCD.19 JLCD.24 JLCD.27 JLCD.30 JLCD.31 JLCD.34 JLCD.37 JLCD.41(GND1) JLCD.42(GND2) JLCD.43(GND3) JLCD.44(GND4) JME1.2 JODD.1 JODD.4 JODD.7 JODD.12 JODD.13 JODD.14(GND1) JODD.15(GND2) JREAD2.3(VSS1) JREAD2.6(VSS2) JREAD2.12(GND1) JREAD2.13(GND2) JRTC.2 JRTC.3(GND1) JRTC.4(GND2) JSPK.5(GND1) JSPK.6(GND2) JTOUCH.3 JTOUCH.6 JTOUCH.10 JTOUCH.11(GND1) JTOUCH.12(GND2) JTP.7 JTP.13(GND1) JTP.14(GND2) JU3LC.3 JU3LC.6 JU3LC.9 JU3LC.12 JU3LC.15 JU3LC.18 JU3LC.21(G1) JU3LC.22(G2) JU3LC.23(G3) JU3LC.24(G4) JU3LF.1 JU3LF.4 JU3LF.7 JU3LF.21 JU3LF.24 JU3LF.27(GND1) JU3LF.28(GND2) JUSB1.4(GND_5) JUSB1.7(GND_DRAIN) JUSB1.10(GND_1) JUSB1.11(GND_2) JUSB1.12(GND_3) JUSB1.13(GND_4) JUSB2.4(GND_5) JUSB2.7(GND_DRAIN) JUSB2.10(GND_1) JUSB2.11(GND_2) JUSB2.12(GND_3) JUSB2.13(GND_4) JWLBT.1(GND1) JWLBT.7(GND2) JWLBT.18(GND16) JWLBT.23(GND3) JWLBT.24(GND13) JWLBT.29(GND4) JWLBT.30(GND14) JWLBT.33(GND5) JWLBT.36(GND15) JWLBT.39(GND6) JWLBT.45(GND7) JWLBT.51(GND8) JWLBT.57(GND9) JWLBT.63(GND10) JWLBT.69(GND11) JWLBT.75(GND12) JWLBT.76(PEG2) JWLBT.77(PEG1) LE2.2 PC1.1 PC2.2 PC3.2 PC4.2 PC5.2 PC6.2 PC7.2 PC8.2 PC9.2 PC10.1 PC103.1 PC104.1 PC106.2 PC107.2 PC109.2 PC110.1 PC111.2 PC112.2 PC113.2 PC114.2 PC115.2 PC116.2 PC117.1 PC119.1 PC120.1 PC121.2 PC122.2 PC123.2 PC125.1 PC126.1 PC127.1 PC128.2 PC201.2 PC202.2 PC204.2 PC205.2 PC206.2 PC207.2 PC208.2 PC209.1 PC210.2 PC211.2 PC213.1 PC214.2 PC215.2 PC216.2 PC218.1 PC219.2 PC220.2 PC221.2 PC222.2 PC223.2 PC224.2 PC225.2 PC226.1 PC227.2 PC228.2 PC230.2 PC231.2 PC301.2 PC302.2 PC303.2 PC304.2 PC305.2 PC306.2 PC307.2 PC308.2 PC309.2 PC311.2(G) PC312.2 PC313.2 PC315.2 PC316.2 PC317.1 PC318.2 PC319.2 PC401.2 PC402.2 PC403.2 PC408.2 PC409.1 PC411.1 PC412.1 PC416.1 PC417.2 PC424.2 PC427.1 PC430.1 PC431.1 PC432.2 PC433.2 PC434.2 PC435.2 PC436.2 PC437.2 PC438.2 PC441.2 PC443.2(G) PC444.2 PC445.2 PC446.2 PC447.2 PC448.2 PC449.2 PC450.2 PC451.2 PC452.2 PC454.2(G) PC455.2 PC456.1 PC457.2 PC458.2 PC459.2 PC460.2 PC461.2 PC463.2 PC464.2 PC465.1 PC466.1 PC467.1 PC468.1 PC469.1 PC470.1 PC471.1 PC472.1 PC473.1 PC474.1 PC475.1 PC476.1 PC477.1 PC478.1 PC479.1 PC480.1 PC481.1 PC482.1 PC483.1 PC484.1 PC485.1 PC486.1 PC487.1 PC488.1 PC489.1 PC490.1 PC491.1 PC492.1 PC493.1 PC494.1 PC495.1 PC496.1 PC497.1 PC498.1 PC499.1 PC500.1 PC501.1 PC502.1 PC503.1 PC504.1 PC505.1 PC506.1 PC507.1 PC508.1 PC509.1 PC510.1 PC511.1 PC512.1 PC513.1 PC514.1 PC515.1 PC516.1 PC517.1 PC518.1 PC519.1 PC520.1 PC521.1 PC522.1 PC523.1 PC524.1 PC525.2(G) PC526.2(G) PC527.2(G) PC528.2(G) PC529.2(G) PC601.2 PC602.2 PC603.2 PC604.2 PC605.2 PC606.2 PC607.2 PC611.2 PC613.2(G) PC614.2(G) PC615.2 PC616.2 PC619.1 PC620.2 PC622.2 PC623.2 PC624.2 PC625.2 PC626.2 PC627.2 PC629.2(G) PC630.2(G) PC631.2 PC632.2 PC636.1 PC637.1 PC701.2 PC702.1 PC703.2 PC705.1 PC706.2 PC707.2 PC708.2 PC709.2 PC710.2 PC711.2 PC712.2 PC713.2 PC714.2 PC715.2 PC716.2 PC717.2 PC718.2 PC801.2 PC802.2 PC803.2 PC804.1 PC806.2 PC807.2 PC808.2 PD5.2 PD7.1 PQ2.3(E) PQ4.4(S2) PQ105.3(S) PQ107.1(S1) PQ107.2(S2) PQ107.3(S3) PQ201.1(S1) PQ201.4(S2) PQ302.1(S1) PQ302.2(S2) PQ302.3(S3) PQ402.1(S1) PQ402.2(S2) PQ402.3(S3) PQ403.1(S1) PQ403.2(S2) PQ403.3(S3) PQ405.1(S1) PQ405.2(S2) PQ405.3(S3) PQ406.1(S1) PQ406.2(S2) PQ406.3(S3) PQ408.1(S1) PQ408.2(S2) PQ408.3(S3) PQ602.1(S1) PQ602.2(S2) PQ602.3(S3) PQ603.1(S1) PQ603.2(S2) PQ603.3(S3) PQ605.1(S1) PQ605.2(S2) PQ605.3(S3) PQ606.1(S1) PQ606.2(S2) PQ606.3(S3) PR8.2 PR19.1 PR105.1 PR110.1 PR115.1 PR132.2 PR201.2 PR208.2 PR301.1 PR302.1 PR307.2 PR313.1 PR413.1 PR418.1 PR419.1 PR420.1 PR421.2 PR425.1 PR436.1 PR440.1 PR441.1 PR442.1 PR443.1 PR444.1 PR445.1 PR446.1 PR447.1 PR448.1 PR619.1 PR626.2 PR627.1 PR628.2 PR629.2 PR637.1 PR638.2 PR640.2 PR642.2 PR643.2 PR703.1 PR705.2 PR802.1 PR805.2 PRT6.2 PRT7.2 PRT402.2 PRT404.2 PU1.2(GND) PU101.22(GND) PU101.29(PAD) PU201.9(GND) PU202.9(GND) PU301.1(VTTGND) PU301.3(GND) PU301.14(PGND) PU301.21(PAD) PU401.49(TAB) PU402.6(GND) PU402.9(FLAG) PU403.6(GND) PU403.9(FLAG) PU404.6(GND) PU404.9(FLAG) PU601.41(TP) PU701.10(PGND1) PU701.11(PGND2) PU701.12(PGND3) PU701.13(PGND4) PU701.14(PGND5) PU701.19(GND1) PU701.23(GSNS) PU701.24(REFIN2) PU701.29(GND2) PU801.11(GND) Q5.3(S) Q6.1(S1) Q6.4(S2) Q24.1(S1) Q24.4(S2) QC3.1(S1) QC3.4(S2) QE1.3(S) QL3.3(S) QV4.3(EMITTER) QV17.3(S) QV18.1(S1) QV18.4(S2) QV19.1(S1) QV19.4(S2) QV23.1(S1) QV23.4(S2) R2.2 R18.2 R21.1 R26.2 R61.1 R67.1 R69.2 R91.2 R107.1 R108.2 R153.2 R235.1 R484.2 R9449.2 R9476.2 R9484.1 R9489.1 R9493.1 RA13.2 RC4.2 RC6.2 RC8.2 RC9.2 RC10.2 RC26.2 RC27.1 RC32.1 RC55.1 RC56.1 RC71.2 RC74.2 RC97.1 RC100.2 RC143.2 RC144.1 RC151.1 RC152.2 RC159.2 RC166.1 RC184.2 RC189.2 RC200.1 RC201.1 RC204.2 RC209.2 RC288.2 RC295.2 RC296.2 RC300.2 RC301.2 RC302.2 RC307.2 RC315.1 RC316.1 RC317.1 RC350.2 RC352.2 RC355.1 RC374.2 RC378.2 RC381.2 RC382.2 RC383.2 RC384.2 RC386.2 RC389.2 RC394.2 RC403.1 RC406.1 RC407.1 RC435.2 RD3.2 RD4.2 RD11.2 RD12.2 RD16.2 RD18.2 RD24.2 RE7.2 RE32.2 RG8.1 RL7.2 RL8.2 RL23.2 RPE4.1(R1) RPE4.4(R4) RT21.2 RT22.2 RT23.2 RV7.1 RV15.1 RV17.1 RV20.2 RV21.2 RV24.2 RV25.2 RV26.1 RV29.2 RV32.2 RV33.2 RV45.2 RV46.2 RV57.2 RV58.2 RV70.2 RV71.2 RV94.1 RV103.2 RV107.2 RV109.2 RV111.2 RV113.2 RV118.2 RV127.2 RV130.1 RV133.2 RV137.2 RV145.2 RV146.2 RV147.1 RV148.2 RV160.1 RV166.2 RV167.2 RV188.2 RV194.2 RV195.2 RV197.2 RV198.2 RV200.2 RV201.2 RV202.2 RV203.2 RV204.2 RV205.2 RVG131.1 RVG134.2 RVG135.2 RW8.1 RX2.1 RX4.2 RX5.2 RX7.2 RX10.2 RX12.2 RX13.2 RX15.2 RX18.2 RX20.2 RX21.2 SW1.1 SW1.2 U1.6(GND) U3.2(GND) U4.2(GND) U7.2(GND) U11.11(GND) U11.15(GPAD) U15.2(GND) U148.B2(GND) U149.6(GND) U150.2(GND) UA1.41(GND) UC1.A5(VSS_A5) UC1.A67(VSS_A67) UC1.A70(VSS_A70) UC1.AA2(VSS_AA2) UC1.AA4(VSS_AA4) UC1.AA65(VSS_AA65) UC1.AA68(VSS_AA68) UC1.AB8(VSS_AB8) UC1.AB15(VSS_AB15) UC1.AB16(VSS_AB16) UC1.AB18(VSS_AB18) UC1.AB21(VSS_AB21) UC1.AD8(VSS_AD8) UC1.AD13(VSS_AD13) UC1.AD16(VSS_AD16) UC1.AD19(VSS_AD19) UC1.AD20(VSS_AD20) UC1.AD21(VSS_AD21) UC1.AD62(VSS_AD62) UC1.AE64(VSS_AE64) UC1.AE65(VSS_AE65) UC1.AE66(VSS_AE66) UC1.AE67(VSS_AE67) UC1.AE68(VSS_AE68) UC1.AE69(VSS_AE69) UC1.AF1(VSS_AF1) UC1.AF2(VSS_AF2) UC1.AF4(VSS_AF4) UC1.AF10(VSS_AF10) UC1.AF15(VSS_AF15) UC1.AF17(VSS_AF17) UC1.AF63(VSS_AF63) UC1.AG16(VSS_AG16) UC1.AG17(VSS_AG17) UC1.AG18(VSS_AG18) UC1.AG19(VSS_AG19) UC1.AG20(VSS_AG20) UC1.AG21(VSS_AG21) UC1.AG71(VSS_AG71) UC1.AH6(VSS_AH6) UC1.AH13(VSS_AH13) UC1.AH63(VSS_AH63) UC1.AH64(VSS_AH64) UC1.AH67(VSS_AH67) UC1.AJ4(VSS_AJ4) UC1.AJ15(VSS_AJ15) UC1.AJ18(VSS_AJ18) UC1.AJ20(VSS_AJ20) UC1.AK8(VSS_AK8) UC1.AK11(VSS_AK11) UC1.AK16(VSS_AK16) UC1.AK18(VSS_AK18) UC1.AK21(VSS_AK21) UC1.AK22(VSS_AK22) UC1.AK27(VSS_AK27) UC1.AK63(VSS_AK63) UC1.AK68(VSS_AK68) UC1.AK69(VSS_AK69) UC1.AL2(VSS_AL2) UC1.AL4(VSS_AL4) UC1.AL28(VSS_AL28) UC1.AL32(VSS_AL32) UC1.AL35(VSS_AL35) UC1.AL38(VSS_AL38) UC1.AL45(VSS_AL45) UC1.AL48(VSS_AL48) UC1.AL52(VSS_AL52) UC1.AL55(VSS_AL55) UC1.AL58(VSS_AL58) UC1.AL64(VSS_AL64) UC1.AL65(VSS_AL65) UC1.AL66(VSS_AL66) UC1.AM8(VSS_AM8) UC1.AM13(VSS_AM13) UC1.AM21(VSS_AM21) UC1.AM25(VSS_AM25) UC1.AM27(VSS_AM27) UC1.AM43(VSS_AM43) UC1.AM45(VSS_AM45) UC1.AM46(VSS_AM46) UC1.AM55(VSS_AM55) UC1.AM60(VSS_AM60) UC1.AM61(VSS_AM61) UC1.AM68(VSS_AM68) UC1.AM71(VSS_AM71) UC1.AN20(VSS_AN20) UC1.AN23(VSS_AN23) UC1.AN28(VSS_AN28) UC1.AN30(VSS_AN30) UC1.AN32(VSS_AN32) UC1.AN33(VSS_AN33) UC1.AN35(VSS_AN35) UC1.AN37(VSS_AN37) UC1.AN38(VSS_AN38) UC1.AN40(VSS_AN40) UC1.AN42(VSS_AN42) UC1.AN43(DDR1_ALERT#) UC1.AN58(VSS_AN58) UC1.AN63(VSS_AN63) UC1.AP10(VSS_AP10) UC1.AP18(VSS_AP18) UC1.AP20(VSS_AP20) UC1.AP23(VSS_AP23) UC1.AP28(VSS_AP28) UC1.AP32(VSS_AP32) UC1.AP35(VSS_AP35) UC1.AP38(VSS_AP38) UC1.AP42(VSS_AP42) UC1.AP58(VSS_AP58) UC1.AP63(VSS_AP63) UC1.AP68(VSS_AP68) UC1.AP70(VSS_AP70) UC1.AR5(VSS_AR5) UC1.AR8(VSS_AR8) UC1.AR11(VSS_AR11) UC1.AR15(VSS_AR15) UC1.AR16(VSS_AR16) UC1.AR20(VSS_AR20) UC1.AR23(VSS_AR23) UC1.AR28(VSS_AR28) UC1.AR35(VSS_AR35) UC1.AR42(VSS_AR42) UC1.AR43(VSS_AR43) UC1.AR45(VSS_AR45) UC1.AR46(VSS_AR46) UC1.AR48(VSS_AR48) UC1.AR50(VSS_AR50) UC1.AR52(VSS_AR52) UC1.AR53(VSS_AR53) UC1.AR55(VSS_AR55) UC1.AR58(VSS_AR58) UC1.AR63(VSS_AR63) UC1.AT2(VSS_AT2) UC1.AT4(VSS_AT4) UC1.AT20(VSS_AT20) UC1.AT23(VSS_AT23) UC1.AT28(VSS_AT28) UC1.AT35(VSS_AT35) UC1.AT42(VSS_AT42) UC1.AT56(VSS_AT56) UC1.AT58(VSS_AT58) UC1.AT63(VSS_AT63) UC1.AT68(VSS_AT68) UC1.AT71(VSS_AT71) UC1.AU10(VSS_AU10) UC1.AU15(VSS_AU15) UC1.AU20(VSS_AU20) UC1.AU32(VSS_AU32) UC1.AU38(VSS_AU38) UC1.AV1(VSS_AV1) UC1.AV68(VSS_AV68) UC1.AV69(VSS_AV69) UC1.AV70(VSS_AV70) UC1.AV71(VSS_AV71) UC1.AW6(VSS_AW6) UC1.AW8(VSS_AW8) UC1.AW10(VSS_AW10) UC1.AW12(VSS_AW12) UC1.AW14(VSS_AW14) UC1.AW16(VSS_AW16) UC1.AW18(VSS_AW18) UC1.AW21(VSS_AW21) UC1.AW23(VSS_AW23) UC1.AW26(VSS_AW26) UC1.AW28(VSS_AW28) UC1.AW30(VSS_AW30) UC1.AW32(VSS_AW32) UC1.AW34(VSS_AW34) UC1.AW36(VSS_AW36) UC1.AW38(VSS_AW38) UC1.AW41(VSS_AW41) UC1.AW43(VSS_AW43) UC1.AW45(VSS_AW45) UC1.AW47(VSS_AW47) UC1.AW49(VSS_AW49) UC1.AW50(DDR0_ALERT#) UC1.AW51(VSS_AW51) UC1.AW53(VSS_AW53) UC1.AW55(VSS_AW55) UC1.AW57(VSS_AW57) UC1.AW60(VSS_AW60) UC1.AW62(VSS_AW62) UC1.AW64(VSS_AW64) UC1.AW66(VSS_AW66) UC1.AY66(VSS_AY66) UC1.B10(VSS_B10) UC1.B14(VSS_B14) UC1.B18(VSS_B18) UC1.B22(VSS_B22) UC1.B30(VSS_B30) UC1.B34(VSS_B34) UC1.B39(VSS_B39) UC1.B44(VSS_B44) UC1.B48(VSS_B48) UC1.B53(VSS_B53) UC1.B58(VSS_B58) UC1.B62(VSS_B62) UC1.B66(VSS_B66) UC1.B71(VSS_B71) UC1.BA1(VSS_BA1) UC1.BA2(VSS_BA2) UC1.BA6(VSS_BA6) UC1.BA10(VSS_BA10) UC1.BA14(VSS_BA14) UC1.BA18(VSS_BA18) UC1.BA23(VSS_BA23) UC1.BA28(VSS_BA28) UC1.BA32(VSS_BA32) UC1.BA36(VSS_BA36) UC1.BA41(VSS_BA41) UC1.BA45(VSS_BA45) UC1.BA49(VSS_BA49) UC1.BA53(VSS_BA53) UC1.BA57(VSS_BA57) UC1.BA62(VSS_BA62) UC1.BA66(VSS_BA66) UC1.BA71(VSS_BA71) UC1.BB6(VSS_BB6) UC1.BB18(VSS_BB18) UC1.BB26(VSS_BB26) UC1.BB30(VSS_BB30) UC1.BB34(VSS_BB34) UC1.BB38(VSS_BB38) UC1.BB43(VSS_BB43) UC1.BB55(VSS_BB55) UC1.BB60(VSS_BB60) UC1.BB64(VSS_BB64) UC1.BB67(VSS_BB67) UC1.BB70(VSS_BB70) UC1.C1(VSS_C1) UC1.C5(VSS_C5) UC1.C25(VSS_C25) UC1.D6(VSS_D6) UC1.D10(VSS_D10) UC1.D11(VSS_D11) UC1.D14(VSS_D14) UC1.D18(VSS_D18) UC1.D22(VSS_D22) UC1.D25(VSS_D25) UC1.D26(VSS_D26) UC1.D30(VSS_D30) UC1.D34(VSS_D34) UC1.D39(VSS_D39) UC1.D44(VSS_D44) UC1.D45(VSS_D45) UC1.D47(VSS_D47) UC1.D48(VSS_D48) UC1.D53(VSS_D53) UC1.D58(VSS_D58) UC1.D62(VSS_D62) UC1.D66(VSS_D66) UC1.D69(VSS_D69) UC1.E6(VSS_E6) UC1.E11(VSS_E11) UC1.E15(VSS_E15) UC1.E18(VSS_E18) UC1.E21(VSS_E21) UC1.E46(VSS_E46) UC1.E50(VSS_E50) UC1.E53(VSS_E53) UC1.E56(VSS_E56) UC1.E65(VSS_E65) UC1.E71(VSS_E71) UC1.F1(VSS_F1) UC1.F2(VSS_F2) UC1.F4(VSS_F4) UC1.F8(VSS_F8) UC1.F13(VSS_F13) UC1.F22(VSS_F22) UC1.F23(VSS_F23) UC1.F27(VSS_F27) UC1.F28(VSS_F28) UC1.F32(VSS_F32) UC1.F33(VSS_F33) UC1.F35(VSS_F35) UC1.F37(VSS_F37) UC1.F38(VSS_F38) UC1.F40(VSS_F40) UC1.F42(VSS_F42) UC1.F65(VSS_F65) UC1.F68(VSS_F68) UC1.G5(VSS_G5) UC1.G6(VSS_G6) UC1.G10(VSS_G10) UC1.G22(VSS_G22) UC1.G43(VSS_G43) UC1.G45(VSS_G45) UC1.G48(VSS_G48) UC1.G52(VSS_G52) UC1.G55(VSS_G55) UC1.G58(VSS_G58) UC1.G60(VSS_G60) UC1.G63(VSS_G63) UC1.G65(VSS_G65) UC1.G66(VSS_G66) UC1.H15(VSS_H15) UC1.H18(VSS_H18) UC1.H71(VSS_H71) UC1.J8(VSS_J8) UC1.J11(VSS_J11) UC1.J13(VSS_J13) UC1.J25(VSS_J25) UC1.J28(VSS_J28) UC1.J32(VSS_J32) UC1.J35(VSS_J35) UC1.J38(VSS_J38) UC1.J42(VSS_J42) UC1.K16(VSS_K16) UC1.K18(VSS_K18) UC1.K22(VSS_K22) UC1.K61(VSS_K61) UC1.K63(VSS_K63) UC1.K64(VSS_K64) UC1.K65(VSS_K65) UC1.K66(VSS_K66) UC1.K67(VSS_K67) UC1.K68(VSS_K68) UC1.K70(VSS_K70) UC1.K71(VSS_K71) UC1.L2(VSS_L2) UC1.L4(VSS_L4) UC1.L8(VSS_L8) UC1.L11(VSS_L11) UC1.L16(VSS_L16) UC1.L17(VSS_L17) UC1.L18(VSS_L18) UC1.L20(VSS_L20) UC1.N6(VSS_N6) UC1.N10(VSS_N10) UC1.N13(VSS_N13) UC1.N19(VSS_N19) UC1.N21(VSS_N21) UC1.N65(VSS_N65) UC1.N68(VSS_N68) UC1.P17(VSS_P17) UC1.P19(VSS_P19) UC1.P20(VSS_P20) UC1.P21(VSS_P21) UC1.R6(VSS_R6) UC1.R13(VSS_R13) UC1.T2(VSS_T2) UC1.T4(VSS_T4) UC1.T15(VSS_T15) UC1.T17(VSS_T17) UC1.T18(VSS_T18) UC1.T21(VSS_T21) UC1.U10(VSS_U10) UC1.U63(VSS_U63) UC1.U64(VSS_U64) UC1.U66(VSS_U66) UC1.U67(VSS_U67) UC1.U69(VSS_U69) UC1.U70(VSS_U70) UC1.V16(VSS_V16) UC1.V17(VSS_V17) UC1.V18(VSS_V18) UC1.W6(VSS_W6) UC1.W9(VSS_W9) UC1.W13(VSS_W13) UC1.Y17(VSS_Y17) UC1.Y19(VSS_Y19) UC1.Y20(VSS_Y20) UC1.Y21(VSS_Y21) UC3.3(GND) UC4M1.4(GND) UC8M2.4(GND) UE1.1(VSS1) UE1.3(VBAT) UE1.27(VSS2) UE1.49(VSS3) UE1.91(VSS4) UE1.113(VSS5) UE1.122(VSS6) UGSEN1.5(GND_1) UGSEN1.10(RES) UGSEN1.12(GND_2) UGSEN1.13(ADC3) UGSEN1.15(ADC2) UGSEN1.16(ADC1) UL1.6(SVR_EN_N) UL1.49(GND) USROM1.4(GND) USROM1.7(WP) UT3.1(OE#) UT3.3(G) UT4.1(OE#) UT4.3(G) UTPM1.2(NC1) UTPM1.9(GND1) UTPM1.16(GND2) UTPM1.23(GND3) UTPM1.32(GND4) UTPM1.33(EX-PAD) UV1.A3(GND_1) UV1.A37(GND_2) UV1.AA2(GND_5) UV1.AA6(GND_10) UV1.AA16(GND_3) UV1.AA18(GND_4) UV1.AA21(GND_6) UV1.AA23(GND_7) UV1.AA26(GND_8) UV1.AA28(GND_9) UV1.AB12(GND_11) UV1.AB15(GND_12) UV1.AB17(GND_13) UV1.AB20(GND_14) UV1.AB22(GND_15) UV1.AB24(GND_16) UV1.AB27(GND_17) UV1.AB39(GND_176) UV1.AC2(GND_22) UV1.AC6(GND_27) UV1.AC11(GND_18) UV1.AC13(GND_19) UV1.AC16(GND_20) UV1.AC18(GND_21) UV1.AC21(GND_23) UV1.AC23(GND_24) UV1.AC26(GND_25) UV1.AC28(GND_26) UV1.AC34(VSS1DI) UV1.AD9(GND_34) UV1.AD15(GND_28) UV1.AD17(GND_29) UV1.AD20(GND_30) UV1.AD22(GND_31) UV1.AD24(GND_32) UV1.AD27(GND_33) UV1.AE2(GND_35) UV1.AE6(GND_36) UV1.AE34(AVSSQ) UV1.AF10(GND_37) UV1.AF16(GND_38) UV1.AF18(GND_39) UV1.AF21(GND_40) UV1.AF39(DP_VSSR_25) UV1.AG2(GND_42) UV1.AG6(GND_45) UV1.AG9(GND_46) UV1.AG17(GND_41) UV1.AG20(GND_43) UV1.AG22(GND_44) UV1.AH21(GND_47) UV1.AH39(DP_VSSR_26) UV1.AJ2(GND_50) UV1.AJ6(GND_52) UV1.AJ10(GND_48) UV1.AJ11(GND_49) UV1.AJ28(GND_51) UV1.AJ33(TSVSS) UV1.AK7(GND_55) UV1.AK11(GND_53) UV1.AK31(GND_54) UV1.AK39(DP_VSSR_27) UV1.AL2(GND_59) UV1.AL6(GND_64) UV1.AL8(GND_65) UV1.AL11(GND_56) UV1.AL14(GND_57) UV1.AL17(GND_58) UV1.AL20(GND_60) UV1.AL23(GND_61) UV1.AL26(GND_62) UV1.AL32(GND_63) UV1.AL34(DP_VSSR_28) UV1.AM9(GND_68) UV1.AM11(GND_66) UV1.AM31(GND_67) UV1.AM35(DP_VSSR_34) UV1.AN2(GND_70) UV1.AN6(GND_72) UV1.AN8(GND_73) UV1.AN10(SPLL_PVSS) UV1.AN11(GND_69) UV1.AN17(DP_VSSR_11) UV1.AN19(DP_VSSR_16) UV1.AN27(DP_VSSR_1) UV1.AN29(DP_VSSR_6) UV1.AN30(GND_71) UV1.AN32(DP_VSSR_35) UV1.AN34(DP_VSSR_21) UV1.AN38(DP_VSSR_33) UV1.AP7(GND_75) UV1.AP9(GND_76) UV1.AP11(GND_74) UV1.AP16(DP_VSSR_12) UV1.AP17(DP_VSSR_13) UV1.AP18(DP_VSSR_17) UV1.AP19(DP_VSSR_18) UV1.AP27(DP_VSSR_2) UV1.AP28(DP_VSSR_3) UV1.AP29(DP_VSSR_7) UV1.AP30(DP_VSSR_8) UV1.AP39(DP_VSSR_22) UV1.AR5(GND_77) UV1.AR18(DP_VSSR_32) UV1.AR28(DP_VSSR_30) UV1.AR39(DP_VSSR_23) UV1.AU37(DP_VSSR_24) UV1.AV17(DP_VSSR_31) UV1.AV27(DP_VSSR_29) UV1.AW14(DP_VSSR_14) UV1.AW16(DP_VSSR_15) UV1.AW20(DP_VSSR_19) UV1.AW22(DP_VSSR_20) UV1.AW24(DP_VSSR_4) UV1.AW26(DP_VSSR_5) UV1.AW30(DP_VSSR_9) UV1.AW32(DP_VSSR_10) UV1.B7(GND_90) UV1.B9(GND_91) UV1.B11(GND_78) UV1.B13(GND_79) UV1.B15(GND_80) UV1.B17(GND_81) UV1.B19(GND_82) UV1.B21(GND_83) UV1.B23(GND_84) UV1.B25(GND_85) UV1.B27(GND_86) UV1.B29(GND_87) UV1.B31(GND_88) UV1.B33(GND_89) UV1.C1(GND_92) UV1.C39(GND_93) UV1.E5(GND_95) UV1.E35(GND_94) UV1.E39(GND_177) UV1.F7(GND_110) UV1.F9(GND_111) UV1.F11(GND_96) UV1.F13(GND_97) UV1.F15(GND_100) UV1.F17(GND_101) UV1.F19(GND_102) UV1.F21(GND_103) UV1.F23(GND_104) UV1.F25(GND_105) UV1.F27(GND_106) UV1.F29(GND_107) UV1.F31(GND_108) UV1.F33(GND_109) UV1.F34(GND_178) UV1.F39(GND_179) UV1.G2(GND_112) UV1.G6(GND_113) UV1.G33(GND_180) UV1.G34(GND_181) UV1.H9(GND_114) UV1.H31(GND_182) UV1.H34(GND_183) UV1.H39(GND_184) UV1.J2(GND_115) UV1.J6(GND_117) UV1.J8(GND_118) UV1.J27(GND_116) UV1.J31(GND_185) UV1.J34(GND_186) UV1.K7(GND_120) UV1.K14(GND_119) UV1.K31(GND_187) UV1.K34(GND_188) UV1.K39(GND_189) UV1.L2(GND_123) UV1.L6(GND_126) UV1.L11(GND_121) UV1.L17(GND_122) UV1.L22(GND_124) UV1.L24(GND_125) UV1.L31(GND_190) UV1.L34(GND_191) UV1.M17(GND_127) UV1.M22(GND_128) UV1.M24(GND_129) UV1.M34(GND_192) UV1.M39(GND_193) UV1.N2(GND_132) UV1.N6(GND_136) UV1.N16(GND_130) UV1.N18(GND_131) UV1.N21(GND_133) UV1.N23(GND_134) UV1.N26(GND_135) UV1.N31(GND_194) UV1.N34(GND_195) UV1.P31(GND_196) UV1.P34(GND_197) UV1.P39(GND_198) UV1.R2(GND_139) UV1.R6(GND_144) UV1.R15(GND_137) UV1.R17(GND_138) UV1.R20(GND_140) UV1.R22(GND_141) UV1.R24(GND_142) UV1.R27(GND_143) UV1.R34(GND_199) UV1.T11(GND_145) UV1.T13(GND_146) UV1.T16(GND_147) UV1.T18(GND_148) UV1.T21(GND_149) UV1.T23(GND_150) UV1.T26(GND_151) UV1.T31(GND_200) UV1.T34(GND_201) UV1.T39(GND_202) UV1.U2(GND_155) UV1.U6(GND_160) UV1.U15(GND_153) UV1.U17(GND_154) UV1.U20(GND_156) UV1.U22(GND_157) UV1.U24(GND_158) UV1.U27(GND_159) UV1.U31(GND_203) UV1.U34(GND_204) UV1.V11(GND_161) UV1.V16(GND_163) UV1.V18(GND_164) UV1.V21(GND_165) UV1.V23(GND_166) UV1.V26(GND_167) UV1.V34(GND_205) UV1.V39(GND_206) UV1.W2(GND_168) UV1.W6(GND_169) UV1.W31(GND_207) UV1.W34(GND_208) UV1.Y15(GND_170) UV1.Y17(GND_171) UV1.Y20(GND_172) UV1.Y22(GND_173) UV1.Y24(GND_174) UV1.Y27(GND_175) UV1.Y34(GND_209) UV1.Y39(GND_210) UV5.A1(VSSQ1) UV5.A3(VSSQ9) UV5.A12(VSSQ23) UV5.A14(VSSQ31) UV5.B5(VSS3) UV5.B10(VSS7) UV5.C1(VSSQ2) UV5.C3(VSSQ10) UV5.C4(VSSQ15) UV5.C11(VSSQ21) UV5.C12(VSSQ24) UV5.C14(VSSQ32) UV5.D10(VSS8) UV5.E1(VSSQ3) UV5.E3(VSSQ11) UV5.E12(VSSQ25) UV5.E14(VSSQ33) UV5.F5(VSSQ17) UV5.F10(VSSQ19) UV5.G5(VSS4) UV5.G10(VSS9) UV5.H1(VSS1) UV5.H2(VSSQ7) UV5.H13(VSSQ29) UV5.H14(VSS13) UV5.K1(VSS2) UV5.K2(VSSQ8) UV5.K13(VSSQ30) UV5.K14(VSS14) UV5.L5(VSS5) UV5.L10(VSS10) UV5.M5(VSSQ18) UV5.M10(VSSQ20) UV5.N1(VSSQ4) UV5.N3(VSSQ12) UV5.N12(VSSQ26) UV5.N14(VSSQ34) UV5.P10(VSS11) UV5.R1(VSSQ5) UV5.R3(VSSQ13) UV5.R4(VSSQ16) UV5.R11(VSSQ22) UV5.R12(VSSQ27) UV5.R14(VSSQ35) UV5.T5(VSS6) UV5.T10(VSS12) UV5.U1(VSSQ6) UV5.U3(VSSQ14) UV5.U12(VSSQ28) UV5.U14(VSSQ36) UV6.A1(VSSQ1) UV6.A3(VSSQ9) UV6.A12(VSSQ23) UV6.A14(VSSQ31) UV6.B5(VSS3) UV6.B10(VSS7) UV6.C1(VSSQ2) UV6.C3(VSSQ10) UV6.C4(VSSQ15) UV6.C11(VSSQ21) UV6.C12(VSSQ24) UV6.C14(VSSQ32) UV6.D10(VSS8) UV6.E1(VSSQ3) UV6.E3(VSSQ11) UV6.E12(VSSQ25) UV6.E14(VSSQ33) UV6.F5(VSSQ17) UV6.F10(VSSQ19) UV6.G5(VSS4) UV6.G10(VSS9) UV6.H1(VSS1) UV6.H2(VSSQ7) UV6.H13(VSSQ29) UV6.H14(VSS13) UV6.K1(VSS2) UV6.K2(VSSQ8) UV6.K13(VSSQ30) UV6.K14(VSS14) UV6.L5(VSS5) UV6.L10(VSS10) UV6.M5(VSSQ18) UV6.M10(VSSQ20) UV6.N1(VSSQ4) UV6.N3(VSSQ12) UV6.N12(VSSQ26) UV6.N14(VSSQ34) UV6.P10(VSS11) UV6.R1(VSSQ5) UV6.R3(VSSQ13) UV6.R4(VSSQ16) UV6.R11(VSSQ22) UV6.R12(VSSQ27) UV6.R14(VSSQ35) UV6.T5(VSS6) UV6.T10(VSS12) UV6.U1(VSSQ6) UV6.U3(VSSQ14) UV6.U12(VSSQ28) UV6.U14(VSSQ36) UV7.A1(VSSQ1) UV7.A3(VSSQ9) UV7.A12(VSSQ23) UV7.A14(VSSQ31) UV7.B5(VSS3) UV7.B10(VSS7) UV7.C1(VSSQ2) UV7.C3(VSSQ10) UV7.C4(VSSQ15) UV7.C11(VSSQ21) UV7.C12(VSSQ24) UV7.C14(VSSQ32) UV7.D10(VSS8) UV7.E1(VSSQ3) UV7.E3(VSSQ11) UV7.E12(VSSQ25) UV7.E14(VSSQ33) UV7.F5(VSSQ17) UV7.F10(VSSQ19) UV7.G5(VSS4) UV7.G10(VSS9) UV7.H1(VSS1) UV7.H2(VSSQ7) UV7.H13(VSSQ29) UV7.H14(VSS13) UV7.K1(VSS2) UV7.K2(VSSQ8) UV7.K13(VSSQ30) UV7.K14(VSS14) UV7.L5(VSS5) UV7.L10(VSS10) UV7.M5(VSSQ18) UV7.M10(VSSQ20) UV7.N1(VSSQ4) UV7.N3(VSSQ12) UV7.N12(VSSQ26) UV7.N14(VSSQ34) UV7.P10(VSS11) UV7.R1(VSSQ5) UV7.R3(VSSQ13) UV7.R4(VSSQ16) UV7.R11(VSSQ22) UV7.R12(VSSQ27) UV7.R14(VSSQ35) UV7.T5(VSS6) UV7.T10(VSS12) UV7.U1(VSSQ6) UV7.U3(VSSQ14) UV7.U12(VSSQ28) UV7.U14(VSSQ36) UV8.A1(VSSQ1) UV8.A3(VSSQ9) UV8.A12(VSSQ23) UV8.A14(VSSQ31) UV8.B5(VSS3) UV8.B10(VSS7) UV8.C1(VSSQ2) UV8.C3(VSSQ10) UV8.C4(VSSQ15) UV8.C11(VSSQ21) UV8.C12(VSSQ24) UV8.C14(VSSQ32) UV8.D10(VSS8) UV8.E1(VSSQ3) UV8.E3(VSSQ11) UV8.E12(VSSQ25) UV8.E14(VSSQ33) UV8.F5(VSSQ17) UV8.F10(VSSQ19) UV8.G5(VSS4) UV8.G10(VSS9) UV8.H1(VSS1) UV8.H2(VSSQ7) UV8.H13(VSSQ29) UV8.H14(VSS13) UV8.K1(VSS2) UV8.K2(VSSQ8) UV8.K13(VSSQ30) UV8.K14(VSS14) UV8.L5(VSS5) UV8.L10(VSS10) UV8.M5(VSSQ18) UV8.M10(VSSQ20) UV8.N1(VSSQ4) UV8.N3(VSSQ12) UV8.N12(VSSQ26) UV8.N14(VSSQ34) UV8.P10(VSS11) UV8.R1(VSSQ5) UV8.R3(VSSQ13) UV8.R4(VSSQ16) UV8.R11(VSSQ22) UV8.R12(VSSQ27) UV8.R14(VSSQ35) UV8.T5(VSS6) UV8.T10(VSS12) UV8.U1(VSSQ6) UV8.U3(VSSQ14) UV8.U12(VSSQ28) UV8.U14(VSSQ36) UV12.5(GND) UV12.9(THERMALPAD) UV14.4(GND) UV15.3(GND) UVG2.32(PGND) UVG2.33(GND) UW1.33(GND) UX1.26(GND1) UX1.35(GND2) UX1.43(GND3) UX1.57(EPAD) YC2.2(GND1) YC2.4(GND2) YL1.2(GND1) YL1.4(GND2) YVG1.2(GND1) YVG1.4(GND2)
GNDA: CA8.2 CA9.2 CA10.2 CA11.2 CA19.2 JAUF.10
VCC0R9GBE: CL4.1 CL5.1 CL6.2 LL1.2 UL1.8(VDD0P9_8) UL1.11(VDD0P9_11) UL1.16(VDD0P9_16) UL1.22(VDD0P9_22) UL1.37(VDD0P9_37) UL1.40(VDD0P9_40) UL1.43(VDD0P9_43) UL1.46(VDD0P9_46) UL1.47(VDD0P9_47)
VCC0R9GBE_L: LL1.1 UL1.7(CTRL0P9)
VCC_SENSE: PC404.1 PC406.2 PR415.1 RC120.2 RC121.2
VCCGT_SENSE: PC413.2 PU401.47(VSP_2PH) RC124.1 RC125.2
VCCIO_SENSE: RC192.1 UC1.AM23(VCCIO_SENSE)
VCCSA_SENSE: PC423.1 PC425.2 PR434.1 RC126.2 RC375.2
VCCST_PG_EC: DC23.1 UE1.34(PWM7/RIG1#/GPA7)
VCCST_PWRGD: DC23.2 RC123.2 RC410.2 UC1.B65(VCCST_PWRGD)
VCCST_PWRGD_GD: QC3.3(D2) RC401.2 RC410.1
VDD_62771: PC604.1 PR601.1 PU601.25(VDD) PU601.31(BOOT_NB)
VDDC_RTN: PR625.2 UV1.AH29(FB_GND)
VDDC_SEN: PR621.1 UV1.AF28(FB_VDDC)
VDDPALW_PWRGD: PR704.1 PU701.1(PGOOD)
VIN_1.00VS: PC706.1 PC707.1 PC708.1 PC709.1 PC710.1 PC714.1 PJ701.1 PU701.15(VIN1) PU701.16(VIN2) PU701.17(VIN3)
VIN_+1.8VSP: PC801.1 PC802.1 PJ801.1 PU801.8(SVIN1) PU801.9(PVIN1) PU801.10(PVIN2)
VSS_SENSE: PC406.1 PC407.1 PR416.1 RC142.2 RC143.1
VSSGT_SENSE: PC413.1 PC415.1 PR424.1 RC183.1 RC184.1
VSSIO_SENSE: RC189.1 UC1.AM22(VSSIO_SENSE)
VSSSA_SENSE: PC425.1 PC426.1 PR437.1 RC185.2 RC374.1
18PWRON_R: CV240.1 DV7.2 RV153.2 UV12.3(ON)
+CRD_POWER: CW12.1 CW13.1 JREAD2.4(VDD) UW1.12(CARD_3V3)
+DCPDSW: CC60.1 UC1.AL1(DCPDSW_1P0)
+DCPRTC: CC259.1 UC1.BB10(DCPRTC)
+FBA_VREFC0: CV79.1 RV30.2 RV32.1 UV6.J14(VREFC)
+FBA_VREFC1: CV106.1 RV43.2 RV45.1 UV5.J14(VREFC)
+FBA_VREFD0: CV80.1 RV31.2 RV33.1 UV6.A10(VREFD1) UV6.U10(VREFD2)
+FBA_VREFD1: CV107.1 RV44.2 RV46.1 UV5.A10(VREFD1) UV5.U10(VREFD2)
+FBB_VREFC0: CV133.1 RV55.2 RV57.1 UV7.J14(VREFC)
+FBB_VREFC1: CV160.1 RV68.2 RV70.1 UV8.J14(VREFC)
+FBB_VREFD0: CV134.1 RV56.2 RV58.1 UV7.A10(VREFD1) UV7.U10(VREFD2)
+FBB_VREFD1: CV161.1 RV69.2 RV71.1 UV8.A10(VREFD1) UV8.U10(VREFD2)
+LCDVDD_CON: C9.1 C8534.1 CRF7.1 CRF8.1 JLCD.7 JLCD.8 U3.1(OUT)
+LEDVDD: C12.1 C8533.2 CRF11.1 CRF12.1 JLCD.1 JLCD.2 JLCD.3 R9474.2
+MICBIASB: DA6.2 DA7.2 UA1.34(MICBIASB)
+PCH_CORE: CC96.1 CC271.1 RC304.2 UC1.AF18(VCCPRIM_CORE_AF18) UC1.AF19(VCCPRIM_CORE_AF19) UC1.V20(VCCPRIM_CORE_V20) UC1.V21(VCCPRIM_CORE_V21)
+RTCBATT: D6.1 PD6.1 RC11.1
+RTCVCC: C8542.1 CC2.1 CC59.1 RC11.2 RC12.1 RC14.1 RC16.1 UC1.AK19(VCCRTC_AK19) UC1.BB14(VCCRTC_BB14)
+USB_VCCA: C122.1 C123.1 C8545.1 D7.5(VP) JUSB1.1(VBUS) U15.1(OUT)
+V_DDR_REFA: CD1.1 CD3.1 JDIMM1.1(VREF_DQ) RD1.2 RD2.2 RD3.1
+V_DDR_REFB: CD32.1 CD33.1 JDIMM2.1(VREF_DQ) RD15.2 RD16.1 RD17.2
+VCOREVCC: CE7.2 UE1.12(VCORE)
+VGA_B+: PC602.1 PC603.1 PC606.1 PC607.1 PC611.1 PC623.1 PC624.1 PC625.1 PC626.1 PC627.1 PL601.1 PL602.1 PQ601.5(D) PQ604.5(D)
+VGA_CORE: CV39.1 CV40.1 CV41.1 CV42.1 CV43.1 CV44.1 CV45.1 CV46.1 CV47.1 CV48.1 CV49.1 CV50.1 CV51.1 CV52.1 CV54.1 CV55.1 CV56.1 CV57.1 CV58.1 CV59.1 CV60.1 CV61.1 CV64.1 CV65.1 CV66.1 CV67.1 CV68.1 CV69.1 CV70.1 PC613.1(P) PC614.1(P) PC615.1 PC629.1(P) PC630.1(P) PC631.1 PL603.2 PL604.2 PR618.2 PR622.1 PR636.2 UV1.AA13(VDDCI_1) UV1.AA15(VDDC_1) UV1.AA17(VDDC_2) UV1.AA20(VDDC_3) UV1.AA22(VDDC_4) UV1.AA24(VDDC_5) UV1.AA27(VDDC_6) UV1.AB13(VDDCI_2) UV1.AB16(VDDC_7) UV1.AB18(VDDC_8) UV1.AB21(VDDC_9) UV1.AB23(VDDC_10) UV1.AB26(VDDC_11) UV1.AB28(VDDC_12) UV1.AC12(VDDCI_3) UV1.AC15(VDDCI_4) UV1.AC17(VDDC_13) UV1.AC20(VDDC_14) UV1.AC22(VDDC_15) UV1.AC24(VDDC_16) UV1.AC27(VDDC_17) UV1.AD13(VDDCI_5) UV1.AD16(VDDCI_6) UV1.AD18(VDDC_18) UV1.AD21(VDDC_19) UV1.AD23(VDDC_20) UV1.AD26(VDDC_21) UV1.AF17(VDDC_22) UV1.AF20(VDDC_23) UV1.AF22(VDDC_24) UV1.AG16(VDDC_25) UV1.AG18(VDDC_26) UV1.AH22(VDDC_28) UV1.AH27(VDDC_29) UV1.AH28(VDDC_30) UV1.M15(VDDCI_7) UV1.M16(VDDCI_8) UV1.M18(VDDCI_9) UV1.M23(VDDCI_10) UV1.M26(VDDC_31) UV1.N13(VDDCI_11) UV1.N15(VDDCI_12) UV1.N17(VDDCI_13) UV1.N20(VDDCI_14) UV1.N22(VDDCI_15) UV1.N24(VDDC_32) UV1.R12(VDDCI_16) UV1.R13(VDDCI_17) UV1.R16(VDDCI_18) UV1.R18(VDDC_33) UV1.R21(VDDC_34) UV1.R23(VDDC_35) UV1.R26(VDDC_36) UV1.T12(VDDCI_19) UV1.T15(VDDCI_20) UV1.T17(VDDC_37) UV1.T20(VDDC_38) UV1.T22(VDDC_39) UV1.T24(VDDC_40) UV1.U16(VDDC_41) UV1.U18(VDDC_42) UV1.U21(VDDC_43) UV1.U23(VDDC_44) UV1.U26(VDDC_45) UV1.V15(VDDCI_21) UV1.V17(VDDC_46) UV1.V20(VDDC_47) UV1.V22(VDDC_48) UV1.V24(VDDC_49) UV1.V27(VDDC_50) UV1.Y13(VDDCI_22) UV1.Y16(VDDC_51) UV1.Y18(VDDC_52) UV1.Y21(VDDC_53) UV1.Y23(VDDC_54) UV1.Y26(VDDC_55) UV1.Y28(VDDC_56)
+VREF_CA: CD17.1 CD18.1 CD49.1 JDIMM1.126(VREF_CA) JDIMM2.126(VREF_CA) RD9.2 RD10.1 RD11.1
AC_PRESENT: RPC18.8(R8) UC1.AY15(GPD1/ACPRESENT) UE1.128(CK32K/GPJ6)
ACIN: CE12.1 DEV1.2 RE33.1 RE43.1 UE1.108(AC_IN#)
ACN: PC109.1 PR106.2 PR108.1 PU101.1(ACN)
ACOFF: PR109.1 UE1.98(GPH5/ID5)
ACP: PR107.2 PU101.2(ACP)
ACPRN: DEV1.1 PR118.1 RE43.2
ADAPTER_ID_ON: PQ4.2(G1) PQ4.3(D2) PR5.2 PR8.1
ADAPTER_ID_ON#: PQ4.5(G2) UE1.118(SMDAT2/PECIRQT#/GPF7)
ADDR_SEL: RG5.1 RG8.2 UGSEN1.7(SDO/SA0)
ADP_I: PC125.2 PR122.1 UE1.71(ADC5/DCD1#/GPI5)
ADP_ID: PD4.2 PD5.1 PR7.2 UE1.73(ADC7/CTS1#/GPI7)
ALL_PWRGD: RE41.1 UE1.29(PWM3/GPA3)
AOU_CTL1: AOU1.6(CLT1) UE1.84(EGCLK/GPE3)
AOU_CTL3: AOU1.8(CLT3) UE1.48(TACH1A/TMA1/GPD7)
AOU_EN: AOU1.5(EN) UE1.85(PS2CLK0/TMB0/CEC/GPF0)
AOU_IFG#: AOU1.9(STATUS#) RPE1.7(R7) UE1.25(PWM1/GPA1)
APDIN: JDCIN1.2 JDCIN1.3 JDCIN1.4 PF1.2
AUXN: CVG19.2 UVG2.3(AUX_N)
AUXP: CVG20.2 UVG2.2(AUX_P)
B+: PC105.1 PC106.1 PC110.2 PC111.1 PC112.1 PC113.1 PC114.1 PC525.1(P) PC526.1(P) PC527.1(P) PC528.1(P) PC529.1(P) PD3.2 PD103.2 PJ201.2 PJ203.2 PJ304.2 PJ701.2 PL401.2 PL402.2 PL404.2 PL405.2 PL407.2 PL601.2 PL602.2 PQ104.5(D) PQ106.5(D) PR101.2 PR106.1 PR401.1 R9474.1
B+_1.35V: PC302.1 PC303.1 PC304.1 PC305.1 PC306.1 PC307.1 PJ304.1 PQ301.5(D) PR309.1
BATLOW#: RPC18.7(R7) UC1.AU13(GPD0/BATLOW#)
BATT+: PC10.2 PC119.2 PC120.2 PC123.1 PC124.2 PL3.2 PL4.2 PR117.2 PR128.1
BATT_TEMP: CE16.1 PR17.2 PU101.15(BATPRES#) UE1.68(ADC2/GPI2)
BEEP#: CA22.1 DA1.2 UE1.32(PWM6/SSCK/GPA6)
BKOFF#: JLCD.11 R26.1 UE1.119(CRX0/GPC0)
BOARD_ID: RE3.1 RE7.1 UE1.69(ADC3/GPI3)
BQ24780_BATDRV: PC108.2 PQ104.4(G) PR103.1 PU101.18(BATDRV)
BQ24780_VDD: PC116.1 PU101.24(REGN)
BST_1.00VS: PR707.1 PU701.5(BST)
BST_CHG: PR116.1 PU101.25(BTST)
BT_ON: R239.2 RPC9.4(R4) UC1.AP5(GPP_B21/GSPI1_MISO)
BT_ON_R: JWLBT.54(RESERVED/W_DISABLE#2) R90.1 R151.2 R239.1
BYPASS_PAD: JCP.12 R61.2 R66.2 R105.2
CEC: TPV16.1 UV1.AC30(CEC_1)
CFG0: RC105.2 RC201.2 TC30.1 UC1.E68(CFG[0])
CFG1: TC43.1 UC1.B67(CFG[1])
CFG1_DP: RVG132.2 RVG134.1 UVG2.12(CFG1)
CFG2: TC44.1 UC1.D65(CFG[2])
CFG2_DP: RVG133.2 RVG135.1 UVG2.15(CFG2)
CFG3: TC33.1 UC1.D67(CFG[3])
CFG4: RC104.2 RC144.2 TC34.1 UC1.E70(CFG[4])
CFG5: TC35.1 UC1.C68(CFG[5])
CFG6: TC36.1 UC1.D68(CFG[6])
CFG7: TC47.1 UC1.C67(CFG[7])
CFG8: TC48.1 UC1.F71(CFG[8])
CFG9: TC39.1 UC1.G69(CFG[9])
CFG10: TC49.1 UC1.F70(CFG[10])
CFG11: TC40.1 UC1.G68(CFG[11])
CFG12: TC41.1 UC1.H70(CFG[12])
CFG13: TC42.1 UC1.G71(CFG[13])
CFG14: TC52.1 UC1.H69(CFG[14])
CFG15: TC54.1 UC1.G70(CFG[15])
CFG16: TC57.1 UC1.E63(CFG[16])
CFG17: TC59.1 UC1.F63(CFG[17])
CFG18: TC61.1 UC1.E66(CFG[18])
CFG19: TC63.1 UC1.F66(CFG[19])
CFG_RCOMP: RC152.1 UC1.E60(CFG_RCOMP)
CHG: PC108.1 PC122.1 PC124.1 PL102.2 PQ104.1(S1) PQ104.2(S2) PQ104.3(S3) PR103.2 PR117.1 PR125.1 PU101.17(BATSRC)
CL_CLK_WLAN: JWLBT.42(RESERVED3) UC1.G3(CL_CLK)
CL_DATA_WLAN: JWLBT.40(RESERVED2) R151.1 UC1.G2(CL_DATA)
CL_RST_WLAN#: JWLBT.38(RESERVED1) R152.1 UC1.G1(CL_RST#)
CLK_PCI_EC: RC24.2 RE38.2 UE1.13(LPCCLK/GPM4)
CLK_PCIE_CR: UC1.E38(CLKOUT_PCIE_P5) UW1.5(REFCLKP)
CLK_PCIE_CR#: UC1.E40(CLKOUT_PCIE_N5) UW1.6(REFCLKN)
CLK_PCIE_LAN: UC1.C40(CLKOUT_PCIE_P3) UL1.44(PE_CLKP)
CLK_PCIE_LAN#: UC1.D40(CLKOUT_PCIE_N3) UL1.45(PE_CLKN)
CLK_PCIE_VGA: RV4.1 UC1.A40(CLKOUT_PCIE_P4)
CLK_PCIE_VGA#: RV5.1 UC1.B40(CLKOUT_PCIE_N4)
CLK_PCIE_WLAN: JWLBT.47(REFCLKP0) UC1.C41(CLKOUT_PCIE_P2)
CLK_PCIE_WLAN#: JWLBT.49(REFCLKN0) UC1.D41(CLKOUT_PCIE_N2)
CLK_REQ_GPU#: QV1.3(S) RV14.2 RV15.2 RV16.2 RV129.1
CLKOUT_ITPXDP_N: TC16.1 UC1.F43(CLKOUT_ITPXDP_N)
CLKOUT_ITPXDP_P: TC17.1 UC1.E43(CLKOUT_ITPXDP_P)
CLKREQ_PCIE2_WLAN#: JWLBT.53(CLKREQ0#) RPC200.8(R8) UC1.AT8(GPP_B7/SRCCLKREQ2#)
CLKREQ_PCIE3_LAN#: RPC200.7(R7) UC1.AT10(GPP_B8/SRCCLKREQ3#) UL1.48(CLK_REQ_N)
CLKREQ_PCIE4_VGA#: CV20.1 QV1.1(D) RC165.2 RC166.2 RV16.1 UC1.AU8(GPP_B9/SRCCLKREQ4#)
CLKREQ_PCIE5_CR#: RPC200.5(R5) UC1.AU7(GPP_B10/SRCCLKREQ5#) UW1.2(CLK_REQ#)
CLKRUN#: RC52.1 UC1.AW11(GPP_A8/CLKRUN#)
CP_BYPASS: R105.1 RC413.1 RC428.1 RC431.2
CP_BYPASS_EC: RC431.1 UE1.67(ADC1/GPI1)
CP_BYPASS_R: RC428.2 UC1.AB2(GPP_C9/UART0_TXD)
CP_CLK: C44.1 JCP.9 RE5.1 UE1.89(PS2CLK2/GPF4)
CP_DATA: C45.1 JCP.10 RE6.1 UE1.90(PS2DAT2/GPF5)
CP_RESET#: JCP.8 R67.2 RC427.2 RC430.1
CP_RESET#_EC: RC430.2 UE1.35(RTS1#/GPE5)
CP_RESET#_R: RC427.1 UC1.P3(GPP_D10)
CPU_EDP_AUX: C18.1 UC1.F45(EDP_AUXP)
CPU_EDP_AUX#: C17.1 UC1.E45(EDP_AUXN)
CPU_EDP_AUX#_CON: C17.2 JLCD.20
CPU_EDP_AUX_CON: C18.2 JLCD.21
CPU_EDP_HPD: JLCD.22 RC159.1 UC1.L10(GPP_E17/EDP_HPD)
CPU_EDP_TX0+: C16.1 UC1.C46(EDP_TXP[0])
CPU_EDP_TX0+_CON: C16.2 JLCD.29
CPU_EDP_TX0-: C15.1 UC1.C47(EDP_TXN[0])
CPU_EDP_TX0-_CON: C15.2 JLCD.28
CPU_EDP_TX1+: C14.1 UC1.C45(EDP_TXP[1])
CPU_EDP_TX1+_CON: C14.2 JLCD.26
CPU_EDP_TX1-: C13.1 UC1.D46(EDP_TXN[1])
CPU_EDP_TX1-_CON: C13.2 JLCD.25
CSB_1B: PC429.2 PC439.2 PR460.2 PRT405.2 PU401.41(CSN_1B)
CSN1: PR423.2 PR456.2
CSN_1A: PC405.2 PC440.2 PR452.2 PRT401.2 PU401.28(CSN_1A)
CSP1: PR422.2 PR426.2 PR455.2
DDI1_MUX_TX0+: CX4.1 UC1.F55(DDI1_TXP[0])
DDI1_MUX_TX0+_R: CX4.2 UX1.3(IN_D0P)
DDI1_MUX_TX0-: CX3.1 UC1.E55(DDI1_TXN[0])
DDI1_MUX_TX0-_R: CX3.2 UX1.4(IN_D0N)
DDI1_MUX_TX1+: CX6.1 UC1.F58(DDI1_TXP[1])
DDI1_MUX_TX1+_R: CX6.2 UX1.6(IN_D1P)
DDI1_MUX_TX1-: CX5.1 UC1.E58(DDI1_TXN[1])
DDI1_MUX_TX1-_R: CX5.2 UX1.7(IN_D1N)
DDI1_MUX_TX2+: CX8.1 UC1.G53(DDI1_TXP[2])
DDI1_MUX_TX2+_R: CX8.2 UX1.9(IN_D2P)
DDI1_MUX_TX2-: CX7.1 UC1.F53(DDI1_TXN[2])
DDI1_MUX_TX2-_R: CX7.2 UX1.10(IN_D2N)
DDI1_MUX_TX3+: CX10.1 UC1.G56(DDI1_TXP[3])
DDI1_MUX_TX3+_R: CX10.2 UX1.12(IN_D3P)
DDI1_MUX_TX3-: CX9.1 UC1.F56(DDI1_TXN[3])
DDI1_MUX_TX3-_R: CX9.2 UX1.13(IN_D3N)
DDI2_VGA_TX0+: CVG16.1 UC1.D50(DDI2_TXP[0])
DDI2_VGA_TX0-: CVG15.1 UC1.C50(DDI2_TXN[0])
DDI2_VGA_TX1+: CVG18.1 UC1.D52(DDI2_TXP[1])
DDI2_VGA_TX1-: CVG17.1 UC1.C52(DDI2_TXN[1])
DDR3_DRAMRST#: CD59.1 CD60.1 JDIMM1.30(RESET#) JDIMM2.30(RESET#) RD21.2 UC1.AT13(DRAM_RESET#)
DDR_A_BS0: JDIMM1.109(BA0) UC1.AU52(DDR0_BA[0]/DDR0_CAB[4]/DDR0_BA[)
DDR_A_BS1: JDIMM1.108(BA1) UC1.AT48(DDR0_BA[1]/DDR0_CAB[6]/DDR0_BA[)
DDR_A_BS2: JDIMM1.79(BA2) UC1.AY55(DDR0_BA[2]/DDR0_CAA[5]/DDR0_BG[)
DDR_A_CAS#: JDIMM1.115(CAS#) UC1.AU48(DDR0_CAS#/DDR0_CAB[1]/DDR0_MA[1)
DDR_A_D0: JDIMM1.5(DQ0) UC1.AL71(DDR0_DQ[0])
DDR_A_D1: JDIMM1.7(DQ1) UC1.AL68(DDR0_DQ[1])
DDR_A_D2: JDIMM1.15(DQ2) UC1.AN68(DDR0_DQ[2])
DDR_A_D3: JDIMM1.17(DQ3) UC1.AN69(DDR0_DQ[3])
DDR_A_D4: JDIMM1.4(DQ4) UC1.AL70(DDR0_DQ[4])
DDR_A_D5: JDIMM1.6(DQ5) UC1.AL69(DDR0_DQ[5])
DDR_A_D6: JDIMM1.16(DQ6) UC1.AN70(DDR0_DQ[6])
DDR_A_D7: JDIMM1.18(DQ7) UC1.AN71(DDR0_DQ[7])
DDR_A_D8: JDIMM1.21(DQ8) UC1.AR70(DDR0_DQ[8])
DDR_A_D9: JDIMM1.23(DQ9) UC1.AR68(DDR0_DQ[9])
DDR_A_D10: JDIMM1.33(DQ10) UC1.AU71(DDR0_DQ[10])
DDR_A_D11: JDIMM1.35(DQ11) UC1.AU68(DDR0_DQ[11])
DDR_A_D12: JDIMM1.22(DQ12) UC1.AR71(DDR0_DQ[12])
DDR_A_D13: JDIMM1.24(DQ13) UC1.AR69(DDR0_DQ[13])
DDR_A_D14: JDIMM1.34(DQ14) UC1.AU70(DDR0_DQ[14])
DDR_A_D15: JDIMM1.36(DQ15) UC1.AU69(DDR0_DQ[15])
DDR_A_D16: JDIMM1.39(DQ16) UC1.BB65(DDR0_DQ[16]/DDR0_DQ[32])
DDR_A_D17: JDIMM1.41(DQ17) UC1.AW65(DDR0_DQ[17]/DDR0_DQ[33])
DDR_A_D18: JDIMM1.51(DQ18) UC1.AW63(DDR0_DQ[18]/DDR0_DQ[34])
DDR_A_D19: JDIMM1.53(DQ19) UC1.AY63(DDR0_DQ[19]/DDR0_DQ[35])
DDR_A_D20: JDIMM1.40(DQ20) UC1.BA65(DDR0_DQ[20]/DDR0_DQ[36])
DDR_A_D21: JDIMM1.42(DQ21) UC1.AY65(DDR0_DQ[21]/DDR0_DQ[37])
DDR_A_D22: JDIMM1.50(DQ22) UC1.BA63(DDR0_DQ[22]/DDR0_DQ[38])
DDR_A_D23: JDIMM1.52(DQ23) UC1.BB63(DDR0_DQ[23]/DDR0_DQ[39])
DDR_A_D24: JDIMM1.57(DQ24) UC1.BA61(DDR0_DQ[24]/DDR0_DQ[40])
DDR_A_D25: JDIMM1.59(DQ25) UC1.AW61(DDR0_DQ[25]/DDR0_DQ[41])
DDR_A_D26: JDIMM1.67(DQ26) UC1.BB59(DDR0_DQ[26]/DDR0_DQ[42])
DDR_A_D27: JDIMM1.69(DQ27) UC1.AW59(DDR0_DQ[27]/DDR0_DQ[43])
DDR_A_D28: JDIMM1.56(DQ28) UC1.BB61(DDR0_DQ[28]/DDR0_DQ[44])
DDR_A_D29: JDIMM1.58(DQ29) UC1.AY61(DDR0_DQ[29]/DDR0_DQ[45])
DDR_A_D30: JDIMM1.68(DQ30) UC1.BA59(DDR0_DQ[30]/DDR0_DQ[46])
DDR_A_D31: JDIMM1.70(DQ31) UC1.AY59(DDR0_DQ[31]/DDR0_DQ[47])
DDR_A_D32: JDIMM1.129(DQ32) UC1.AY39(DDR0_DQ[32]/DDR1_DQ[0])
DDR_A_D33: JDIMM1.131(DQ33) UC1.AW39(DDR0_DQ[33]/DDR1_DQ[1])
DDR_A_D34: JDIMM1.141(DQ34) UC1.AY37(DDR0_DQ[34]/DDR1_DQ[2])
DDR_A_D35: JDIMM1.143(DQ35) UC1.AW37(DDR0_DQ[35]/DDR1_DQ[3])
DDR_A_D36: JDIMM1.130(DQ36) UC1.BB39(DDR0_DQ[36]/DDR1_DQ[4])
DDR_A_D37: JDIMM1.132(DQ37) UC1.BA39(DDR0_DQ[37]/DDR1_DQ[5])
DDR_A_D38: JDIMM1.140(DQ38) UC1.BA37(DDR0_DQ[38]/DDR1_DQ[6])
DDR_A_D39: JDIMM1.142(DQ39) UC1.BB37(DDR0_DQ[39]/DDR1_DQ[7])
DDR_A_D40: JDIMM1.147(DQ40) UC1.AY35(DDR0_DQ[40]/DDR1_DQ[8])
DDR_A_D41: JDIMM1.149(DQ41) UC1.AW35(DDR0_DQ[41]/DDR1_DQ[9])
DDR_A_D42: JDIMM1.157(DQ42) UC1.AY33(DDR0_DQ[42]/DDR1_DQ[10])
DDR_A_D43: JDIMM1.159(DQ43) UC1.AW33(DDR0_DQ[43]/DDR1_DQ[11])
DDR_A_D44: JDIMM1.146(DQ44) UC1.BB35(DDR0_DQ[44]/DDR1_DQ[12])
DDR_A_D45: JDIMM1.148(DQ45) UC1.BA35(DDR0_DQ[45]/DDR1_DQ[13])
DDR_A_D46: JDIMM1.158(DQ46) UC1.BA33(DDR0_DQ[46]/DDR1_DQ[14])
DDR_A_D47: JDIMM1.160(DQ47) UC1.BB33(DDR0_DQ[47]/DDR1_DQ[15])
DDR_A_D48: JDIMM1.163(DQ48) UC1.AY31(DDR0_DQ[48]/DDR1_DQ[32])
DDR_A_D49: JDIMM1.165(DQ49) UC1.AW31(DDR0_DQ[49]/DDR1_DQ[33])
DDR_A_D50: JDIMM1.175(DQ50) UC1.AY29(DDR0_DQ[50]/DDR1_DQ[34])
DDR_A_D51: JDIMM1.177(DQ51) UC1.AW29(DDR0_DQ[51]/DDR1_DQ[35])
DDR_A_D52: JDIMM1.164(DQ52) UC1.BB31(DDR0_DQ[52]/DDR1_DQ[36])
DDR_A_D53: JDIMM1.166(DQ53) UC1.BA31(DDR0_DQ[53]/DDR1_DQ[37])
DDR_A_D54: JDIMM1.174(DQ54) UC1.BA29(DDR0_DQ[54]/DDR1_DQ[38])
DDR_A_D55: JDIMM1.176(DQ55) UC1.BB29(DDR0_DQ[55]/DDR1_DQ[39])
DDR_A_D56: JDIMM1.181(DQ56) UC1.AY27(DDR0_DQ[56]/DDR1_DQ[40])
DDR_A_D57: JDIMM1.183(DQ57) UC1.AW27(DDR0_DQ[57]/DDR1_DQ[41])
DDR_A_D58: JDIMM1.191(DQ58) UC1.AY25(DDR0_DQ[58]/DDR1_DQ[42])
DDR_A_D59: JDIMM1.193(DQ59) UC1.AW25(DDR0_DQ[59]/DDR1_DQ[43])
DDR_A_D60: JDIMM1.180(DQ60) UC1.BB27(DDR0_DQ[60]/DDR1_DQ[44])
DDR_A_D61: JDIMM1.182(DQ61) UC1.BA27(DDR0_DQ[61]/DDR1_DQ[45])
DDR_A_D62: JDIMM1.192(DQ62) UC1.BA25(DDR0_DQ[62]/DDR1_DQ[46])
DDR_A_D63: JDIMM1.194(DQ63) UC1.BB25(DDR0_DQ[63]/DDR1_DQ[47])
DDR_A_DQS0: JDIMM1.12(DQS0) UC1.AM69(DDR0_DQSP[0])
DDR_A_DQS1: JDIMM1.29(DQS1) UC1.AT70(DDR0_DQSP[1])
DDR_A_DQS2: JDIMM1.47(DQS2) UC1.AY64(DDR0_DQSP[2]/DDR0_DQSP[4])
DDR_A_DQS3: JDIMM1.64(DQS3) UC1.BA60(DDR0_DQSP[3]/DDR0_DQSP[5])
DDR_A_DQS4: JDIMM1.137(DQS4) UC1.AY38(DDR0_DQSP[4]/DDR1_DQSP[0])
DDR_A_DQS5: JDIMM1.154(DQS5) UC1.BA34(DDR0_DQSP[5]/DDR1_DQSP[1])
DDR_A_DQS6: JDIMM1.171(DQS6) UC1.AY30(DDR0_DQSP[6]/DDR1_DQSP[4])
DDR_A_DQS7: JDIMM1.188(DQS7) UC1.BA26(DDR0_DQSP[7]/DDR1_DQSP[5])
DDR_A_DQS#0: JDIMM1.10(DQS#0) UC1.AM70(DDR0_DQSN[0])
DDR_A_DQS#1: JDIMM1.27(DQS#1) UC1.AT69(DDR0_DQSN[1])
DDR_A_DQS#2: JDIMM1.45(DQS#2) UC1.BA64(DDR0_DQSN[2]/DDR0_DQSN[4])
DDR_A_DQS#3: JDIMM1.62(DQS#3) UC1.AY60(DDR0_DQSN[3]/DDR0_DQSN[5])
DDR_A_DQS#4: JDIMM1.135(DQS#4) UC1.BA38(DDR0_DQSN[4]/DDR1_DQSN[0])
DDR_A_DQS#5: JDIMM1.152(DQS#5) UC1.AY34(DDR0_DQSN[5]/DDR1_DQSN[1])
DDR_A_DQS#6: JDIMM1.169(DQS#6) UC1.BA30(DDR0_DQSN[6]/DDR1_DQSN[4])
DDR_A_DQS#7: JDIMM1.186(DQS#7) UC1.AY26(DDR0_DQSN[7]/DDR1_DQSN[5])
DDR_A_MA0: JDIMM1.98(A0) UC1.AY50(DDR0_MA[0]/DDR0_CAB[9]/DDR0_MA[)
DDR_A_MA1: JDIMM1.97(A1) UC1.BB50(DDR0_MA[1]/DDR0_CAB[8]/DDR0_MA[)
DDR_A_MA2: JDIMM1.96(A2) UC1.AY51(DDR0_MA[2]/DDR0_CAB[5]/DDR0_MA[)
DDR_A_MA3: JDIMM1.95(A3) UC1.BA50(DDR0_MA[3])
DDR_A_MA4: JDIMM1.92(A4) UC1.BB52(DDR0_MA[4])
DDR_A_MA5: JDIMM1.91(A5) UC1.BA51(DDR0_MA[5]/DDR0_CAA[0]/DDR0_MA[)
DDR_A_MA6: JDIMM1.90(A6) UC1.BA52(DDR0_MA[6]/DDR0_CAA[2]/DDR0_MA[)
DDR_A_MA7: JDIMM1.86(A7) UC1.AW52(DDR0_MA[7]/DDR0_CAA[4]/DDR0_MA[)
DDR_A_MA8: JDIMM1.89(A8) UC1.AY52(DDR0_MA[8]/DDR0_CAA[3]/DDR0_MA[)
DDR_A_MA9: JDIMM1.85(A9) UC1.BB54(DDR0_MA[9]/DDR0_CAA[1]/DDR0_MA[)
DDR_A_MA10: JDIMM1.107(A10/AP) UC1.AT50(DDR0_MA[10]/DDR0_CAB[7]/DDR0_MA)
DDR_A_MA11: JDIMM1.84(A11) UC1.BA54(DDR0_MA[11]/DDR0_CAA[7]/DDR0_MA)
DDR_A_MA12: JDIMM1.83(A12/BC#) UC1.AW54(DDR0_MA[12]/DDR0_CAA[6]/DDR0_MA)
DDR_A_MA13: JDIMM1.119(A13) UC1.AU46(DDR0_MA[13]/DDR0_CAB[0]/DDR0_MA)
DDR_A_MA14: JDIMM1.80(A14) UC1.AY54(DDR0_MA[14]/DDR0_CAA[9]/DDR0_BG)
DDR_A_MA15: JDIMM1.78(A15) UC1.BA55(DDR0_MA[15]/DDR0_CAA[8]/DDR0_AC)
DDR_A_RAS#: JDIMM1.110(RAS#) UC1.AU50(DDR0_RAS#/DDR0_CAB[3]/DDR0_MA[1)
DDR_A_WE#: JDIMM1.113(WE#) UC1.AT46(DDR0_WE#/DDR0_CAB[2]/DDR0_MA[14)
DDR_B_BS0: JDIMM2.109(BA0) UC1.BB44(DDR1_BA[0]/DDR1_CAB[4]/DDR1_BA[)
DDR_B_BS1: JDIMM2.108(BA1) UC1.BA44(DDR1_BA[1]/DDR1_CAB[6]/DDR1_BA[)
DDR_B_BS2: JDIMM2.79(BA2) UC1.AP52(DDR1_BA[2]/DDR1_CAA[5]/DDR1_BG[)
DDR_B_CAS#: JDIMM2.115(CAS#) UC1.AY43(DDR1_CAS#/DDR1_CAB[1]/DDR1_MA[1)
DDR_B_D0: JDIMM2.21(DQ8) UC1.AF65(DDR1_DQ[0]/DDR0_DQ[16])
DDR_B_D1: JDIMM2.23(DQ9) UC1.AF64(DDR1_DQ[1]/DDR0_DQ[17])
DDR_B_D2: JDIMM2.33(DQ10) UC1.AK65(DDR1_DQ[2]/DDR0_DQ[18])
DDR_B_D3: JDIMM2.35(DQ11) UC1.AK64(DDR1_DQ[3]/DDR0_DQ[19])
DDR_B_D4: JDIMM2.22(DQ12) UC1.AF66(DDR1_DQ[4]/DDR0_DQ[20])
DDR_B_D5: JDIMM2.24(DQ13) UC1.AF67(DDR1_DQ[5]/DDR0_DQ[21])
DDR_B_D6: JDIMM2.34(DQ14) UC1.AK67(DDR1_DQ[6]/DDR0_DQ[22])
DDR_B_D7: JDIMM2.36(DQ15) UC1.AK66(DDR1_DQ[7]/DDR0_DQ[23])
DDR_B_D8: JDIMM2.5(DQ0) UC1.AF70(DDR1_DQ[8]/DDR0_DQ[24])
DDR_B_D9: JDIMM2.7(DQ1) UC1.AF68(DDR1_DQ[9]/DDR0_DQ[25])
DDR_B_D10: JDIMM2.15(DQ2) UC1.AH71(DDR1_DQ[10]/DDR0_DQ[26])
DDR_B_D11: JDIMM2.17(DQ3) UC1.AH68(DDR1_DQ[11]/DDR0_DQ[27])
DDR_B_D12: JDIMM2.4(DQ4) UC1.AF71(DDR1_DQ[12]/DDR0_DQ[28])
DDR_B_D13: JDIMM2.6(DQ5) UC1.AF69(DDR1_DQ[13]/DDR0_DQ[29])
DDR_B_D14: JDIMM2.16(DQ6) UC1.AH70(DDR1_DQ[14]/DDR0_DQ[30])
DDR_B_D15: JDIMM2.18(DQ7) UC1.AH69(DDR1_DQ[15]/DDR0_DQ[31])
DDR_B_D16: JDIMM2.39(DQ16) UC1.AT66(DDR1_DQ[16]/DDR0_DQ[48])
DDR_B_D17: JDIMM2.41(DQ17) UC1.AU66(DDR1_DQ[17]/DDR0_DQ[49])
DDR_B_D18: JDIMM2.51(DQ18) UC1.AP65(DDR1_DQ[18]/DDR0_DQ[50])
DDR_B_D19: JDIMM2.53(DQ19) UC1.AN65(DDR1_DQ[19]/DDR0_DQ[51])
DDR_B_D20: JDIMM2.40(DQ20) UC1.AN66(DDR1_DQ[20]/DDR0_DQ[52])
DDR_B_D21: JDIMM2.42(DQ21) UC1.AP66(DDR1_DQ[21]/DDR0_DQ[53])
DDR_B_D22: JDIMM2.50(DQ22) UC1.AT65(DDR1_DQ[22]/DDR0_DQ[54])
DDR_B_D23: JDIMM2.52(DQ23) UC1.AU65(DDR1_DQ[23]/DDR0_DQ[55])
DDR_B_D24: JDIMM2.57(DQ24) UC1.AT61(DDR1_DQ[24]/DDR0_DQ[56])
DDR_B_D25: JDIMM2.59(DQ25) UC1.AU61(DDR1_DQ[25]/DDR0_DQ[57])
DDR_B_D26: JDIMM2.67(DQ26) UC1.AP60(DDR1_DQ[26]/DDR0_DQ[58])
DDR_B_D27: JDIMM2.69(DQ27) UC1.AN60(DDR1_DQ[27]/DDR0_DQ[59])
DDR_B_D28: JDIMM2.56(DQ28) UC1.AN61(DDR1_DQ[28]/DDR0_DQ[60])
DDR_B_D29: JDIMM2.58(DQ29) UC1.AP61(DDR1_DQ[29]/DDR0_DQ[61])
DDR_B_D30: JDIMM2.68(DQ30) UC1.AT60(DDR1_DQ[30]/DDR0_DQ[62])
DDR_B_D31: JDIMM2.70(DQ31) UC1.AU60(DDR1_DQ[31]/DDR0_DQ[63])
DDR_B_D32: JDIMM2.129(DQ32) UC1.AU40(DDR1_DQ[32]/DDR1_DQ[16])
DDR_B_D33: JDIMM2.131(DQ33) UC1.AT40(DDR1_DQ[33]/DDR1_DQ[17])
DDR_B_D34: JDIMM2.141(DQ34) UC1.AT37(DDR1_DQ[34]/DDR1_DQ[18])
DDR_B_D35: JDIMM2.143(DQ35) UC1.AU37(DDR1_DQ[35]/DDR1_DQ[19])
DDR_B_D36: JDIMM2.130(DQ36) UC1.AR40(DDR1_DQ[36]/DDR1_DQ[20])
DDR_B_D37: JDIMM2.132(DQ37) UC1.AP40(DDR1_DQ[37]/DDR1_DQ[21])
DDR_B_D38: JDIMM2.140(DQ38) UC1.AP37(DDR1_DQ[38]/DDR1_DQ[22])
DDR_B_D39: JDIMM2.142(DQ39) UC1.AR37(DDR1_DQ[39]/DDR1_DQ[23])
DDR_B_D40: JDIMM2.147(DQ40) UC1.AT33(DDR1_DQ[40]/DDR1_DQ[24])
DDR_B_D41: JDIMM2.149(DQ41) UC1.AU33(DDR1_DQ[41]/DDR1_DQ[25])
DDR_B_D42: JDIMM2.157(DQ42) UC1.AU30(DDR1_DQ[42]/DDR1_DQ[26])
DDR_B_D43: JDIMM2.159(DQ43) UC1.AT30(DDR1_DQ[43]/DDR1_DQ[27])
DDR_B_D44: JDIMM2.146(DQ44) UC1.AR33(DDR1_DQ[44]/DDR1_DQ[28])
DDR_B_D45: JDIMM2.148(DQ45) UC1.AP33(DDR1_DQ[45]/DDR1_DQ[29])
DDR_B_D46: JDIMM2.158(DQ46) UC1.AR30(DDR1_DQ[46]/DDR1_DQ[30])
DDR_B_D47: JDIMM2.160(DQ47) UC1.AP30(DDR1_DQ[47]/DDR1_DQ[31])
DDR_B_D48: JDIMM2.163(DQ48) UC1.AU27(DDR1_DQ[48])
DDR_B_D49: JDIMM2.165(DQ49) UC1.AT27(DDR1_DQ[49])
DDR_B_D50: JDIMM2.175(DQ50) UC1.AT25(DDR1_DQ[50])
DDR_B_D51: JDIMM2.177(DQ51) UC1.AU25(DDR1_DQ[51])
DDR_B_D52: JDIMM2.164(DQ52) UC1.AP27(DDR1_DQ[52])
DDR_B_D53: JDIMM2.166(DQ53) UC1.AN27(DDR1_DQ[53])
DDR_B_D54: JDIMM2.174(DQ54) UC1.AN25(DDR1_DQ[54])
DDR_B_D55: JDIMM2.176(DQ55) UC1.AP25(DDR1_DQ[55])
DDR_B_D56: JDIMM2.181(DQ56) UC1.AT22(DDR1_DQ[56])
DDR_B_D57: JDIMM2.183(DQ57) UC1.AU22(DDR1_DQ[57])
DDR_B_D58: JDIMM2.191(DQ58) UC1.AU21(DDR1_DQ[58])
DDR_B_D59: JDIMM2.193(DQ59) UC1.AT21(DDR1_DQ[59])
DDR_B_D60: JDIMM2.180(DQ60) UC1.AN22(DDR1_DQ[60])
DDR_B_D61: JDIMM2.182(DQ61) UC1.AP22(DDR1_DQ[61])
DDR_B_D62: JDIMM2.192(DQ62) UC1.AP21(DDR1_DQ[62])
DDR_B_D63: JDIMM2.194(DQ63) UC1.AN21(DDR1_DQ[63])
DDR_B_DQS0: JDIMM2.29(DQS1) UC1.AH65(DDR1_DQSP[0]/DDR0_DQSP[2])
DDR_B_DQS1: JDIMM2.12(DQS0) UC1.AG70(DDR1_DQSP[1]/DDR0_DQSP[3])
DDR_B_DQS2: JDIMM2.47(DQS2) UC1.AR65(DDR1_DQSP[2]/DDR0_DQSP[6])
DDR_B_DQS3: JDIMM2.64(DQS3) UC1.AR60(DDR1_DQSP[3]/DDR0_DQSP[7])
DDR_B_DQS4: JDIMM2.137(DQS4) UC1.AR38(DDR1_DQSP[4]/DDR1_DQSP[2])
DDR_B_DQS5: JDIMM2.154(DQS5) UC1.AR32(DDR1_DQSP[5]/DDR1_DQSP[3])
DDR_B_DQS6: JDIMM2.171(DQS6) UC1.AR27(DDR1_DQSP[6])
DDR_B_DQS7: JDIMM2.188(DQS7) UC1.AR21(DDR1_DQSP[7])
DDR_B_DQS#0: JDIMM2.27(DQS1#) UC1.AH66(DDR1_DQSN[0]/DDR0_DQSN[2])
DDR_B_DQS#1: JDIMM2.10(DQS0#) UC1.AG69(DDR1_DQSN[1]/DDR0_DQSN[3])
DDR_B_DQS#2: JDIMM2.45(DQS2#) UC1.AR66(DDR1_DQSN[2]/DDR0_DQSN[6])
DDR_B_DQS#3: JDIMM2.62(DQS3#) UC1.AR61(DDR1_DQSN[3]/DDR0_DQSN[7])
DDR_B_DQS#4: JDIMM2.135(DQS4#) UC1.AT38(DDR1_DQSN[4]/DDR1_DQSN[2])
DDR_B_DQS#5: JDIMM2.152(DQS5#) UC1.AT32(DDR1_DQSN[5]/DDR1_DQSN[3])
DDR_B_DQS#6: JDIMM2.169(DQS6#) UC1.AR25(DDR1_DQSN[6])
DDR_B_DQS#7: JDIMM2.186(DQS7#) UC1.AR22(DDR1_DQSN[7])
DDR_B_MA0: JDIMM2.98(A0) UC1.BA46(DDR1_MA[0]/DDR1_CAB[9]/DDR1_MA[)
DDR_B_MA1: JDIMM2.97(A1) UC1.AY46(DDR1_MA[1]/DDR1_CAB[8]/DDR1_MA[)
DDR_B_MA2: JDIMM2.96(A2) UC1.AY47(DDR1_MA[2]/DDR1_CAB[5]/DDR1_MA[)
DDR_B_MA3: JDIMM2.95(A3) UC1.BB46(DDR1_MA[3])
DDR_B_MA4: JDIMM2.92(A4) UC1.BA47(DDR1_MA[4])
DDR_B_MA5: JDIMM2.91(A5) UC1.AY48(DDR1_MA[5]/DDR1_CAA[0]/DDR1_MA[)
DDR_B_MA6: JDIMM2.90(A6) UC1.BA48(DDR1_MA[6]/DDR1_CAA[2]/DDR1_MA[)
DDR_B_MA7: JDIMM2.86(A7) UC1.AP48(DDR1_MA[7]/DDR1_CAA[4]/DDR1_MA[)
DDR_B_MA8: JDIMM2.89(A8) UC1.BB48(DDR1_MA[8]/DDR1_CAA[3]/DDR1_MA[)
DDR_B_MA9: JDIMM2.85(A9) UC1.AP50(DDR1_MA[9]/DDR1_CAA[1]/DDR1_MA[)
DDR_B_MA10: JDIMM2.107(A10/AP) UC1.AW46(DDR1_MA[10]/DDR1_CAB[7]/DDR1_MA)
DDR_B_MA11: JDIMM2.84(A11) UC1.AN48(DDR1_MA[11]/DDR1_CAA[7]/DDR1_MA)
DDR_B_MA12: JDIMM2.83(A12/BC#) UC1.AN50(DDR1_MA[12]/DDR1_CAA[6]/DDR1_MA)
DDR_B_MA13: JDIMM2.119(A13) UC1.BA43(DDR1_MA[13]/DDR1_CAB[0]/DDR1_MA)
DDR_B_MA14: JDIMM2.80(A14) UC1.AN52(DDR1_MA[14]/DDR1_CAA[9]/DDR1_BG)
DDR_B_MA15: JDIMM2.78(A15) UC1.AN53(DDR1_MA[15]/DDR1_CAA[8]/DDR1_AC)
DDR_B_RAS#: JDIMM2.110(RAS#) UC1.AW44(DDR1_RAS#/DDR1_CAB[3]/DDR1_MA[1)
DDR_B_WE#: JDIMM2.113(WE#) UC1.AY44(DDR1_WE#/DDR1_CAB[2]/DDR1_MA[14)
DDR_PG_CTRL: QD1.3(EMITTER) RD24.1 UC1.AW67(DDR_VTT_CNTL)
DDRA_CKE0_DIMMA: JDIMM1.73(CKE0) UC1.BA56(DDR0_CKE[0])
DDRA_CKE1_DIMMA: JDIMM1.74(CKE1) UC1.BB56(DDR0_CKE[1])
DDRA_CS0_DIMMA#: JDIMM1.114(S0#) UC1.AU45(DDR0_CS#[0])
DDRA_CS1_DIMMA#: JDIMM1.121(S1#) UC1.AU43(DDR0_CS#[1])
DDRA_ODT0_DIMMA#: JDIMM1.116(ODT0) UC1.AT45(DDR0_ODT[0])
DDRA_ODT1_DIMMA#: JDIMM1.120(ODT1) UC1.AT43(DDR0_ODT[1])
DDRB_CKE0_DIMMB: JDIMM2.73(CKE0) UC1.AN56(DDR1_CKE[0])
DDRB_CKE1_DIMMB: JDIMM2.74(CKE1) UC1.AP55(DDR1_CKE[1])
DDRB_CS0_DIMMB#: JDIMM2.114(S0#) UC1.BB42(DDR1_CS#[0])
DDRB_CS1_DIMMB#: JDIMM2.121(S1#) UC1.AY42(DDR1_CS#[1])
DDRB_ODT0_DIMMB#: JDIMM2.116(ODT0) UC1.BA42(DDR1_ODT[0])
