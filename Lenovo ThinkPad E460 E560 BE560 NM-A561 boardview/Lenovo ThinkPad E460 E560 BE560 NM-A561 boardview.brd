# Allegro board Lenovo ThinkPad E460 E560 BE560 NM-A561 boardview.brd (continued)
## Nets (continued)
DDRB_ODT1_DIMMB#: JDIMM2.120(ODT1) UC1.AW42(DDR1_ODT[1])
DGPU_HOLD_RST#: RPC9.3(R3) UC1.U9(GPP_C19/I2C1_SCL) UV15.2(IN2)
DGPU_PWREN#: QV19.3(D2) RV161.2 RV163.1 RV164.1
DGPU_PWROK: PR605.1 RC67.2 RC71.1 RC402.1 RC411.1 RV210.2
DGPU_PWROK_R: RC402.2 RC433.2 UC1.BB11(GPP_A7/PIRQA#)
DH_1.35V: PQ301.4(G) PU301.17(UGATE)
DH_CHG: PQ106.4(G) PU101.26(HIDRV)
DIFFCLK_BIASREF: RC379.1 UC1.E42(XCLK_BIASREF)
DISCRETE_PRESENCE: RC29.2 RC32.2 UC1.AR10(GPP_B5/SRCCLKREQ0#)
DL_1.35V: PQ302.4(G) PU301.15(LGATE)
DL_CHG: PQ107.4(G) PU101.23(LODRV)
DMIC_CLK: CA40.1 JLCD.15 RA31.1
DMIC_DATA: CA43.1 JLCD.14 UA1.1(DMIC_DAT/GPIO1)
DMINUS: TPV20.1 UV1.AG29(DMINUS)
DOCK_AUX: JU3LC.1 R107.2 UX1.55(DP_AUXP_SCL)
DOCK_AUX#: JU3LC.2 R106.2 UX1.54(DP_AUXN_SDA)
DOCK_CONSUMP: JU3LF.9 PR108.2
DOCK_TX0+: JU3LC.4 UX1.40(DP_D0P)
DOCK_TX0-: JU3LC.5 UX1.39(DP_D0N)
DOCK_TX1+: JU3LC.7 UX1.37(DP_D1P)
DOCK_TX1-: JU3LC.8 UX1.36(DP_D1N)
DOCKDP_HPD: JU3LF.8 R108.1 UX1.32(DP_HPD)
DP_DDC_CLK: RC1.2 UC1.N7(GPP_E20/DDPC_CTRLCLK)
DP_DDC_DAT: RC2.2 UC1.N8(GPP_E21/DDPC_CTRLDATA)
DP_HPD_R: RVG129.2 UVG2.11(HPD)
DPAB: TPV21.1 UV1.AW28(DPAB_CALR)
DPCD: TPV22.1 UV1.AW18(DPCD_CALR)
DPLS: TPV18.1 UV1.AF29(DPLUS)
DRAM_RST: CV78.1 RV28.2 RV29.1 UV1.AH11(DRAM_RST)
DRVON: PU401.35(DRVON) PU402.3(EN) PU403.3(EN) PU404.3(EN)
EC_AGND: CE2.2 CE3.2 LE2.1 UE1.75(AVSS)
EC_DPWROK: RC286.1 RC383.1 RC392.2 UE1.96(GPH3/ID3)
EC_DPWROK_R: RC286.2 RC373.2 UC1.BB20(DSW_PWROK)
EC_FAN_PWM: JFAN.1 RE8.1 UE1.31(PWM5/GPA5)
EC_FAN_SPEED: JFAN.3 RPE3.7(R7) UE1.47(TACH0A/GPD6)
EC_GS_ON#: RG4.1 UE1.106(SSCE1#/GPG0)
EC_MUTE#: DA5.1 RE31.1 RE32.1 UE1.100(SSCE0#/GPG2)
EC_ON: PR206.1 RE39.1 UE1.83(EGCS#/GPE2)
EC_ON2: PD801.1 PR701.1 PR801.1 RE42.2
EC_ON2_R: RE42.1 UE1.28(PWM2/GPA2)
EC_RSMRST#: RC27.2 RC373.1 UC1.AY17(RSMRST#) UE1.93(CLKRUN#/GPH0/ID0)
EC_RX: R90.2 UE1.16(PWUREQ#/BBO/SMCLK2ALT/GPC7)
EC_SCI#: RPC22.2(R2) UC1.M1(GPP_D0/SPI1_CS#) UE1.23(ECSCI#/GPD3)
EC_SMB_CK1: IT1.1 PR15.2 PR121.1 RPE5.8(R8) UE1.115(SMCLK1/GPC1)
EC_SMB_CK3: JU3LF.6 QC2.1(S1) QG2.6(D1) QV5.6(D1) RPE5.5(R5) RV144.2 U1.10(SCL) UE1.94(CRX1/SIN1/SMCLK3/GPH1/ID1)
EC_SMB_DA1: IT2.1 PR14.2 PR120.1 RPE5.7(R7) UE1.116(SMDAT1/GPC2)
EC_SMB_DA3: JU3LF.5 QC2.4(S2) QG2.3(D2) QV5.3(D2) RPE5.6(R6) RV142.2 U1.9(SDA) UE1.95(CTX1/SOUT1/GPH2/SMDAT3/ID2)
EC_SMCA: JBATT1.3 PD7.3 PR15.1
EC_SMDA: JBATT1.4 PD7.2 PR14.1
EC_TX: R89.2 UE1.17(LPCPD#/GPE6)
EC_TX_R: JWLBT.64(RESERVED4) R89.1 R91.1 R152.2
EC_WAKE#: RC40.1 RE40.2 UE1.2(CK32KE/GPJ7)
EC_WAKE#_L: RC40.2 UC1.A6(GPP_E3/CPU_GP0)
EC_WLAN_WAKE#: JWLBT.55(PEWAKE0#) RPE1.5(R5) UE1.19(L80HLAT/BAO/GPE0)
EDP_COMP: RC344.2 UC1.E52(EDP_RCOMP)
EN_1.8VSP: PC803.1 PD801.2 PR801.2 PR802.2 PU801.5(EN)
ENBKL: RC209.1 UC1.R12(EDP_BKLTEN) UE1.81(DAC5/RIG0#/GPJ5)
EXT_MIC_A: RA14.1 UA1.30(PORTD_A_MIC)
EXT_MIC_B: RA15.1 UA1.31(PORTD_B_MIC)
EXT_PWR_GATE#: TC121.1 UC1.AM10(GPP_B11/EXT_PWR_GATE#)
F1_LED#: JKB.27 UC1.AC2(GPP_C13/UART1_TXD/ISH_UART1_TXD)
F4_LED#: JKB.28 UC1.AD3(GPP_C22/UART2_RTS#)
FAN_ID: JFAN.5 RPE2.6(R6) UE1.70(ADC4/GPI4)
FB_1.35V: PC314.2 PR305.2 PR307.1 PU301.6(FB)
FBA0_DBI0#: UV1.A34(DDBIA0_0/QSA0_0B) UV6.D2(DBI0#                DBI3#)
FBA0_DBI1#: UV1.E30(DDBIA0_1/QSA0_1B) UV6.D13(DBI1#                DBI2#)
FBA0_DBI2#: UV1.E26(DDBIA0_2/QSA0_2B) UV6.P13(DBI2#                DBI1#)
FBA0_DBI3#: UV1.C20(DDBIA0_3/QSA0_3B) UV6.P2(DBI3#                DBI0#)
FBA0_EDC0: UV1.C34(EDCA0_0/QSA0_0) UV6.C2(EDC0                EDC3)
FBA0_EDC1: UV1.D29(EDCA0_1/QSA0_1) UV6.C13(EDC1                EDC2)
FBA0_EDC2: UV1.D25(EDCA0_2/QSA0_2) UV6.R13(EDC2                EDC1)
FBA0_EDC3: UV1.E20(EDCA0_3/QSA0_3) UV6.R2(EDC3                EDC0)
FBA1_D0: UV1.C18(DQA1_0) UV5.A2(DQ25              DQ1)
FBA1_D1: UV1.A18(DQA1_1) UV5.B2(DQ27              DQ3)
FBA1_D2: UV1.F18(DQA1_2) UV5.E2(DQ29              DQ5)
FBA1_D3: UV1.D17(DQA1_3) UV5.F2(DQ31              DQ7)
FBA1_D4: UV1.A16(DQA1_4) UV5.A4(DQ24              DQ0)
FBA1_D5: UV1.F16(DQA1_5) UV5.E4(DQ28              DQ4)
FBA1_D6: UV1.D15(DQA1_6) UV5.F4(DQ30              DQ6)
FBA1_D7: UV1.E14(DQA1_7) UV5.B4(DQ26              DQ2)
FBA1_D8: UV1.F14(DQA1_8) UV5.A11(DQ16              DQ8)
FBA1_D9: UV1.D13(DQA1_9) UV5.A13(DQ17              DQ9)
FBA1_D10: UV1.F12(DQA1_10) UV5.B11(DQ18           DQ10)
FBA1_D11: UV1.A12(DQA1_11) UV5.B13(DQ19           DQ11)
FBA1_D12: UV1.D11(DQA1_12) UV5.E13(DQ21           DQ13)
FBA1_D13: UV1.F10(DQA1_13) UV5.F11(DQ22           DQ14)
FBA1_D14: UV1.A10(DQA1_14) UV5.F13(DQ23           DQ15)
FBA1_D15: UV1.C10(DQA1_15) UV5.E11(DQ20           DQ12)
FBA1_D16: UV1.G13(DQA1_16) UV5.M13(DQ15           DQ23)
FBA1_D17: UV1.H13(DQA1_17) UV5.N13(DQ13           DQ21)
FBA1_D18: UV1.J13(DQA1_18) UV5.M11(DQ14           DQ22)
FBA1_D19: UV1.H11(DQA1_19) UV5.N11(DQ12           DQ20)
FBA1_D20: UV1.G10(DQA1_20) UV5.U13(DQ9             DQ17)
FBA1_D21: UV1.G8(DQA1_21) UV5.T13(DQ11           DQ19)
FBA1_D22: UV1.K9(DQA1_22) UV5.T11(DQ10           DQ18)
FBA1_D23: UV1.K10(DQA1_23) UV5.U11(DQ8             DQ16)
FBA1_D24: UV1.G9(DQA1_24) UV5.T4(DQ2             DQ26)
FBA1_D25: UV1.A8(DQA1_25) UV5.U4(DQ0             DQ24)
FBA1_D26: UV1.C8(DQA1_26) UV5.T2(DQ3             DQ27)
FBA1_D27: UV1.E8(DQA1_27) UV5.U2(DQ1             DQ25)
FBA1_D28: UV1.A6(DQA1_28) UV5.N4(DQ4             DQ28)
FBA1_D29: UV1.C6(DQA1_29) UV5.N2(DQ5             DQ29)
FBA1_D30: UV1.E6(DQA1_30) UV5.M4(DQ6             DQ30)
FBA1_D31: UV1.A5(DQA1_31) UV5.M2(DQ7             DQ31)
FBA1_DBI0#: UV1.C16(DDBIA1_0/QSA1_0B) UV5.D2(DBI0#                DBI3#)
FBA1_DBI1#: UV1.C12(DDBIA1_1/QSA1_1B) UV5.D13(DBI1#                DBI2#)
FBA1_DBI2#: UV1.J11(DDBIA1_2/QSA1_2B) UV5.P13(DBI2#                DBI1#)
FBA1_DBI3#: UV1.F8(DDBIA1_3/QSA1_3B) UV5.P2(DBI3#                DBI0#)
FBA1_EDC0: UV1.E16(EDCA1_0/QSA1_0) UV5.C2(EDC0                EDC3)
FBA1_EDC1: UV1.E12(EDCA1_1/QSA1_1) UV5.C13(EDC1                EDC2)
FBA1_EDC2: UV1.J10(EDCA1_2/QSA1_2) UV5.R13(EDC2                EDC1)
FBA1_EDC3: UV1.D7(EDCA1_3/QSA1_3) UV5.R2(EDC3                EDC0)
FBA_ADBIA0: UV1.J21(ADBIA0/ODTA0) UV6.J4(ABI#)
FBA_ADBIA1: UV1.G19(ADBIA1/ODTA1) UV5.J4(ABI#)
FBA_CASA0#: UV1.K20(CASA0B) UV6.L3(CAS#                 RAS#)
FBA_CASA1#: UV1.K17(CASA1B) UV5.G3(RAS#                 CAS#)
FBA_CKEA0: UV1.K21(CKEA0) UV6.J3(CKE#)
FBA_CKEA1: UV1.J20(CKEA1) UV5.J3(CKE#)
FBA_CLKA0: RV41.1 UV1.H27(CLKA0) UV6.J12(CK)
FBA_CLKA0#: RV42.2 UV1.G27(CLKA0B) UV6.J11(CK#)
FBA_CLKA1: RV53.1 UV1.J14(CLKA1) UV5.J12(CK)
FBA_CLKA1#: RV54.2 UV1.H14(CLKA1B) UV5.J11(CK#)
FBA_CSA0#: UV1.K24(CSA0B_0) UV6.G12(CS#                    WE#)
FBA_CSA1#: UV1.M13(CSA1B_0) UV5.L12(WE#                   CS#)
FBA_D0: UV1.C37(DQA0_0) UV6.F2(DQ31              DQ7)
FBA_D1: UV1.C35(DQA0_1) UV6.B2(DQ27              DQ3)
FBA_D2: UV1.A35(DQA0_2) UV6.A2(DQ25              DQ1)
FBA_D3: UV1.E34(DQA0_3) UV6.E2(DQ29              DQ5)
FBA_D4: UV1.G32(DQA0_4) UV6.E4(DQ28              DQ4)
FBA_D5: UV1.D33(DQA0_5) UV6.A4(DQ24              DQ0)
FBA_D6: UV1.F32(DQA0_6) UV6.F4(DQ30              DQ6)
FBA_D7: UV1.E32(DQA0_7) UV6.B4(DQ26              DQ2)
FBA_D8: UV1.D31(DQA0_8) UV6.A13(DQ17              DQ9)
FBA_D9: UV1.F30(DQA0_9) UV6.B11(DQ18           DQ10)
FBA_D10: UV1.C30(DQA0_10) UV6.A11(DQ16              DQ8)
FBA_D11: UV1.A30(DQA0_11) UV6.B13(DQ19           DQ11)
FBA_D12: UV1.F28(DQA0_12) UV6.E13(DQ21           DQ13)
FBA_D13: UV1.C28(DQA0_13) UV6.F11(DQ22           DQ14)
FBA_D14: UV1.A28(DQA0_14) UV6.E11(DQ20           DQ12)
FBA_D15: UV1.E28(DQA0_15) UV6.F13(DQ23           DQ15)
FBA_D16: UV1.D27(DQA0_16) UV6.M13(DQ15           DQ23)
FBA_D17: UV1.F26(DQA0_17) UV6.N13(DQ13           DQ21)
FBA_D18: UV1.C26(DQA0_18) UV6.M11(DQ14           DQ22)
FBA_D19: UV1.A26(DQA0_19) UV6.N11(DQ12           DQ20)
FBA_D20: UV1.F24(DQA0_20) UV6.T11(DQ10           DQ18)
FBA_D21: UV1.C24(DQA0_21) UV6.U13(DQ9             DQ17)
FBA_D22: UV1.A24(DQA0_22) UV6.T13(DQ11           DQ19)
FBA_D23: UV1.E24(DQA0_23) UV6.U11(DQ8             DQ16)
FBA_D24: UV1.C22(DQA0_24) UV6.T2(DQ3             DQ27)
FBA_D25: UV1.A22(DQA0_25) UV6.U4(DQ0             DQ24)
FBA_D26: UV1.F22(DQA0_26) UV6.T4(DQ2             DQ26)
FBA_D27: UV1.D21(DQA0_27) UV6.U2(DQ1             DQ25)
FBA_D28: UV1.A20(DQA0_28) UV6.N4(DQ4             DQ28)
FBA_D29: UV1.F20(DQA0_29) UV6.N2(DQ5             DQ29)
FBA_D30: UV1.D19(DQA0_30) UV6.M4(DQ6             DQ30)
FBA_D31: UV1.E18(DQA0_31) UV6.M2(DQ7             DQ31)
FBA_MAA0_0: UV1.G24(MAA0_0/MAA_0) UV6.H4(A10/A0                A8/A7)
FBA_MAA0_1: UV1.J23(MAA0_1/MAA_1) UV6.H5(A9/A1                  A11/A6)
FBA_MAA0_2: UV1.H24(MAA0_2/MAA_2) UV6.H11(BA0/A2               BA2/A4)
FBA_MAA0_3: UV1.J24(MAA0_3/MAA_3) UV6.H10(BA3/A3               BA1/A5)
FBA_MAA0_4: UV1.H26(MAA0_4/MAA_4) UV6.K11(BA2/A4               BA0/A2)
FBA_MAA0_5: UV1.J26(MAA0_5/MAA_5) UV6.K10(BA1/A5               BA3/A3)
FBA_MAA0_6: UV1.H21(MAA0_6/MAA_6) UV6.K5(A11/A6                A9/A1)
FBA_MAA0_7: UV1.G21(MAA0_7/MAA_7) UV6.K4(A8/A7                  A10/A0)
FBA_MAA0_8: UV1.H23(MAA0_8/MAA_13) UV6.J5(A12/RFU/NC)
FBA_MAA1_0: UV1.H19(MAA1_0/MAA_8) UV5.K4(A8/A7                  A10/A0)
FBA_MAA1_1: UV1.H20(MAA1_1/MAA_9) UV5.K5(A11/A6                A9/A1)
FBA_MAA1_2: UV1.L13(MAA1_2/MAA_10) UV5.K11(BA2/A4               BA0/A2)
FBA_MAA1_3: UV1.G16(MAA1_3/MAA_11) UV5.K10(BA1/A5               BA3/A3)
FBA_MAA1_4: UV1.J16(MAA1_4/MAA_12) UV5.H11(BA0/A2               BA2/A4)
FBA_MAA1_5: UV1.H16(MAA1_5/MAA_0) UV5.H10(BA3/A3               BA1/A5)
FBA_MAA1_6: UV1.J17(MAA1_6/MAA_1) UV5.H5(A9/A1                  A11/A6)
FBA_MAA1_7: UV1.H17(MAA1_7/MAA_2) UV5.H4(A10/A0                A8/A7)
FBA_MAA1_8: UV1.J19(MAA1_8/MAA_14) UV5.J5(A12/RFU/NC)
FBA_RASA0#: UV1.K23(RASA0B) UV6.G3(RAS#                 CAS#)
FBA_RASA1#: UV1.K19(RASA1B) UV5.L3(CAS#                 RAS#)
FBA_RST#: RV27.1 UV5.J2(RESET#) UV6.J2(RESET#) UV7.J2(RESET#) UV8.J2(RESET#)
FBA_WCKA0_0: UV1.A32(WCKA0_0/DQMA0_0) UV6.D4(WCK01              WCK23)
FBA_WCKA0_1: UV1.D23(WCKA0_1/DQMA0_2) UV6.P4(WCK23              WCK01)
FBA_WCKA0B_0: UV1.C32(WCKA0B_0/DQMA0_1) UV6.D5(WCK01#           WCK23#)
FBA_WCKA0B_1: UV1.E22(WCKA0B_1/DQMA0_3) UV6.P5(WCK23#           WCK01#)
FBA_WCKA1_0: UV1.C14(WCKA1_0/DQMA1_0) UV5.D4(WCK01              WCK23)
FBA_WCKA1_1: UV1.E10(WCKA1_1/DQMA1_2) UV5.P4(WCK23              WCK01)
FBA_WCKA1B_0: UV1.A14(WCKA1B_0/DQMA1_1) UV5.D5(WCK01#           WCK23#)
FBA_WCKA1B_1: UV1.D9(WCKA1B_1/DQMA1_3) UV5.P5(WCK23#           WCK01#)
FBA_WEA0#: UV1.K26(WEA0B) UV6.L12(WE#                   CS#)
FBA_WEA1#: UV1.L15(WEA1B) UV5.G12(CS#                    WE#)
FBB0_DBI0#: UV1.G7(DDBIB0_0) UV7.D2(DBI0#                DBI3#)
FBB0_DBI1#: UV1.K1(DDBIB0_1) UV7.D13(DBI1#                DBI2#)
FBB0_DBI2#: UV1.P1(DDBIB0_2) UV7.P13(DBI2#                DBI1#)
FBB0_DBI3#: UV1.W4(DDBIB0_3) UV7.P2(DBI3#                DBI0#)
FBB0_EDC0: UV1.F6(EDCB0_0) UV7.C2(EDC0                EDC3)
FBB0_EDC1: UV1.K3(EDCB0_1) UV7.C13(EDC1                EDC2)
FBB0_EDC2: UV1.P3(EDCB0_2) UV7.R13(EDC2                EDC1)
FBB0_EDC3: UV1.V5(EDCB0_3) UV7.R2(EDC3                EDC0)
FBB1_D0: UV1.AA4(DQB1_0) UV8.B2(DQ27              DQ3)
FBB1_D1: UV1.AB6(DQB1_1) UV8.F2(DQ31              DQ7)
FBB1_D2: UV1.AB1(DQB1_2) UV8.A2(DQ25              DQ1)
FBB1_D3: UV1.AB3(DQB1_3) UV8.E2(DQ29              DQ5)
FBB1_D4: UV1.AD6(DQB1_4) UV8.F4(DQ30              DQ6)
FBB1_D5: UV1.AD1(DQB1_5) UV8.E4(DQ28              DQ4)
FBB1_D6: UV1.AD3(DQB1_6) UV8.B4(DQ26              DQ2)
FBB1_D7: UV1.AD5(DQB1_7) UV8.A4(DQ24              DQ0)
FBB1_D8: UV1.AF1(DQB1_8) UV8.A13(DQ17              DQ9)
FBB1_D9: UV1.AF3(DQB1_9) UV8.B11(DQ18           DQ10)
FBB1_D10: UV1.AF6(DQB1_10) UV8.A11(DQ16              DQ8)
FBB1_D11: UV1.AG4(DQB1_11) UV8.B13(DQ19           DQ11)
FBB1_D12: UV1.AH5(DQB1_12) UV8.E13(DQ21           DQ13)
FBB1_D13: UV1.AH6(DQB1_13) UV8.F11(DQ22           DQ14)
FBB1_D14: UV1.AJ4(DQB1_14) UV8.E11(DQ20           DQ12)
FBB1_D15: UV1.AK3(DQB1_15) UV8.F13(DQ23           DQ15)
FBB1_D16: UV1.AF8(DQB1_16) UV8.M13(DQ15           DQ23)
FBB1_D17: UV1.AF9(DQB1_17) UV8.N13(DQ13           DQ21)
FBB1_D18: UV1.AG8(DQB1_18) UV8.M11(DQ14           DQ22)
FBB1_D19: UV1.AG7(DQB1_19) UV8.N11(DQ12           DQ20)
FBB1_D20: UV1.AK9(DQB1_20) UV8.T11(DQ10           DQ18)
FBB1_D21: UV1.AL7(DQB1_21) UV8.U13(DQ9             DQ17)
FBB1_D22: UV1.AM8(DQB1_22) UV8.U11(DQ8             DQ16)
FBB1_D23: UV1.AM7(DQB1_23) UV8.T13(DQ11           DQ19)
FBB1_D24: UV1.AK1(DQB1_24) UV8.M4(DQ6             DQ30)
FBB1_D25: UV1.AL4(DQB1_25) UV8.N4(DQ4             DQ28)
FBB1_D26: UV1.AM6(DQB1_26) UV8.U4(DQ0             DQ24)
FBB1_D27: UV1.AM1(DQB1_27) UV8.T4(DQ2             DQ26)
FBB1_D28: UV1.AN4(DQB1_28) UV8.U2(DQ1             DQ25)
FBB1_D29: UV1.AP3(DQB1_29) UV8.N2(DQ5             DQ29)
FBB1_D30: UV1.AP1(DQB1_30) UV8.T2(DQ3             DQ27)
FBB1_D31: UV1.AP5(DQB1_31) UV8.M2(DQ7             DQ31)
FBB1_DBI0#: UV1.AC4(DDBIB1_0) UV8.D2(DBI0#                DBI3#)
FBB1_DBI1#: UV1.AH3(DDBIB1_1) UV8.D13(DBI1#                DBI2#)
FBB1_DBI2#: UV1.AJ8(DDBIB1_2) UV8.P13(DBI2#                DBI1#)
FBB1_DBI3#: UV1.AM3(DDBIB1_3) UV8.P2(DBI3#                DBI0#)
FBB1_EDC0: UV1.AB5(EDCB1_0) UV8.C2(EDC0                EDC3)
FBB1_EDC1: UV1.AH1(EDCB1_1) UV8.C13(EDC1                EDC2)
FBB1_EDC2: UV1.AJ9(EDCB1_2) UV8.R13(EDC2                EDC1)
FBB1_EDC3: UV1.AM5(EDCB1_3) UV8.R2(EDC3                EDC0)
FBB_ADBIB0: UV1.T7(ADBIB0) UV7.J4(ABI#)
FBB_ADBIB1: UV1.W7(ADBIB1) UV8.J4(ABI#)
FBB_CASB0#: UV1.W10(CASB0B) UV7.L3(CAS#                 RAS#)
FBB_CASB1#: UV1.AA10(CASB1B) UV8.G3(RAS#                 CAS#)
FBB_CKEB0: UV1.U10(CKEB0) UV7.J3(CKE#)
FBB_CKEB1: UV1.AA11(CKEB1) UV8.J3(CKE#)
FBB_CLKB0: RV66.1 UV1.L9(CLKB0) UV7.J12(CK)
FBB_CLKB0#: RV67.2 UV1.L8(CLKB0B) UV7.J11(CK#)
FBB_CLKB1: RV78.1 UV1.AD8(CLKB1) UV8.J12(CK)
FBB_CLKB1#: RV79.2 UV1.AD7(CLKB1B) UV8.J11(CK#)
FBB_CSB0#: UV1.P10(CSB0B_0) UV7.G12(CS#                    WE#)
FBB_CSB1#: UV1.AD10(CSB1B_0) UV8.L12(WE#                   CS#)
FBB_D0: UV1.C5(DQB0_0) UV7.F2(DQ31              DQ7)
FBB_D1: UV1.C3(DQB0_1) UV7.E2(DQ29              DQ5)
FBB_D2: UV1.E3(DQB0_2) UV7.B2(DQ27              DQ3)
FBB_D3: UV1.E1(DQB0_3) UV7.A2(DQ25              DQ1)
FBB_D4: UV1.F1(DQB0_4) UV7.A4(DQ24              DQ0)
FBB_D5: UV1.F3(DQB0_5) UV7.B4(DQ26              DQ2)
FBB_D6: UV1.F5(DQB0_6) UV7.E4(DQ28              DQ4)
FBB_D7: UV1.G4(DQB0_7) UV7.F4(DQ30              DQ6)
FBB_D8: UV1.H5(DQB0_8) UV7.A11(DQ16              DQ8)
FBB_D9: UV1.H6(DQB0_9) UV7.A13(DQ17              DQ9)
FBB_D10: UV1.J4(DQB0_10) UV7.B11(DQ18           DQ10)
FBB_D11: UV1.K6(DQB0_11) UV7.B13(DQ19           DQ11)
FBB_D12: UV1.K5(DQB0_12) UV7.E13(DQ21           DQ13)
FBB_D13: UV1.L4(DQB0_13) UV7.F13(DQ23           DQ15)
FBB_D14: UV1.M6(DQB0_14) UV7.E11(DQ20           DQ12)
FBB_D15: UV1.M1(DQB0_15) UV7.F11(DQ22           DQ14)
FBB_D16: UV1.M3(DQB0_16) UV7.M11(DQ14           DQ22)
FBB_D17: UV1.M5(DQB0_17) UV7.N13(DQ13           DQ21)
FBB_D18: UV1.N4(DQB0_18) UV7.M13(DQ15           DQ23)
FBB_D19: UV1.P6(DQB0_19) UV7.N11(DQ12           DQ20)
FBB_D20: UV1.P5(DQB0_20) UV7.U13(DQ9             DQ17)
FBB_D21: UV1.R4(DQB0_21) UV7.T13(DQ11           DQ19)
FBB_D22: UV1.T6(DQB0_22) UV7.U11(DQ8             DQ16)
FBB_D23: UV1.T1(DQB0_23) UV7.T11(DQ10           DQ18)
FBB_D24: UV1.U4(DQB0_24) UV7.M4(DQ6             DQ30)
FBB_D25: UV1.V6(DQB0_25) UV7.N4(DQ4             DQ28)
FBB_D26: UV1.V1(DQB0_26) UV7.T4(DQ2             DQ26)
FBB_D27: UV1.V3(DQB0_27) UV7.U4(DQ0             DQ24)
FBB_D28: UV1.Y6(DQB0_28) UV7.U2(DQ1             DQ25)
FBB_D29: UV1.Y1(DQB0_29) UV7.N2(DQ5             DQ29)
FBB_D30: UV1.Y3(DQB0_30) UV7.T2(DQ3             DQ27)
FBB_D31: UV1.Y5(DQB0_31) UV7.M2(DQ7             DQ31)
FBB_MAB0_0: UV1.P8(MAB0_0) UV7.H4(A10/A0                A8/A7)
FBB_MAB0_1: UV1.T9(MAB0_1) UV7.H5(A9/A1                  A11/A6)
FBB_MAB0_2: UV1.P9(MAB0_2) UV7.H11(BA0/A2               BA2/A4)
FBB_MAB0_3: UV1.N7(MAB0_3) UV7.H10(BA3/A3               BA1/A5)
FBB_MAB0_4: UV1.N8(MAB0_4) UV7.K11(BA2/A4               BA0/A2)
FBB_MAB0_5: UV1.N9(MAB0_5) UV7.K10(BA1/A5               BA3/A3)
FBB_MAB0_6: UV1.U9(MAB0_6) UV7.K5(A11/A6                A9/A1)
FBB_MAB0_7: UV1.U8(MAB0_7) UV7.K4(A8/A7                  A10/A0)
FBB_MAB0_8: UV1.T8(MAB0_8) UV7.J5(A12/RFU/NC)
FBB_MAB1_0: UV1.Y9(MAB1_0) UV8.K4(A8/A7                  A10/A0)
FBB_MAB1_1: UV1.W9(MAB1_1) UV8.K5(A11/A6                A9/A1)
FBB_MAB1_2: UV1.AC8(MAB1_2) UV8.K11(BA2/A4               BA0/A2)
FBB_MAB1_3: UV1.AC9(MAB1_3) UV8.K10(BA1/A5               BA3/A3)
FBB_MAB1_4: UV1.AA7(MAB1_4) UV8.H11(BA0/A2               BA2/A4)
FBB_MAB1_5: UV1.AA8(MAB1_5) UV8.H10(BA3/A3               BA1/A5)
FBB_MAB1_6: UV1.Y8(MAB1_6) UV8.H5(A9/A1                  A11/A6)
FBB_MAB1_7: UV1.AA9(MAB1_7) UV8.H4(A10/A0                A8/A7)
FBB_MAB1_8: UV1.W8(MAB1_8) UV8.J5(A12/RFU/NC)
FBB_RASB0#: UV1.T10(RASB0B) UV7.G3(RAS#                 CAS#)
FBB_RASB1#: UV1.Y10(RASB1B) UV8.L3(CAS#                 RAS#)
FBB_WCKB0_0: UV1.H3(WCKB0_0) UV7.D4(WCK01              WCK23)
FBB_WCKB0_1: UV1.T3(WCKB0_1) UV7.P4(WCK23              WCK01)
FBB_WCKB0B_0: UV1.H1(WCKB0B_0) UV7.D5(WCK01#           WCK23#)
FBB_WCKB0B_1: UV1.T5(WCKB0B_1) UV7.P5(WCK23#           WCK01#)
FBB_WCKB1_0: UV1.AE4(WCKB1_0) UV8.D4(WCK01              WCK23)
FBB_WCKB1_1: UV1.AK6(WCKB1_1) UV8.P4(WCK23              WCK01)
FBB_WCKB1B_0: UV1.AF5(WCKB1B_0) UV8.D5(WCK01#           WCK23#)
FBB_WCKB1B_1: UV1.AK5(WCKB1B_1) UV8.P5(WCK23#           WCK01#)
FBB_WEB0#: UV1.N10(WEB0B) UV7.L12(WE#                   CS#)
FBB_WEB1#: UV1.AB11(WEB1B) UV8.G12(CS#                    WE#)
FDO: RV147.2 UV1.AK32(GPIO_28_FDO)
FN_LED#: JKB.26 UC1.AC1(GPP_C12/UART1_RXD/ISH_UART1_RXD)
FSCE#: RC311.1 UE1.101(NC1)
FW_GPIO: JLCD.38 R9449.1 UC1.BB7(GPP_A20/ISH_GP2)
GPD7: RC351.2 UC1.AT15(GPD7/RSVD)
GPIO01: TP120.1 UTPM1.30(SCL/GPIO1)
GPIO2: Q27.1(D) R9480.1 R9489.2 UTPM1.3(GPX/GPIO2)
GPIO03: TP121.1 UTPM1.6(GPIO3/BADD)
GPIO04: TP124.1 UTPM1.13(\\C\L\K\R\U\N\/GPIO04/\S\I\N\T\)
GPIO5_AC_BATT: DV5.2 RV117.2 RV149.2 UV1.AH17(GPIO_5_AC_BATT)
GPIO8_ROMSO: TPV3.1 UV1.AJ13(GPIO_8_ROMSO)
GPIO9_ROMSI: TPV4.1 UV1.AH15(GPIO_9_ROMSI)
GPIO10_ROMSCK: TPV5.1 TPV15.1 UV1.AJ16(GPIO_10_ROMSCK) UV1.AM14(GPIO_14_HPD2)
GPIO15_PWRCNTL_0: RV178.1 UV1.AM13(GPIO_15_PWRCNTL_0)
GPIO17_THERMAL_INT: RV104.1 UV1.AG30(GPIO_17_THERMAL_INT)
GPIO19_CTF: RV102.1 RV118.1 UV1.AM17(GPIO_19_CTF)
GPIO20_PWRCNTL_1: RV179.1 UV1.AL13(GPIO_20_PWRCNTL_1)
GPIO22_ROMCSB: TPV6.1 UV1.AK13(GPIO_22_ROMCSB)
GPP_B18: RC97.2 RC98.2 UC1.AR7(GPP_B18/GSPI0_MOSI)
GPP_B22: RC99.2 RC100.1 UC1.AN5(GPP_B22/GSPI1_MOSI)
GPP_B23: RC101.2 UC1.AM7(GPP_B23/SML1ALERT#/PCHHOT#)
GPP_C2: RC306.1 RC307.1 UC1.R10(GPP_C2/SMBALERT#)
GPP_C5: RC83.2 RC350.1 UC1.W1(GPP_C5/SML0ALERT#)
GPU_VR_HOT#: PR610.1 RE9.1 RV149.1 UE1.66(ADC0/GPI0)
GSENSE_INT: RG7.2 UGSEN1.11(INT1)
GSENSE_INT2: TG1.1 UGSEN1.9(INT2)
H_CPUPWRGD: T59.1 UC1.A68(PROCPWRGD)
H_HDMI_TX0+: L1.1 UX1.19(TMDS_CH0P)
H_HDMI_TX0-: L1.4 UX1.18(TMDS_CH0N)
H_HDMI_TX1+: L2.1 UX1.22(TMDS_CH1P)
H_HDMI_TX1-: L2.4 UX1.21(TMDS_CH1N)
H_HDMI_TX2+: L3.1 UX1.25(TMDS_CH2P)
H_HDMI_TX2-: L3.4 UX1.24(TMDS_CH2N)
H_HDMI_TXC+: L4.1 UX1.16(TMDS_CLKP)
H_HDMI_TXC-: L4.4 UX1.15(TMDS_CLKN)
H_PECI: RE1.1 UC1.A54(PECI)
H_PROCHOT_EC: QE1.2(G) UE1.80(DAC4/DCD0#/GPJ4)
H_THERMTRIP#: RC54.1 RV110.2
HDA_BCLK: RPC2.7(R7) UC1.AY22(HDA_BLK/I2S0_SCLK)
HDA_RST#: RPC2.8(R8) UC1.AW22(HDA_RST#/I2S1_SCLK)
HDA_SDOUT: RC21.2 RC299.1 RC302.1 RPC2.6(R6) UC1.BB22(HDA_SDO/I2S0_TXD)
HDA_SYNC: RC356.1 RPC2.5(R5) UC1.BA22(HDA_SYNC/I2S0_SFRM)
HDD_DETECT#: JHDD.12(GND5) RE15.2 UE1.15(ECSMI#/GPD4)
HDD_DEVSLP0: JHDD.10(VCC_3V3_3) RC88.2 UC1.J1(GPP_E4/DEVSLP0)
HDMI_CLK: D12.5(IN4) D12.6(OUT1) JHDMI.15(SCL) R224.2 UX1.48(TMDS_SCL)
HDMI_DAT: D12.4(IN3) D12.7(OUT2) JHDMI.16(SDA) R225.2 UX1.47(TMDS_SDA)
HDMI_HPD: D12.2(IN2) D12.8(OUT3) JHDMI.19(HP_DET) UX1.17(TMDS_HPD)
HDMI_TX0+_CON: D14.5(IN4) D14.6(OUT1) JHDMI.7(D0+) L1.2
HDMI_TX0-_CON: D14.4(IN3) D14.7(OUT2) JHDMI.9(D0-) L1.3
HDMI_TX1+_CON: D13.2(IN2) D13.8(OUT3) JHDMI.4(D1+) L2.2
HDMI_TX1-_CON: D13.1(IN1) D13.9(OUT4) JHDMI.6(D1-) L2.3
HDMI_TX2+_CON: D13.5(IN4) D13.6(OUT1) JHDMI.1(D2+) L3.2
HDMI_TX2-_CON: D13.4(IN3) D13.7(OUT2) JHDMI.3(D2-) L3.3
HDMI_TXC+_CON: D14.2(IN2) D14.8(OUT3) JHDMI.10(CK+) L4.2
HDMI_TXC-_CON: D14.1(IN1) D14.9(OUT4) JHDMI.12(CK-) L4.3
HG_1PH: PQ407.4(G) PU404.8(DRVH)
HG_A1: PQ401.4(G) PU402.8(DRVH)
HG_B1: PQ404.4(G) PU403.8(DRVH)
HGNDA: CA30.2 JAUF.4 JAUF.5 JAUF.6 UA1.25(HGNDA)
HGNDB: CA29.2 JAUF.1 JAUF.2 JAUF.3 UA1.26(HGNDB)
HP_OUTL: CA31.2 RA16.1 RA17.1 UA1.22(PORTA_L)
HP_OUTL_CON: JAUF.7 RA17.2
HP_OUTR: CA32.2 RA22.1 RA23.1 UA1.23(PORTA_R)
HP_OUTR_CON: JAUF.8 RA23.2
HPD: TPV17.1 UV1.AK24(HPD1)
I2C_CLK_GSENSE: QG2.1(S1) UGSEN1.4(SCL/SPC)
I2C_DATA_GSENSE: QG2.4(S2) UGSEN1.6(SDA/SDI/SDO)
I2CS_SCL: TPV13.1 UV1.AK26(SCL)
I2CS_SDA: TPV14.1 UV1.AJ26(SDA)
ILIM_HI: AOU1.16(ILIM_HI) R9476.1
ILIM_LO: AOU1.15(ILIM_LO) R484.1
ISEN1: PC608.2 PR616.1 PU601.13(ISEN1)
ISEN2: PC628.2 PR632.1 PU601.12(ISEN2)
ITP_PMODE: RC390.1 UC1.E8(ITP_PMODE)
JSENSE: RA18.2 RA20.2 RA21.2 UA1.38(JSENSE)
JSENSE_CON: JAUF.9 RA20.1 RA21.1
JTAG_TCK: RV137.1 TPV9.1 UV1.AK23(JTAG_TCK)
JTAG_TDI: RV135.2 TPV8.1 UV1.AN23(JTAG_TDI)
JTAG_TDO: RV136.2 TPV11.1 UV1.AM24(JTAG_TDO)
JTAG_TMS: RV132.2 TPV10.1 UV1.AL24(JTAG_TMS)
JTAG_TRSTB: RV131.2 TPV7.1 UV1.AM23(JTAG_TRSTB)
KB_FN: JKB.29 RPE1.6(R6) UE1.20(L80LLAT/GPE7)
KBRST#: RPC22.4(R4) UC1.AW13(GPP_A0/RCIN#) UE1.4(KBRST#/GPB6)
KSI0: JKB.12 UE1.58(KSI0/STB#)
KSI1: JKB.1 UE1.59(KSI1/AFD#)
KSI2: JKB.8 UE1.60(KSI2/INIT#)
KSI3: JKB.9 UE1.61(KSI3/SLIN#)
KSI4: JKB.5 UE1.62(KSI4)
KSI5: JKB.6 UE1.63(KSI5)
KSI6: IT7.1 JKB.3 UE1.64(KSI6)
KSI7: IT6.1 JKB.2 UE1.65(KSI7)
KSO0: JKB.7 UE1.36(KSO0/PD0)
KSO1: JKB.11 RPE2.8(R8) UE1.37(KSO1/PD1)
KSO2: JKB.13 RPE2.7(R7) UE1.38(KSO2/PD2)
KSO3: JKB.18 UE1.39(KSO3/PD3)
KSO4: JKB.14 UE1.40(KSO4/PD4)
KSO5: JKB.10 UE1.41(KSO5/PD5)
KSO6: JKB.17 UE1.42(KSO6/PD6)
KSO7: JKB.15 UE1.43(KSO7/PD7)
KSO8: JKB.16 UE1.44(KSO8/ACK#)
KSO9: JKB.4 UE1.45(KSO9/BUSY)
KSO10: JKB.23 UE1.46(KSO10/PE)
KSO11: JKB.22 UE1.51(KSO11/ERR#)
KSO12: JKB.19 UE1.52(KSO12/SLCT)
KSO13: JKB.20 UE1.53(KSO13)
KSO14: JKB.21 UE1.54(KSO14)
KSO15: JKB.24 UE1.55(KSO15)
KSO16: JKB.31 UE1.56(KSO16/SMOSI/GPC3)
KSO17: JKB.32 UE1.57(KSO17/SMISO/GPC5)
LAN_PWRON: RL25.1 UE1.97(GPH4/ID4)
LAN_PWRON#: QL3.1(D) RL22.2 RL24.1
LAN_PWRON_R: QL3.2(G) RL23.1 RL25.2
LAN_WAKE#: RL18.1 RPE2.5(R5) UE1.125(GPE4)
LAN_WAKE#_R: RL17.2 RL18.2 UL1.2(LANWAKE_N)
LAN_XTALI: CL8.1 UL1.10(XTAL_IN) YL1.3
LAN_XTALO: CL7.1 UL1.9(XTAL_OUT) YL1.1
LANGND: CL10.2 CL11.1 CL12.1 DL3.1 DL4.1 DL5.1 DL6.1 JRJ452.13(GND1) JRJ452.14(GND2)
LANPHYPC: RL9.2 UC1.AW17(GPD11/LANPHYPC) UL1.3(LAN_DISABLE_N)
LG_1PH: PQ408.4(G) PU404.5(DRVL)
LG_A1: PQ402.4(G) PQ403.4(G) PU402.5(DRVL)
LG_B1: PQ405.4(G) PQ406.4(G) PU403.5(DRVL)
LID_SW#: D11.1 JU3LF.11 RPE3.5(R5) UE1.109(LID_SW#)
LOGO_LED#: D1.2 JAUF.11 JLCD.10 UE1.24(PWM0/GPA0)
LPC_AD0: UC1.AY13(GPP_A1/LAD0/ESPI_IO0) UE1.10(LAD0/GPM0)
LPC_AD1: UC1.BA13(GPP_A2/LAD1/ESPI_IO1) UE1.9(LAD1/GPM1)
LPC_AD2: UC1.BB13(GPP_A3/LAD2/ESPI_IO2) UE1.8(LAD2/GPM2)
LPC_AD3: UC1.AY12(GPP_A4/LAD3/ESPI_IO3) UE1.7(LAD3/GPM3)
LPC_FRAME#: RPE3.8(R8) UC1.BA12(GPP_A5/LFRAME#/ESPI_CS#) UE1.6(LFRAME#/GPM5)
LX_1.35V: PC310.1 PL301.2 PQ301.1(S1) PQ301.2(S2) PQ301.3(S3) PQ302.5(D) PR304.2 PU301.16(PHASE)
LX_CHG: PC118.1 PL102.1 PQ106.1(S1) PQ106.2(S2) PQ106.3(S3) PQ107.5(D) PR119.2 PU101.27(PHASE)
MAINPWON_EC: PD2.2 PQ201.5(G2) PR13.1 PR217.2 UE1.79(DAC3/TACH1B/GPJ3)
MCT1: DL3.2 RL10.2 TL1.22(TXCT1)
MCT2: DL4.2 RL11.2 TL1.21(TXCT2)
MCT3: DL5.2 RL12.2 TL1.16(TXCT3)
MCT4: DL6.2 RL13.2 TL1.15(TXCT4)
MDI_0+: DL1.1(IN1) DL1.9(OUT4) TL1.1(TD1+) UL1.13(MDI_PLUS[0])
MDI_0-: DL1.2(IN2) DL1.8(OUT3) TL1.2(TD1-) UL1.14(MDI_MINUS[0])
MDI_1+: DL1.4(IN3) DL1.7(OUT2) TL1.5(TD2+) UL1.17(MDI_PLUS[1])
MDI_1-: DL1.5(IN4) DL1.6(OUT1) TL1.6(TD2-) UL1.18(MDI_MINUS[1])
MDI_2+: DL2.1(IN1) DL2.9(OUT4) TL1.7(TD3+) UL1.20(MDI_PLUS[2])
MDI_2-: DL2.2(IN2) DL2.8(OUT3) TL1.8(TD3-) UL1.21(MDI_MINUS[2])
MDI_3+: DL2.4(IN3) DL2.7(OUT2) TL1.11(TD4+) UL1.23(MDI_PLUS[3])
MDI_3-: DL2.5(IN4) DL2.6(OUT1) TL1.12(TD4-) UL1.24(MDI_MINUS[3])
ME_FLASH: RC21.1 UE1.104(DSR0#/GPG6)
MIC_CLK_R: RA31.2 UA1.40(DMIC_CLK/MUSIC_REQ/GPIO0)
MIC_HW_EN: RC355.2 UC1.AH11(GPP_F6/I2C3_SDA)
ML0N: CVG15.2 UVG2.5(ML0_N)
ML0P: CVG16.2 UVG2.4(ML0_P)
ML1N: CVG17.2 UVG2.8(ML1_N)
ML1P: CVG18.2 UVG2.7(ML1_P)
MPLL_PVDD: CV218.1 CV219.1 CV220.1 LV3.2 UV1.H7(MPLL_PVDD_1) UV1.H8(MPLL_PVDD_2)
MUX_CAD: RX21.1 UX1.42(DP_CA_DET)
MUX_CFG0: RX17.2 RX18.1 UX1.44(DP_CFG0/SCL_CTL)
MUX_CFG1: RX19.2 RX20.1 UX1.29(DP_CFG1)
MUX_DDCBUF: RX9.2 RX12.1 UX1.2(TMDS_DDCBUF)
MUX_I2C_CTL_EN: RX13.1 RX14.2 UX1.38(I2C_CTL_EN)
MUX_MODE: RX10.1 RX11.2 UX1.53(MODE)
MUX_PEQ: RX3.2 RX4.1 UX1.8(PEQ)
MUX_PRE: RX5.1 RX6.2 UX1.20(TMDS_PRE)
MUX_RT: RX7.1 RX8.2 UX1.23(TMDS_RT)
MUX_SW: RX15.1 RX16.2 UX1.45(SW/SDA_CTL)
MVREFDA: CV73.1 RV18.2 RV20.1 UV1.L18(MVREFDA)
MVREFDB: CV74.1 RV19.2 RV21.1 UV1.Y12(MVREFDB)
MVREFSA: CV75.1 RV22.2 RV24.1 UV1.L20(MVREFSA)
MVREFSB: CV76.1 RV23.2 RV25.1 UV1.AA12(MVREFSB)
NTC_V_1: PR9.1 PR10.2 PR11.2 PR12.1 PRT7.1 PU1.8(TMSNS1)
ODD_DA#: R150.1 RC409.2 UC1.H2(GPP_E0/SATAXPCIE0/SATAGP0)
ODD_DA#_R: JODD.11 R150.2
ODD_DETEC#: JODD.8 RC86.2 RC386.1 UC1.H3(GPP_E1/SATAXPCIE1/SATAGP1)
ODD_EN: R153.1 U150.3(EN) UC1.J3(GPP_E6/DEVSLP2)
ON/OFF#: J1.2 JU3LF.12 R71.2 SW1.3 SW1.4 UE1.110(PWRSW#)
ONEDOCK_DET#: JU3LF.10 R233.2 R234.2 R235.2 RC372.1 UC1.G4(GPP_E2/SATAXPCIE2/SATAGP2)
OPC_RCOMP: RC56.2 UC1.H65(OPC_RCOMP)
OPCE_RCOMP: RC200.2 UC1.H66(OPCE_RCOMP)
OTP_N_002: PR12.2 PU1.7(RHYST1)
OTP_N_003: PR13.2 PU1.3(\\\\\\OT1)
P2: PC102.1 PQ101.1(S1) PQ101.2(S2) PQ101.3(S3) PQ102.1(S1) PQ102.2(S2) PQ102.3(S3) PQ103.3(S) PR104.2 PR112.1
P3: PC103.2 PL101.1 PQ102.5(D)
PBTN_OUT#: RC399.2 TP129.1 UC1.BA15(GPD3/PWRBTN#) UE1.86(PS2DAT0/TMB1/GPF1)
PC_BEEP: CA24.2 UA1.10(PC_BEEP)
PCH_BEEP: CA23.1 DA1.3 RC95.1 RC300.1 UC1.AW5(GPP_B14/SPKR)
PCH_CMOS_ON: R2.1 U4.3(EN) UC1.AM5(GPP_B19/GSPI1_CS#)
PCH_EDP_PWM: JLCD.12 UC1.R11(EDP_BKLTCTL)
PCH_ENVDD: R18.1 U3.4(EN) UC1.U13(EDP_VDDEN)
PCH_HDA_BCLK: RPC2.2(R2) UA1.5(BIT_CLK)
PCH_HDA_RST#: RPC2.1(R1) UA1.9(RESET#)
PCH_HDA_SDIN0: RA5.1 RC297.1 RC301.1 UC1.BA21(HDA_SDI0/I2S0_RXD)
PCH_HDA_SDIN0_R: RA5.2 UA1.6(SDATA_IN)
PCH_HDA_SDOUT: RPC2.3(R3) UA1.4(SDATA_OUT)
PCH_HDA_SYNC: RPC2.4(R4) UA1.8(SYNC)
PCH_INTRUDER#: RC16.2 UC1.AP16(INTRUDER#)
PCH_JTAG_TCK: RC352.1 TC10.1 UC1.B56(PCH_JTAG_TCK)
PCH_JTAG_TDI: RC354.1 RC422.2 UC1.D59(PCH_JTAG_TDI)
PCH_JTAG_TDO: RC423.2 UC1.A56(PCH_JTAG_TDO)
PCH_JTAG_TMS: RC353.1 RC424.2 UC1.C59(PCH_JTAG_TMS)
PCH_JTAG_TRST#: RC425.2 UC1.C61(PCH_TRST#)
PCH_JTAGX: RC415.2 UC1.A59(JTAGX)
PCH_MUX_AUX: CX15.1 UC1.F50(DDI1_AUXP)
PCH_MUX_AUX#: CX16.1 UC1.G50(DDI1_AUXN)
PCH_MUX_AUX#_C: CX16.2 UX1.51(IN_AUXN)
PCH_MUX_AUX_C: CX15.2 UX1.52(IN_AUXP)
PCH_MUX_CLK: RC277.2 UC1.L13(GPP_E18/DDPB_CTRLCLK) UX1.50(IN_DDC_SCL)
PCH_MUX_DAT: RC287.2 UC1.L12(GPP_E19/DDPB_CTRLDATA) UX1.49(IN_DDC_SDA)
PCH_MUX_HPD: RC288.1 UC1.L9(GPP_E13/DDPB_HPD0) UX1.5(IN_HPD)
PCH_OPIRCOMP: RC55.2 UC1.AU16(PCH_OPIRCOMP)
PCH_PCI_CLK_R: RC24.1 UC1.AW9(GPP_A9/CLKOUT_LPC0/ESPI_CLK)
PCH_PWROK: RC41.1 RC382.1 UE1.99(GPH6/ID6)
PCH_RTCRST#: CC1.1 JCMOS1.1 RC12.2 UC1.AM16(RTCRST#)
PCH_RTCX1: CC3.1 RC13.1 UC1.AM18(RTCX1) YC1.1
PCH_RTCX2: CC4.1 RC13.2 UC1.AM20(RTCX2) YC1.2
PCH_SLP_LAN#: RL17.1 RPC18.5(R5) UC1.AW15(SLP_LAN#) UE1.87(GPF2)
PCH_SLP_SUS#: TC21.1 UC1.AN15(SLP_SUS#)
PCH_SLP_WLAN#: RC393.2 UC1.BB17(GPD9/SLP_WLAN#) UE1.88(GPF3)
PCH_SMB_CLK: QC1.6(D1) RC395.1 UC1.R7(GPP_C0/SMBCLK)
PCH_SMB_DATA: QC1.3(D2) RC396.1 UC1.R8(GPP_C1/SMBDATA)
PCH_SML0_CLK: RC92.1 UC1.R9(GPP_C3/SML0CLK) UL1.28(SMB_CLK)
PCH_SML0_DAT: RC93.1 UC1.W2(GPP_C4/SML0DATA) UL1.31(SMB_DATA)
PCH_SML1CLK: QC2.6(D1) RC397.1 UC1.W3(GPP_C6/SML1CLK)
PCH_SML1DATA: QC2.3(D2) RC398.1 UC1.V3(GPP_C7/SML1DATA)
PCH_SRTCRST#: CC5.1 JME1.1 RC14.2 UC1.AN18(SRTCRST#)
PCH_SYSPWROK: RC381.1 UC1.B6(SYS_PWROK) UE1.82(EGAD/GPE1)
PCH_TSOFF#: D60.1 RPC9.1(R1) UC1.AD4(GPP_C23/UART2_CTS#)
PCH_VGA_AUX: CVG20.1 UC1.F48(DDI2_AUXP)
PCH_VGA_AUX#: CVG19.1 UC1.E48(DDI2_AUXN)
PCH_VGA_HPD: RC204.1 RVG129.1 UC1.L7(GPP_E14/DDPC_HPD1)
PCH_XTAL24_IN: CC7.1 RC30.2 UC1.E37(XTAL24_IN) YC2.3
PCH_XTAL24_OUT: CC6.1 RC30.1 UC1.E35(XTAL24_OUT) YC2.1
PCIE1_PTX_DRX_N0: CC86.2 UC1.B23(PCIE9_TXN)
PCIE1_PTX_DRX_P0: CC87.2 UC1.A23(PCIE9_TXP)
PCIE2_PTX_DRX_N1: CC88.2 UC1.D23(PCIE10_TXN)
PCIE2_PTX_DRX_P1: CC89.2 UC1.C23(PCIE10_TXP)
PCIE3_CRX_DTX_N: JWLBT.43(PERN0) UC1.H16(PCIE3_RXN)
PCIE3_CRX_DTX_P: JWLBT.41(PERP0) UC1.G16(PCIE3_RXP)
PCIE3_CTX_C_DRX_N: CC18.1 JWLBT.37(PETN0)
PCIE3_CTX_C_DRX_P: CC19.1 JWLBT.35(PETP0)
PCIE3_CTX_DRX_N: CC18.2 UC1.D17(PCIE3_TXN)
PCIE3_CTX_DRX_P: CC19.2 UC1.C17(PCIE3_TXP)
PCIE3_PTX_DRX_N2: CC90.2 UC1.D24(PCIE11_TXN/SATA1B_TXN)
PCIE3_PTX_DRX_P2: CC23.2 UC1.C24(PCIE11_TXP/SATA1B_TXP)
PCIE4_CRX_DTX_N: CL2.1 UC1.G15(PCIE4_RXN)
PCIE4_CRX_DTX_N_C: CL2.2 UL1.39(PETN)
PCIE4_CRX_DTX_P: CL1.1 UC1.F15(PCIE4_RXP)
PCIE4_CRX_DTX_P_C: CL1.2 UL1.38(PETP)
PCIE4_CTX_C_DRX_N: CC92.1 UL1.42(PERN)
PCIE4_CTX_C_DRX_P: CC93.1 UL1.41(PERP)
PCIE4_CTX_DRX_N: CC92.2 UC1.B19(PCIE4_TXN)
PCIE4_CTX_DRX_P: CC93.2 UC1.A19(PCIE4_TXP)
PCIE4_PTX_DRX_N3: CC24.2 UC1.A25(PCIE12_TXN/SATA2_TXN)
PCIE4_PTX_DRX_P3: CC91.2 UC1.B25(PCIE12_TXP/SATA2_TXP)
PCIE6_CRX_C_DTX_N: CW10.2 UW1.8(HSON)
PCIE6_CRX_C_DTX_P: CW9.2 UW1.7(HSOP)
PCIE6_CRX_DTX_N: CW10.1 UC1.G18(PCIE6_RXN)
PCIE6_CRX_DTX_P: CW9.1 UC1.F18(PCIE6_RXP)
PCIE6_CTX_C_DRX_N: CC20.1 UW1.4(HSIN)
PCIE6_CTX_C_DRX_P: CC21.1 UW1.3(HSIP)
PCIE6_CTX_DRX_N: CC20.2 UC1.D20(PCIE6_TXN)
PCIE6_CTX_DRX_P: CC21.2 UC1.C20(PCIE6_TXP)
PCIE_CRX_C_GTX_N0: CV2.1 UV1.Y32(PCIE_TX0N)
PCIE_CRX_C_GTX_N1: CV4.1 UV1.W32(PCIE_TX1N)
PCIE_CRX_C_GTX_N2: CV6.1 UV1.U32(PCIE_TX2N)
PCIE_CRX_C_GTX_N3: CV8.1 UV1.U29(PCIE_TX3N)
PCIE_CRX_C_GTX_P0: CV1.1 UV1.Y33(PCIE_TX0P)
PCIE_CRX_C_GTX_P1: CV3.1 UV1.W33(PCIE_TX1P)
PCIE_CRX_C_GTX_P2: CV5.1 UV1.U33(PCIE_TX2P)
PCIE_CRX_C_GTX_P3: CV7.1 UV1.U30(PCIE_TX3P)
PCIE_CRX_GTX_N0: CV2.2 UC1.E22(PCIE9_RXN)
PCIE_CRX_GTX_N1: CV4.2 UC1.F25(PCIE10_RXN)
PCIE_CRX_GTX_N2: CV6.2 UC1.E28(PCIE11_RXN/SATA1B_RXN)
PCIE_CRX_GTX_N3: CV8.2 UC1.E30(PCIE12_RXN/SATA2_RXN)
PCIE_CRX_GTX_P0: CV1.2 UC1.E23(PCIE9_RXP)
PCIE_CRX_GTX_P1: CV3.2 UC1.E25(PCIE10_RXP)
PCIE_CRX_GTX_P2: CV5.2 UC1.E27(PCIE11_RXP/SATA1B_RXP)
PCIE_CRX_GTX_P3: CV7.2 UC1.F30(PCIE12_RXP/SATA2_RXP)
PCIE_CTX_C_GRX_N0: CC86.1 UV1.Y37(PCIE_RX0N)
PCIE_CTX_C_GRX_N1: CC88.1 UV1.W36(PCIE_RX1N)
PCIE_CTX_C_GRX_N2: CC90.1 UV1.V37(PCIE_RX2N)
PCIE_CTX_C_GRX_N3: CC24.1 UV1.U36(PCIE_RX3N)
PCIE_CTX_C_GRX_P0: CC87.1 UV1.AA38(PCIE_RX0P)
PCIE_CTX_C_GRX_P1: CC89.1 UV1.Y35(PCIE_RX1P)
PCIE_CTX_C_GRX_P2: CC23.1 UV1.W38(PCIE_RX2P)
PCIE_CTX_C_GRX_P3: CC91.1 UV1.V35(PCIE_RX3P)
PCIE_RCOMP: RC385.2 UC1.F5(PCIE_RCOMPN)
PCIE_WAKE#: RPC18.6(R6) UC1.BB15(WAKE#)
PECI: CE1.1 RE1.2 UE1.117(SMCLK2/PECI/GPF6)
PG_VDD: PR604.1 PR605.2 PU601.20(PGOOD)
PLANARID0: RC70.2 RC74.1 UC1.AB1(GPP_C8/UART0_RXD)
PLANARID1: RC434.2 RC435.1 UC1.U7(GPP_C16/I2C0_SDA)
PLT_RST_VGA#: DV4.1 PR606.1 RV9.2 RV167.1 RV207.2 UV1.AA30(PERSTB) UV15.4(OUT)
PLTRST#: RC26.1 RV207.1 UC1.AN10(GPP_B13/PLTRST#) UC3.2(IN_A) UV15.1(IN1)
PLTRST_FAR#: CC9.1 CE13.2 JWLBT.52(PERST0#) JWLBT.66(PERST1#) RC48.2 UE1.22(LPCRST#/GPD2) UTPM1.17(\\L\R\E\S\E\T\/\S\P\I\_\R\S\T\/)
PLTRST_NEAR#: CC102.1 RC348.2 UL1.36(PE_RST_N) USROM1.3(PROT#) UW1.1(PERST#)
PM_SLP_A#: TP128.1 UC1.AN16(GPD6/SLP_A#) UE1.76(TACH2/GPJ0)
PM_SLP_S0#: TC20.1 UC1.AT11(GPP_B12/SLP_S0#)
PM_SLP_S3#: D59.1 D65.1 TP125.1 UC1.AP15(GPD4/SLP_S3#) UE1.18(RI1#/GPD0)
PM_SLP_S4#: D64.1 TP126.1 UC1.BA16(GPD5/SLP_S4#) UE1.21(RI2#/GPD1)
PM_SLP_S5#: TP127.1 UC1.AY16(GPD10/SLP_S5#) UE1.77(GPJ1)
PM_SMB_CLK: JCP.2 JDIMM1.202(SCL) JDIMM2.202(SCL) QC1.1(S1) RC106.1 USROM1.6(SCL)
PM_SMB_DAT: JCP.6 JDIMM1.200(SDA) JDIMM2.200(SDA) QC1.4(S2) RC107.1 USROM1.5(SDA)
PME#: TC120.1 UC1.AU11(GPP_A11/PME#)
PORTB_L: RA19.1 UA1.32(PORTB_L_LINE)
PORTB_R: RA24.1 UA1.33(PORTB_R_LINE)
PP: TP940.1 UTPM1.4(PP)
PROC_POPIRCOMP: RC151.2 UC1.AT16(PROC_POPIRCOMP)
PS_0: CV213.1 RV112.2 RV113.1 UV1.AM34(PS_0)
PS_1: CV212.1 RV106.2 RV109.1 UV1.AD31(PS_1)
PS_2: CV210.1 RV108.2 RV111.1 UV1.AG31(PS_2)
PS_3: CV211.1 RV107.1 RV114.2 UV1.AD33(PS_3)
PSYS: PC127.2 PR124.1 PR413.2 PU401.46(PSYS)
PWM1_2PH: PU401.16(PWM1_2PH) PU403.2(PWM)
PWM_1A: PU401.22(PWM_1A) PU402.2(PWM)
PWM_1B: PU401.36(PWM_1B) PU404.2(PWM)
PWROK: RC41.2 RC403.2 UC1.BA20(PCH_PWROK)
Q27_G: Q27.2(G) R9491.1
REMOTE1+: C2.1 C4.1 Q1.1(COLLECTOR) Q1.2(BASE) U1.2(DP1)
REMOTE1-: C2.2 C4.2 Q1.3(EMITTER) U1.3(DN1)
REMOTE2+: C3.1 C5.1 Q2.1(COLLECTOR) Q2.2(BASE) U1.4(DP2)
REMOTE2-: C3.2 C5.2 Q2.3(EMITTER) U1.5(DN2)
RF_OFF#: JWLBT.56(W_DISABLE#1) RC376.2 UC1.AN8(GPP_B15/GSPI0_CS#)
RJ45_ACTIVITY#: JRJ452.10(YELLOWLED-) UL1.27(LED1)
RJ45_GND: CL10.1 RL10.1 RL11.1 RL12.1 RL13.1
RJ45_LINKUP#: JRJ452.12(GREENLED-) UL1.26(LED0)
RJ45_TXD0N: JRJ452.2(PR1-) TL1.23(TX1-)
RJ45_TXD0P: JRJ452.1(PR1+) TL1.24(TX1+)
RJ45_TXD1N: JRJ452.6(PR2-) TL1.19(TX2-)
RJ45_TXD1P: JRJ452.3(PR2+) TL1.20(TX2+)
RJ45_TXD2N: JRJ452.5(PR3-) TL1.17(TX3-)
RJ45_TXD2P: JRJ452.4(PR3+) TL1.18(TX3+)
RJ45_TXD3N: JRJ452.8(PR4-) TL1.13(TX4-)
RJ45_TXD3P: JRJ452.7(PR4+) TL1.14(TX4+)
RST#: RVG131.2 UVG2.23(RSET)
S3_1.35V: PC318.1 PR310.1 PR311.1 PU301.7(S3)
S5_1.35V: PC319.1 PR312.2 PR313.2 PU301.8(S5)
SA_CLK_DDR0: JDIMM1.101(CK0) UC1.AT53(DDR0_CKP[0])
SA_CLK_DDR1: JDIMM1.102(CK1) UC1.AT55(DDR0_CKP[1])
SA_CLK_DDR#0: JDIMM1.103(CK0#) UC1.AU53(DDR0_CKN[0])
SA_CLK_DDR#1: JDIMM1.104(CK1#) UC1.AU55(DDR0_CKN[1])
SA_DIMM_VREFDQ: CD2.1 RD2.1 UC1.AY68(DDR0_VREF_DQ)
SATA_PRX_C_DTX_N0: C26.2 JHDD.5(B-)
SATA_PRX_C_DTX_N1: C129.2 JODD.5
SATA_PRX_C_DTX_P0: C27.2 JHDD.6(B+)
SATA_PRX_C_DTX_P1: C130.2 JODD.6
SATA_PRX_DTX_N0: C26.1 UC1.F20(PCIE7_RXN/SATA0_RXN)
SATA_PRX_DTX_N1: C129.1 UC1.G21(PCIE8_RXN/SATA1A_RXN)
SATA_PRX_DTX_P0: C27.1 UC1.E20(PCIE7_RXP/SATA0_RXP)
SATA_PRX_DTX_P1: C130.1 UC1.F21(PCIE8_RXP/SATA1A_RXP)
SATA_PTX_C_DRX_N0: C25.2 JHDD.3(A-)
SATA_PTX_C_DRX_N1: C165.2 JODD.3
SATA_PTX_C_DRX_P0: C24.2 JHDD.2(A+)
SATA_PTX_C_DRX_P1: C164.2 JODD.2
SATA_PTX_DRX_N0: C25.1 UC1.B21(PCIE7_TXN/SATA0_TXN)
SATA_PTX_DRX_N1: C165.1 UC1.D21(PCIE8_TXN/SATA1A_TXN)
SATA_PTX_DRX_P0: C24.1 UC1.A21(PCIE7_TXP/SATA0_TXP)
SATA_PTX_DRX_P1: C164.1 UC1.C21(PCIE8_TXP/SATA1A_TXP)
SB_CLK_DDR0: JDIMM2.101(CK0) UC1.AP45(DDR1_CKP[0])
SB_CLK_DDR1: JDIMM2.102(CK1) UC1.AP46(DDR1_CKP[1])
SB_CLK_DDR#0: JDIMM2.103(CK0#) UC1.AN45(DDR1_CKN[0])
SB_CLK_DDR#1: JDIMM2.104(CK1#) UC1.AN46(DDR1_CKN[1])
SB_DIMM_VREFDQ: CD31.1 RD17.1 UC1.BA67(DDR1_VREF_DQ)
SD_CD#: RW14.1 UW1.30(SD_CD#)
SD_CD#_R: JREAD2.11(C/D) RW13.2 RW14.2
SD_CLK_MS_DATA0: CW11.1 JREAD2.5(CLK) RW16.1 RW22.1
SD_CLK_MS_DATA0_R: RW22.2 UW1.17(SP3)
SD_CMD_MS_DATA2: JREAD2.2(CMD) RW23.1
SD_CMD_MS_DATA2_R: RW23.2 UW1.19(SP4)
SD_DATA0_MS_DATA1: JREAD2.7(DAT0) RW21.1
SD_DATA0_MS_DATA1_R: RW21.2 UW1.16(SP2)
SD_DATA1: JREAD2.8(DAT1) RW4.1
SD_DATA1_R: RW4.2 UW1.15(SP1)
SD_DATA2_MS_CLK: JREAD2.9(DAT2) RW25.1
SD_DATA2_MS_CLK_R: RW25.2 UW1.21(SP6)
SD_MS_DATA3: JREAD2.1(CD/DAT3) RW24.1
SD_MS_DATA3_R: RW24.2 UW1.20(SP5)
SD_WP: RW15.1 UW1.29(SP7)
SD_WP_R: JREAD2.10(W/P) RW12.2 RW15.2
SERIRQ: R9478.1 RPC22.1(R1) UC1.AY11(GPP_A6/SERIRQ) UE1.5(SERIRQ/GPM6)
SERIRQ_R: R9477.1 R9478.2 UTPM1.18(LAD2/\S\P\I\_\I\R\Q\)
SM_DIMM_VREFCA: CD12.1 RD10.2 UC1.AY67(DDR_VREF_CA)
SM_PG_CTRL: PR310.2 QD1.1(COLLECTOR) RD23.2 RD25.1
SM_RCOMP0: RC8.1 UC1.AR18(DDR_RCOMP[0])
SM_RCOMP1: RC9.1 UC1.AT18(DDR_RCOMP[1])
SM_RCOMP2: RC10.1 UC1.AU18(DDR_RCOMP[2])
SMBCLK: QV5.1(S1) RV98.2 RV144.1 UV1.AJ23(SMBCLK)
SMBDAT: QV5.4(S2) RV99.2 RV142.1 UV1.AH23(SMBDATA)
SPI_CLK: R9483.1 RC380.1 RPC23.7(R7) RPC24.7(R7)
SPI_CLK_4MB: RPC24.2(R2) UC4M1.6(CLK)
SPI_CLK_8MB: RC314.2 RPC23.2(R2) UC8M2.6(CLK)
SPI_CLK_L: R9483.2 UTPM1.19(LCLK/SCLK)
SPI_CLK_R: RC380.2 UC1.AV2(SPI0_CLK)
SPI_CS0#_8MB: RC311.2 UC1.AU3(SPI0_CS0#) UC8M2.1(CS#)
SPI_CS1#_4MB: UC1.AU2(SPI0_CS1#) UC4M1.1(CS#)
SPI_CS2#_TPM: R9482.1 UC1.AU1(SPI0_CS2#)
SPI_CS2_R: R9482.2 R9491.2 UTPM1.20(\\L\F\R\A\M\E\/\S\C\S\)
SPI_FMISO: RC313.1 UE1.103(NC3)
SPI_FMOSI#: RC312.1 UE1.102(NC2)
SPI_FSCK: RC314.1 UE1.105(NC4)
SPI_IO2: RC117.2 RPC23.5(R5) RPC24.5(R5) UC1.AW2(SPI0_IO2)
SPI_IO2_4MB: RPC24.4(R4) UC4M1.3(WP#)
SPI_IO2_8MB: RPC23.4(R4) UC8M2.3(WP#)
SPI_IO3: RC118.2 RC394.1 RPC23.8(R8) RPC24.8(R8) UC1.AU4(SPI0_IO3)
SPI_IO3_4MB: RPC24.1(R1) UC4M1.7(HOLD#)
SPI_IO3_8MB: RPC23.1(R1) UC8M2.7(HOLD#)
SPI_SI: R9479.1 RC298.1 RPC23.6(R6) RPC24.6(R6) UC1.AV3(SPI0_MOSI)
SPI_SI_4MB: RPC24.3(R3) UC4M1.5(DI)
SPI_SI_8MB: RC312.2 RPC23.3(R3) UC8M2.5(DI)
SPI_SI_R: R9479.2 UTPM1.21(LAD1/MOSI)
SPI_SO: R9481.1 RC102.2 RC103.2 RC308.1 UC1.AW3(SPI0_MISO)
SPI_SO_4MB: RC102.1 UC4M1.2(DO)
SPI_SO_8MB: RC103.1 RC313.2 UC8M2.2(DO)
SPI_SO_R: R9481.2 UTPM1.24(LAD0/MISO)
SPK_L1-: RA8.1 UA1.14(LEFT-)
SPK_L1-_CON: CA25.2 JSPK.4 RA8.2
SPK_L2+: RA9.1 UA1.12(LEFT+)
SPK_L2+_CON: CA26.2 JSPK.3 RA9.2
SPK_R1-: RA10.1 UA1.15(RIGHT-)
SPK_R1-_CON: CA27.2 JSPK.2 RA10.2
SPK_R2+: RA12.1 UA1.17(RIGHT+)
SPK_R2+_CON: CA28.2 JSPK.1 RA12.2
SPKR_MUTE#: DA5.2 RA29.2 UA1.39(SPKR_MUTE#)
SPLL_PVDD: CV221.1 CV222.1 CV225.1 LV4.2 UV1.AM10(SPLL_PVDD)
SPLL_VDDC: CV223.1 CV224.1 CV226.1 LV5.2 UV1.AN9(SPLL_VDDC)
SRN: PR128.2 PU101.19(SRN)
SRP: PR125.2 PU101.20(SRP)
SSD_DEVSLP1: TC27.1 UC1.J2(GPP_E5/DEVSLP1)
SUS_STAT#: RC47.1 UC1.BA11(GPP_A14/SUS_STAT#/ESPI_RESET#)
SUSACK#: RC109.1 UC1.AP11(GPP_A15/SUSACK#)
SUSCLK_32K: JWLBT.50(SUSCLK) UC1.BA17(GPD8/SUSCLK)
SUSP: Q6.5(G2) Q6.6(D1) Q22.2(G) R156.2 R157.2
SUSP#: D15.1 D63.2 D65.2 PR311.2 Q6.2(G1) Q24.2(G1) RE53.1 U11.3(ON1) U11.5(ON2)
SUSP#_EC: D63.1 RPE4.8(R8) UE1.124(TMRI1/GPC6)
SUSWARN#: RC109.2 UC1.AR13(GPP_A13/SUSWARN#/SUSPWRDNACK)
SVI2_SVC: PR609.1 RV97.2 RV181.2
SVI2_SVD: PR615.1 RV96.2 RV180.2
SW_1.00VS: PC704.2 PL701.1 PR708.2 PU701.6(SW1) PU701.7(SW2) PU701.8(SW3) PU701.9(SW4)
SW_1A: PR412.2 PR451.2
SW_1B: PR438.2 PR459.2
SW_1PH: PC462.1 PL408.1 PQ407.1(S1) PQ407.2(S2) PQ407.3(S3) PQ408.5(D) PR458.2 PR459.1 PU404.7(SW)
SW_A1: PC442.1 PL403.1 PQ401.1(S1) PQ401.2(S2) PQ401.3(S3) PQ402.5(D) PQ403.5(D) PR450.2 PR451.1 PU402.7(SW)
SW_B1: PC453.1 PL406.1 PQ404.1(S1) PQ404.2(S2) PQ404.3(S3) PQ405.5(D) PQ406.5(D) PR454.2 PR455.1 PU403.7(SW)
SYS_RESET#: RC108.2 UC1.B5(SYS_RESET#)
SYSON: D62.2 D64.2 PR312.1 R9492.1 RE52.1 U7.4(EN)
SYSON_EC: CE14.1 D62.1 RPE4.5(R5) UE1.107(DTR1#/SBUSY/GPG1/ID7)
THRMTRIP#: RC53.2 RC54.2 UC1.C63(THERMTRIP#)
TON_1.35V: PR309.2 PU301.9(TON)
TP_CLK2: JCP.5 JTP.6 R63.2
TP_DATA2: JCP.4 JTP.1 R65.2
TP_RESET: JTP.2 R59.2 R60.2 R64.2
TP_REST: JCP.11 R64.1 R66.1 RC429.1 RC432.2
TP_REST_EC: RC432.1 UE1.72(ADC6/DSR1#/GPI6)
TP_REST_R: RC429.2 UC1.W4(GPP_C10/UART0_RTS#)
TS_OFF#: D11.2 D60.2 JTOUCH.2 R217.2
UART2_RX: TP941.1 UC1.AD1(GPP_C20/UART2_RXD)
UART2_TX: TP942.1 UC1.AD2(GPP_C21/UART2_TXD)
USB2_ID: RC407.2 UC1.AG3(USB2_ID)
USB2_VBUSSENSE: RC406.2 UC1.AG4(USB2_VBUSSENSE)
USB3P1_RXN: L10.1 UC1.H8(USB3_1_RXN)
USB3P1_RXN_CON: D8.5(IN4) D8.6(OUT1) JUSB1.5(STDA_SSRX-) L10.2
USB3P1_RXP: L10.4 UC1.G8(USB3_1_RXP)
USB3P1_RXP_CON: D8.4(IN3) D8.7(OUT2) JUSB1.6(STDA_SSRX+) L10.3
USB3P1_TXN: C124.1 UC1.C13(USB3_1_TXN)
USB3P1_TXN_C: C124.2 L9.1
USB3P1_TXN_CON: D8.2(IN2) D8.8(OUT3) JUSB1.8(STDA_SSTX-) L9.2
USB3P1_TXP: C121.1 UC1.D13(USB3_1_TXP)
USB3P1_TXP_C: C121.2 L9.4
USB3P1_TXP_CON: D8.1(IN1) D8.9(OUT4) JUSB1.9(STDA_SSTX+) L9.3
USB3P2_RXN: L18.1 UC1.J6(USB3_2_RXN/SSIC_1_RXN)
USB3P2_RXN_CON: D16.5(IN4) D16.6(OUT1) JUSB2.5(STDA_SSRX-) L18.2
USB3P2_RXP: L18.4 UC1.H6(USB3_2_RXP/SSIC_1_RXP)
USB3P2_RXP_CON: D16.4(IN3) D16.7(OUT2) JUSB2.6(STDA_SSRX+) L18.3
USB3P2_TXN: C8530.1 UC1.B13(USB3_2_TXN/SSIC_1_TXN)
USB3P2_TXN_C: C8530.2 L19.1
USB3P2_TXN_CON: D16.2(IN2) D16.8(OUT3) JUSB2.8(STDA_SSTX-) L19.2
USB3P2_TXP: C8529.1 UC1.A13(USB3_2_TXP/SSIC_1_TXP)
USB3P2_TXP_C: C8529.2 L19.4
USB3P2_TXP_CON: D16.1(IN1) D16.9(OUT4) JUSB2.9(STDA_SSTX+) L19.3
USB3P3_RXN: L6.4 R169.1 UC1.J10(USB3_3_RXN/SSIC_2_RXN)
USB3P3_RXN_COAX_CON: JU3LC.14 L6.3 R169.2
USB3P3_RXP: L6.1 R170.1 UC1.H10(USB3_3_RXP/SSIC_2_RXP)
USB3P3_RXP_COAX_CON: JU3LC.13 L6.2 R170.2
USB3P3_TXN: L12.4 R176.1 UC1.B15(USB3_3_TXN/SSIC_2_TXN)
USB3P3_TXN_COAX_CON: JU3LC.11 L12.3 R176.2
USB3P3_TXP: L12.1 R175.1 UC1.A15(USB3_3_TXP/SSIC_2_TXP)
USB3P3_TXP_COAX_CON: JU3LC.10 L12.2 R175.2
USB3P4_RXN: L7.4 R172.1 UC1.E10(USB3_4_RXN)
USB3P4_RXN_COAX_CON: JU3LC.20 L7.3 R172.2
USB3P4_RXP: L7.1 R171.1 UC1.F10(USB3_4_RXP)
USB3P4_RXP_COAX_CON: JU3LC.19 L7.2 R171.2
USB3P4_TXN: L8.4 R174.1 UC1.C15(USB3_4_TXN)
USB3P4_TXN_COAX_CON: JU3LC.17 L8.3 R174.2
USB3P4_TXP: L8.1 R173.1 UC1.D15(USB3_4_TXP)
USB3P4_TXP_COAX_CON: JU3LC.16 L8.2 R173.2
USB3P5_RXN: L16.4 R165.1 UC1.H13(PCIE1_RXN/USB3_5_RXN)
USB3P5_RXN_CON: JLCD.32 L16.3 R165.2
USB3P5_RXP: L16.1 R166.1 UC1.G13(PCIE1_RXP/USB3_5_RXP)
USB3P5_RXP_CON: JLCD.33 L16.2 R166.2
USB3P5_TXN: C28.1 UC1.B17(PCIE1_TXN/USB3_5_TXN)
USB3P5_TXN_C: C28.2 L17.4 R167.1
USB3P5_TXN_CON: JLCD.35 L17.3 R167.2
USB3P5_TXP: C29.1 UC1.A17(PCIE1_TXP/USB3_5_TXP)
USB3P5_TXP_C: C29.2 L17.1 R168.1
USB3P5_TXP_CON: JLCD.36 L17.2 R168.2
USB20_N1: L11.1 UC1.AB9(USB2N_1)
USB20_N1_CON: D7.1(CH1) JUSB1.2(D-) L11.2
USB20_N2: AOU1.2(DM_OUT) UC1.AD6(USB2N_2)
USB20_N2_CON: D17.1(CH1) JUSB2.2(D-) L20.2
USB20_N3: L5.4 R163.1 UC1.AH3(USB2N_3)
USB20_N3_FFC_CON: JU3LF.22 L5.3 R163.2
USB20_N4: L13.4 R177.1 UC1.AD9(USB2N_4)
USB20_N4_FFC_CON: JU3LF.25 L13.3 R177.2
USB20_N5: L22.1 R9472.1 UC1.AJ1(USB2N_5)
USB20_N5_CON: JTOUCH.4 L22.2 R9472.2
USB20_N6: JWLBT.5(USB_D-) UC1.AF6(USB2N_6)
USB20_N7: L15.4 UC1.AH1(USB2N_7)
USB20_N7_CMOS: JLCD.17 L15.3
USB20_N9: D4.3 JFPB.3 UC1.AF8(USB2N_8)
USB20_P1: L11.4 UC1.AB10(USB2P_1)
USB20_P1_CON: D7.6(CH4) JUSB1.3(D+) L11.3
USB20_P2: AOU1.3(DP_OUT) UC1.AD7(USB2P_2)
USB20_P2_CON: D17.6(CH4) JUSB2.3(D+) L20.3
USB20_P3: L5.1 R164.1 UC1.AJ3(USB2P_3)
USB20_P3_FFC_CON: JU3LF.23 L5.2 R164.2
USB20_P4: L13.1 R178.1 UC1.AD10(USB2P_4)
USB20_P4_FFC_CON: JU3LF.26 L13.2 R178.2
USB20_P5: L22.4 R9473.1 UC1.AJ2(USB2P_5)
USB20_P5_CON: JTOUCH.5 L22.3 R9473.2
USB20_P6: JWLBT.3(USB_D+) UC1.AF7(USB2P_6)
USB20_P7: L15.1 UC1.AH2(USB2P_7)
USB20_P7_CMOS: JLCD.18 L15.2
USB20_P9: D4.2 JFPB.2 UC1.AF9(USB2P_8)
USB20N2: AOU1.11(DM_IN) L20.1
USB20P2: AOU1.10(DP_IN) L20.4
USB_OC0#: RPC15.8(R8) U15.3(O\C\) UC1.A9(GPP_E9/USB2_OC0#)
USB_OC1#: AOU1.13(FAULT#) RPC15.7(R7) UC1.C9(GPP_E10/USB2_OC1#)
USB_OC2#: JU3LF.2 RPC15.6(R6) UC1.D9(GPP_E11/USB2_OC2#)
USB_OC3#: RPC15.5(R5) UC1.B9(GPP_E12/USB2_OC3#)
USB_ON#: JU3LF.3 RE2.1 U15.4(E\N\) UE1.33(GINT/CTS0#/GPD5)
USBCOMP: RC384.1 UC1.AB6(USB2_COMP)
VBUCK_1V5: CVG39.1 CVG40.1 CVG41.1 CVG44.1 L21.2 UVG2.6(VDDA15_DP) UVG2.27(VDDA15_DAC) UVG2.28(VDDD15)
VGA_AC_DC#: DV5.1 UE1.126(GA20/GPB5)
VGA_BLUE: R231.1 UVG2.21(BLU)
VGA_BLUE_CON: CT28.1 DT1.6(CH4) JCRT.3 LT1.2
VGA_BLUE_R: CT24.1 LT1.1 R231.2 RT23.1
VGA_DDC_SCL: QT1.1(S1) RT28.1 RT36.2 UVG2.16(DDC_SCL)
VGA_DDC_SCL_CON: DT2.3(CH2) JCRT.15 QT1.6(D1) RT14.2 RT28.2
VGA_DDC_SDA: QT1.4(S2) RT29.1 RT37.2 UVG2.18(DDC_SDA)
VGA_DDC_SDA_CON: DT2.4(CH3) JCRT.12 QT1.3(D2) RT13.2 RT29.2
VGA_GREEN: R230.1 UVG2.22(GRN)
VGA_GREEN_CON: CT27.1 DT1.3(CH2) JCRT.2 LT2.2
VGA_GREEN_R: CT26.1 LT2.1 R230.2 RT22.1
VGA_HSYNC: RT34.1 RVG18.2 UT3.2(A)
VGA_HSYNC_1: RT20.1 RT34.2 UT3.4(Y)
VGA_HSYNC_CON: DT2.6(CH4) JCRT.13 RT20.2
VGA_HSYNC_L: RVG18.1 UVG2.20(HSYNC)
VGA_LGATE1: PQ602.4(G) PQ603.4(G) PU601.24(LGATE1)
VGA_LGATE2: PQ605.4(G) PQ606.4(G) PU601.27(LGATE2)
VGA_ON: DV7.1 PR603.1 QV18.2(G1) RPC9.2(R2) RV13.2 RV153.1 RV183.1 RV188.1 UC1.U8(GPP_C18/I2C1_SDA)
VGA_PHASE1: PC612.2 PL603.1 PQ601.1(S1) PQ601.2(S2) PQ601.3(S3) PQ602.5(D) PQ603.5(D) PR607.2 PR608.2 PR616.2 PU601.23(PHASE1)
VGA_PHASE2: PC618.2 PL604.1 PQ604.1(S1) PQ604.2(S2) PQ604.3(S3) PQ605.5(D) PQ606.5(D) PR630.2 PR631.2 PR632.2 PU601.28(PHASE2)
VGA_RED: R229.1 UVG2.24(RED)
VGA_RED_CON: CT25.1 DT1.1(CH1) JCRT.1 LT3.2
VGA_RED_R: CT29.1 LT3.1 R229.2 RT21.1
VGA_UGATE1: PQ601.4(G) PU601.22(UGATE1)
VGA_UGATE2: PQ604.4(G) PU601.29(UGATE2)
VGA_VSYNC: RT35.1 RVG19.2 UT4.2(A)
VGA_VSYNC_1: RT27.1 RT35.2 UT4.4(Y)
VGA_VSYNC_CON: DT2.1(CH1) JCRT.14 RT27.2
VGA_VSYNC_L: RVG19.1 UVG2.19(VSYNC)
VGATE: PR406.1 PU401.38(VR_RDY) UE1.78(DAC2/TACH0B/GPJ2)
VMB: PC9.1 PF2.1 PL3.1 PL4.1
VMB2: JBATT1.1 JBATT1.2 PF2.2
VR_HOT#: CE17.1 PR126.1 PR409.2 QE1.1(D) RC5.1 RC294.2
VR_HOT#_R: RC5.2 UC1.C65(PROCHOT#)
VR_HOT_R#: PR126.2 PU101.10(PROCHOT#)
VR_ON: D59.2 D61.2 PR407.1 QC3.2(G1) RE51.1
VR_ON_EC: D61.1 UE1.30(PWM4/GPA4)
VR_SVID_ALRT#: PR408.1 RC19.2 RC20.2
VR_SVID_ALRT#_R: RC19.1 UC1.B63(VIDALERT#)
VR_SVID_CLK: PR404.2 PR410.1 RC387.2 UC1.A63(VIDSCK)
VR_SVID_DAT: PR403.2 PR411.1 RC388.2 UC1.D64(VIDSOUT)
VRALERT#: TC24.1 UC1.AM11(GPP_B2/VRALERT#)
VREFG: CV214.1 RV128.1 RV160.2 UV1.AH13(VREFG)
VSUM+: PC633.1 PC634.1 PR608.1 PR631.1 PR633.1 PR634.1 PU601.14(ISUMP)
VSUM-: PC608.1 PC628.1 PC633.2 PC634.2 PC637.2 PR618.1 PR634.2 PR635.2 PR636.1 PR639.2 PRT601.1
VSYSTEM: PC6.1 PC7.1 PC101.1 PD1.2 PD102.2 PL1.2 PL2.2 PQ101.5(D) PR5.1 PR113.1
VTTREF_0.675V: PC315.1 PU301.4(VTTREF)
WLAN_PWRON: R9460.1 UE1.123(CTX0/TMA0/GPB2)
WLAN_PWRON#: Q5.1(D) R28.2 R51.1
WLAN_PWRON_R: Q5.2(G) R69.1 R9460.2
WRST#: CE11.1 IT8.1 RE4.2 UE1.14(WRST#)
XDP_BPM#0: TC1.1 UC1.C55(BPM#[0])
XDP_BPM#1: TC2.1 UC1.D55(BPM#[1])
XDP_BPM#2: TC7.1 UC1.B54(BPM#[2])
XDP_BPM#3: TC9.1 UC1.C56(BPM#[3])
XDP_PRDY_N: TC25.1 UC1.D56(PROC_PRDY#)
XDP_PREQ_N: TC26.1 UC1.D61(PROC_PREQ#)
XDP_TCLK: RC4.1 RC415.1 UC1.B61(PROC_TCK)
XDP_TDI: RC31.1 RC422.1 UC1.D60(PROC_TDI)
XDP_TDO: RC3.1 RC423.1 RC426.1 UC1.A61(PROC_TDO)
XDP_TMS: RC34.1 RC424.1 UC1.C60(PROC_TMS)
XDP_TRST#: RC6.1 RC425.1 UC1.B59(PROC_TRST#)
XTALIN: CV17.1 RV10.1 UV1.AV33(XTALIN) YV1.1(OSC1)
XTALOUT: CV18.1 RV10.2 UV1.AU34(XTALOUT) YV1.3(OSC2)
XTLI: CVG32.1 RVG16.1 UVG2.25(OSC_IN) YVG1.1(OSC1)
XTLO: CVG33.1 RVG16.2 UVG2.26(OSC_OUT) YVG1.3(OSC2)
N09817: PC621.2 PC622.1 PR625.1 PR626.1 PU601.17(RTN)
N09897: PC617.1 PC619.2 PC621.1 PR621.2 PR622.2 PR623.1 PU601.16(VSEN)
N10003: PC610.1 PR613.2
N10023: PC609.2 PC610.2 PR619.2 PU601.19(COMP)
N10051: PC609.1 PR613.1 PR617.2 PR623.2 PR624.1 PU601.18(FB)
N10079: PC617.2 PR617.1
N10153: PC620.1 PR624.2
N13273: PC635.1 PR635.1 PU601.15(ISUMN)
N13333: PC635.2 PR639.1
N13487: PR633.2 PRT601.2
N18669: PC612.1 PR614.2
N18705: PR614.1 PU601.21(BOOT1)
N22144: PC618.1 PR620.2
N22186: PR620.1 PU601.30(BOOT2)
N32858: PC636.2 PR642.1 PU601.10(IMON)
N34928: PC605.1 PR602.1 PU601.26(VDDP)
N41772: PC601.1 PR603.2 PU601.8(ENABLE)
N193745: PR641.1 PRT602.1 PU601.11(NTC)
N14385930: RV7.2 UV1.AH16(TEST_PG)
N14386081: RV6.1 UV1.Y30(PCIE_CALR_TX)
N14386085: RV8.1 UV1.Y29(PCIE_CALR_RX)
N14410135: RV26.2 UV1.M27(MEM_CALRP0)
N14437159: RV17.2 UV1.AM39(DPEF_CALR)
N15168718: PC310.2 PR303.1
N15172206: PR301.2 PU301.11(VID)
N15172224: PC316.1 PR306.2 PU301.12(VDD)
N15173757: PR308.1 PU301.10(PGOOD)
N15178230: PR302.2 PU301.13(CS)
N15269244: PC805.2 PR804.2 PR805.1 PU801.6(FB)
N15269410: PC804.2 PR803.1
N16794113: PR120.2 PU101.11(SDA)
N16794114: PR121.2 PU101.12(SCL)
N16794121: PC104.2 PC105.2 PC107.1 PL101.2 PR101.1 PR107.1
N16794165: PC115.1 PR114.1 PU101.28(VCC)
N16794166: PD102.1 PD103.1 PR114.2
N16794173: PC118.2 PR116.2
N16794272: PR111.2 PU101.4(ACDRV)
N16794274: PR112.2 PU101.3(CMSRC)
N16794279: PC101.2 PC102.2 PD101.2 PQ102.4(G) PQ103.1(D) PR102.2 PR111.1
N16794300: PC117.2 PR113.2 PR115.2 PU101.6(ACDET)
N16794308: PR118.2 PU101.5(ACOK)
N16794310: PC126.2 PR123.1
N16794335: PQ103.2(G) PR104.1 PR105.2
N16794344: PR122.2 PU101.7(IADP)
N16794345: PR123.2 PU101.8(IDCHG)
N16794346: PR124.2 PU101.9(PMON)
N16797507: PD1.1 PD3.1 PR2.2 PR3.2
N16797515: PC1.2 PQ1.1 PQ2.2(B) PR3.1 PRT1.2
N16797523: PQ1.3 PR1.2 PR2.1
N16797527: PD2.1 PQ1.2 PQ2.1(C) PR1.1
N16797541: PRT4.1 PRT5.1
N16797550: PRT2.1 PRT5.2
N16797569: PRT2.2 PRT6.1
N16797599: PRT1.1 PRT3.2
N16797601: PRT3.1 PRT4.2
N16880265: PR611.1 T96.1
N16880284: PR606.2 PU601.9(PWROK)
N16880287: PR609.2 PU601.3(SVC)
N16880290: PR615.2 PU601.5(SVD)
N16880296: PR611.2 PU601.7(SVT)
N16880299: PR610.2 PU601.4(VR_HOT_L)
N16901916: PC616.1 PR607.1
N16902103: PC632.1 PR630.1
N16922606: PR129.2 PU101.21(ILIM)
N16922622: PC128.1 PR129.1 PR130.2 PR131.1 PR132.1
N16922664: PR131.2 PU101.16(TB_STAT#)
N16922835: PC121.1 PR119.1
N16954250: JBATT1.5 PR16.2 PR17.1
N19577504: RL5.2 UL1.33(JTAG_TMS)
N19577505: RL6.2 UL1.35(JTAG_TCK)
N19577517: RL7.1 UL1.30(TEST_EN)
N19577520: RL8.1 UL1.12(RBIAS)
N19577582: RL4.1 UL1.1(RSVD1_VCC3P3)
N26325477: PC432.1 PC433.1 PC434.1 PC435.1 PC436.1 PC437.1 PC438.1 PL401.1 PL402.1 PQ401.5(D)
N26386889: PC445.1 PR450.1
N31349437: PC442.2 PR449.1
N31349441: PR449.2 PU402.1(BST)
N31382737: PC446.1 PC447.1 PC448.1 PC449.1 PC450.1 PC451.1 PC452.1 PL404.1 PL405.1 PQ404.5(D)
N31383366: PC456.2 PR454.1
N31383897: PC453.2 PR453.1
N31383905: PR453.2 PU403.1(BST)
N31389989: PC457.1 PC458.1 PC459.1 PC460.1 PC461.1 PL407.1 PQ407.5(D)
N31390138: PC464.1 PR458.1
N31390261: PC462.2 PR457.1
N31390277: PR457.2 PU404.1(BST)
N31396697: PC416.2 PR425.2 PU401.1(IOUT_2PH)
N31396723: PC415.2 PR424.2 PU401.48(VSN_2PH)
N31396745: PC412.2 PR420.2 PU401.27(ILIM_1A)
N31396767: PC411.2 PR421.1 PU401.30(IOUT_1A)
N31396821: PR414.2 PR415.2 PU401.24(VSP_1A)
N31396831: PC404.2 PR414.1
N31396857: PC428.1 PR440.2
N31396859: PC427.2 PC428.2 PU401.43(COMP_1B)
N31396879: PC409.2 PC410.2 PU401.26(COMP_1A)
N31396887: PC410.1 PR419.2
N31396963: PC407.2 PR416.2 PU401.25(VSN_1A)
N31397011: PC429.1 PC439.1 PR438.1 PR439.1 PU401.40(CSP_1B)
N31397019: PR439.2 PRT405.1
N31397040: PR409.1 PU401.31(VR_HOT#)
N31397051: PC424.1 PR435.1 PU401.11(TSENSE_2PH)
N31397062: PR435.2 PR436.2 PRT404.1
N31397070: PR432.1 PU401.5(ILIM_2PH)
N31397078: PC418.1 PC419.1 PR427.1 PR432.2 PRT403.1 PU401.6(CSCOMP_2PH)
N31397084: PC418.2 PC419.2 PR426.1 PR430.2 PU401.7(CSSUM_2PH)
N31397096: PR427.2 PR430.1 PRT403.2
N31397121: PC414.2 PC417.1 PR423.1 PU401.8(CSREF_2PH)
N31397144: PC414.1 PR422.1 PU401.10(CSP1_2PH)
N31397166: PC408.1 PR417.1 PU401.23(TSENSE_1PH)
N31397172: PR417.2 PR418.2 PRT402.1
N31397188: PC401.1 PR401.2 PU401.12(VRMP)
N31397190: PC402.1 PR402.2 PU401.13(VCC)
N31397230: PC441.1 PR407.2 PU401.37(EN)
N31397238: PR410.2 PU401.34(SCLK)
N31397260: PC405.1 PC440.1 PR405.1 PR412.1 PU401.29(CSP_1A)
N31397268: PR405.2 PRT401.1
N31397346: PC431.2 PR441.2 PU401.42(ILIM_1B)
N31397348: PR428.1 PR431.1 PU401.2(DIFFOUT_2PH)
N31397350: PC421.2 PC422.1 PR428.2 PR429.1 PU401.3(FB_2PH)
N31397402: PC420.2 PC422.2 PU401.4(COMP_2PH)
N31397404: PC430.2 PR442.2 PU401.39(IOUT_1B)
N31397538: PR443.2 PU401.14(ROSC_COREGT)
