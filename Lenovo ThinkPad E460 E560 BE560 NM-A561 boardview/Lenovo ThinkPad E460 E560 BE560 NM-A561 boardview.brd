# Allegro board Lenovo ThinkPad E460 E560 BE560 NM-A561 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HP_OUTR_CON: length 3.6
  TOP w0.254: JAUF.8 220.28,9.15 219.21,10.23 218.8,10.23 RA23.2 v2(217.66,10.43)
HPD: length 10.1
  TOP w0.114: TPV17.1 158.5,146.42 157.49,145.4 152.56,145.4 152.15,145 152.15,144.2 v1(152.74,143.62)
  BOTTOM w0.102: v1(152.74,143.62) 152.2,144.16 UV1.AK24
I2C_CLK_GSENSE: length 5.4
  TOP w0.254: UGSEN1.4 v4(209.63,68.44) 210.75,68.44 211.5,67.69 QG2.1
I2C_DATA_GSENSE: length 10
  TOP w0.114: QG2.4 212.8,69.52 211.46,70.86 210.88,70.86 v4(210.34,71.39) 210.29,71.44 207.09,71.44 206.28,70.63 UGSEN1.6
I2CS_SCL: length 8
  TOP w0.114: v1(152.51,142.48) 152.9,142.88 159.3,142.88 TPV13.1
  BOTTOM w0.102: v1(152.51,142.48) 152.51,142.65 UV1.AK26
I2CS_SDA: length 1.8
  TOP w0.114: v1(151.91,142.49) 151.31,143.09 TPV14.1
  BOTTOM w0.102: UV1.AJ26 151.52,142.96 151.91,142.57 v1(151.91,142.49)
ILIM_HI: length 2.8
  TOP w0.114: v4(36.51,15.38) R9476.1 35.15,15.8 AOU1.16
ILIM_LO: length 3.1
  TOP w0.114: AOU1.15 34.65,16.1 34.68,16.07 R484.1 33.86,14.57 v2(33.61,14.57)
ISEN1: length 7.7
  TOP w0.114: PR616.1 215.46,143.82 v4(215.07,143.42)
  TOP w0.254: v3(214.31,148.48) 214.31,148.25 214.75,147.8 214.75,146.41 PC608.2 215.39,144.77 PR616.1
  BOTTOM w0.203: PU601.13 214.13,148.66 v3(214.31,148.48)
ISEN2: length 5
  TOP w0.254: v3(214.89,148.76) 215.25,148.4 v4(215.25,148.22) 215.25,147.12 PC628.2 215.8,146.98 PR632.1
  BOTTOM w0.203: PU601.12 214.53,149.12 v3(214.89,148.76)
ITP_PMODE: length 23.1
  TOP w0.076: v1(112.38,104.08) 112.73,104.43 112.73,105.96 114.23,107.46 114.23,109.77 113.96,110.03 113.96,111.38 113.14,112.21
  TOP w0.114: 113.14,112.21 112.71,112.64 111.92,112.64 v4(111.24,113.32) 110.8,113.76 110.8,114.53 111.44,115.17 RC390.1
  IN3 w0.076: v1(112.38,104.08) 111.74,103.44 111.66,103.44 111.31,103.09 107.46,103.09 107.26,102.88 104.98,102.88 104.74,102.64 v3(104.74,102.47)
  BOTTOM w0.076: v3(104.74,102.47) 104.96,102.24 UC1.E8
JSENSE: length 5.9
  TOP w0.114: UA1.38 212.44,21.79 212.96,21.27 v4(214.41,21.27) 214.41,22.09 RA18.2 RA21.2 RA20.2
JSENSE_CON: length 23.5
  TOP w0.114: JAUF.9 221.52,9.65 221.65,9.52 v3(221.65,9.46) ; v2(218.75,24.09) v3(218.12,24.09) 216.74,24.09 216.54,23.89 216.54,23.74 215.98,23.18 RA21.1 RA20.1
  IN1 w0.14: v3(218.12,24.09) 218.12,23.61 219.13,22.6 219.13,12.13 218.83,11.83 218.83,10.43 219.79,9.46 v3(221.65,9.46)
JTAG_TCK: length 2.7
  TOP w0.114: RV137.1 150.6,145.15 TPV9.1 151.35,145.9 v1(151.66,145.9)
  BOTTOM w0.102: UV1.AK23 152.2,145.36 v1(151.66,145.9)
JTAG_TDI: length 10.1
  TOP w0.114: TPV8.1 162.24,147.18 161.91,147.51 160.94,147.51 RV135.2 158.65,147.03 157.59,145.96 v1(154.74,145.96)
  BOTTOM w0.102: UV1.AN23 154.62,145.36 154.74,145.48 v1(154.74,145.96)
JTAG_TDO: length 8.1
  TOP w0.114: v1(154.16,144.62) 154.34,144.44 158.6,144.44 158.93,144.11 TPV11.1 160.53,144.41 RV136.2
  BOTTOM w0.084: v1(154.16,144.62) 153.8,144.26 UV1.AM24
JTAG_TMS: length 8.7
  TOP w0.114: RV132.2 160.38,146.14 TPV10.1 158.93,144.69 157.38,144.69 156.98,145.1 154.01,145.1 v1(153.57,144.67)
  BOTTOM w0.102: UV1.AL24 153.07,144.16 v1(153.57,144.67)
JTAG_TRSTB: length 11.3
  TOP w0.114: v1(153.81,145.93) 154.5,146.62 156.72,146.62 157.84,147.74 TPV7.1 159.21,147.77 163.12,147.77 RV131.2
  BOTTOM w0.102: v1(153.81,145.93) 153.8,145.93 UV1.AM23
KB_FN: length 116.6
  TOP w0.114: v3(174.35,116.65) 174.39,116.69 JKB.29 ; v3(203.13,52.36) 202.83,52.07 UE1.20 ; RPE1.6 v4(206.82,58.54) 206.38,58.1 v3(206.38,57.77)
  IN1 w0.14: v3(203.13,52.36) 203.13,53.38 206.38,56.63 v3(206.38,57.77)
  BOTTOM w0.114: v3(174.35,116.65) 173.55,117.46 170.54,117.46 169.09,116.02 169.09,114.01 167.25,112.17 167.25,105.85 164.64,103.24 164.64,102.4 165.73,101.31 165.73,95.97 161.99,92.23 161.99,90.98 161.21,90.2 161.21,76.43 174.33,63.31 189.29,63.31 189.7,63.72 190.12,63.72 190.28,63.56 191.97,63.56 192.67,64.26 195.31,64.26 195.48,64.43 196.96,64.43 197.55,63.84 197.55,63.04 202.81,57.77 v3(206.38,57.77)
KBRST#: length 130.7
  TOP w0.114: v3(187.1,48.25) 187.48,48.63 197.34,48.63 198.25,47.72 199.02,47.72 199.57,47.16 199.57,46.39 200.3,45.67 UE1.4 ; v3(119.88,66.11) 119.01,66.97 v4(118.29,66.97) 116.16,64.84 114.61,64.84 113.73,63.96 RPC22.4
  IN2 w0.14: v3(187.1,48.25) 186.49,48.86 183.6,48.86 182.21,47.47 176.37,47.47 175.43,48.41 166.67,48.41 161.43,53.65 159.91,53.65 153.06,60.5 142.62,60.5 140.26,62.86 134.92,62.86 131.59,66.19 130.68,66.19 130.02,65.54 124.6,65.54 123.93,66.21 119.98,66.21 v3(119.88,66.11)
  BOTTOM w0.076: UC1.AW13 102.37,84.19 102.19,84.01 102.19,84.01 101.97,83.31 101.97,83.23 101.92,83.07 101.92,82.93 101.98,82.71 101.98,82.59 101.93,82.48 101.93,82.1 102.13,81.9 102.13,80.94 104.36,78.71
  BOTTOM w0.102: 104.63,75.38 104.63,78.44 104.36,78.71
  BOTTOM w0.114: v3(119.88,66.11) 118.1,67.88 115.88,67.88 115.07,68.7 111.69,68.7 111.08,69.31 109.43,69.31 104.63,74.11 104.63,75.38
KSI0: length 88.1
  TOP w0.114: UE1.58 189.71,60.07 187.99,61.79 v4(185.77,61.79) 185.39,61.41 179.05,61.41 v3(176.82,59.17) ; JKB.12 165.89,117.21 v3(165.61,116.93)
  BOTTOM w0.114: v3(176.82,59.17) 176.31,59.68 172.34,59.68 159.09,72.92 159.09,86.52 158.29,87.32 158.29,92.03 160.93,94.68 160.93,95.22 162.42,96.7 162.42,110.14 165.28,113.01 165.28,116.6 v3(165.61,116.93)
KSI1: length 102.5
  TOP w0.114: v3(171.41,53.79) 171.15,54.04 171.15,56.91 v4(172.14,57.9) 172.9,58.66 176.99,58.66 179.43,61.1 188.12,61.1 189.31,59.91 UE1.59 ; JKB.1 160.39,117.85 160.39,117.29 160.05,116.96 v3(159.9,116.96)
  BOTTOM w0.114: v3(159.9,116.96) 159.9,116.78 158.65,115.53 158.15,115.53 157.99,115.37 157.99,114.04 158.28,113.75 158.28,112.33 158.55,112.05 158.55,96.79 158.28,96.52 158.28,96.35 153.33,91.4 153.33,90.24 153.7,89.86 153.7,86.58 155.82,84.46 155.82,69.81 159.14,66.49 159.14,62.93 168.7,53.37 170.99,53.37 v3(171.41,53.79)
KSI2: length 89.9
  TOP w0.114: v3(176.79,57.88) v4(178.5,59.59) 179.74,60.82 188.04,60.82 188.91,59.95 UE1.60 ; JKB.8 163.89,116.02 v3(163.51,115.64)
  BOTTOM w0.114: v3(163.51,115.64) 163.51,112.25 161.7,110.44 161.7,97 160.21,95.52 160.21,94.98 157.57,92.33 157.57,91.13 155.97,89.53 155.97,88.15 158.3,85.82 158.3,72.44 169.53,61.21 169.53,60.26 171.1,58.69 175.29,58.69 176.1,57.88 v3(176.79,57.88)
KSI3: length 90.6
  TOP w0.114: v5(176.79,57.14) 180.22,60.57 187.71,60.57 188.51,59.77 UE1.61 ; v3(164.39,116.91) JKB.9
  BOTTOM w0.114: v3(164.39,116.91) 164.13,116.91 163.02,115.8 163.02,112.21 161.45,110.64 161.45,97.1 159.97,95.62 159.97,95.08 157.33,92.43 157.33,91.23 155.73,89.63 155.73,87.96 158.04,85.64 158.04,72.35 169.2,61.2 169.2,60.19 171.05,58.33 174.83,58.33 176.03,57.14 v5(176.79,57.14)
KSI4: length 92
  TOP w0.114: v3(173.06,56.15) 173.46,56.15 173.97,56.66 v4(174.17,56.66) 177.07,56.66 180.73,60.31 187.38,60.31 188.11,59.58 UE1.62 ; JKB.5 162.39,117.26 v3(161.98,116.85)
  BOTTOM w0.114: v3(161.98,116.85) 161.68,116.55 161.68,115.76 160.89,114.97 160.89,113.33 160.56,113 160.56,97.29 159.25,95.97 159.25,95.38 156.6,92.73 156.6,91.53 155,89.93 155,87.48 157.08,85.4 157.08,70.55 162.72,64.91 162.72,63.74 170.11,56.35 172.85,56.35 v3(173.06,56.15)
KSI5: length 90.5
  TOP w0.114: UE1.63 187.71,59.45 187.1,60.06 181.39,60.06 178.49,57.16 v5(178.49,57.06) ; JKB.6 162.89,117.1 v3(162.64,116.85)
  BOTTOM w0.114: v5(178.49,57.06) 177.78,56.35 175.42,56.35 174.88,56.89 171.42,56.89 166.35,61.97 165.79,61.97 164.22,63.54 164.22,65.45 157.54,72.13 157.54,85.28 155.24,87.58 155.24,89.83 156.84,91.43 156.84,92.63 159.49,95.28 159.49,95.87 160.97,97.36 160.97,113.07 161.14,113.24 161.14,114.67 161.93,115.46 161.93,116.14 v3(162.64,116.85)
KSI6: length 95.8
  TOP w0.114: v3(176.46,53.86) IT7.1 177.79,56.17 178.26,56.17 180.88,58.79 180.88,59.15 181.54,59.81 186.95,59.81 187.31,59.44 UE1.64 ; JKB.3 161.39,117.41 161.17,117.18 161.17,116.73 160.38,115.94 v3(160.31,115.94)
  BOTTOM w0.114: v3(160.31,115.94) 160.31,113.45 159.24,112.38 159.24,96.65 158.76,96.17 158.76,96.01 155,92.25 155,91.13 154.24,90.37 154.24,86.93 156.3,84.87 156.3,70.01 159.8,66.51 159.8,62.97 168,54.76 171.44,54.76 172.35,53.86 v3(176.46,53.86)
KSI7: length 100.6
  TOP w0.114: IT6.1 184.94,56.87 UE1.65 186.92,56.87 v3(188.12,55.67) ; JKB.2 160.89,117.11 v3(160.66,116.88)
  BOTTOM w0.114: v3(160.66,116.88) 160.51,116.88 159.26,115.64 159.26,115.18 158.52,114.44 158.52,112.52 158.86,112.18 158.86,96.64 158.52,96.3 158.52,96.25 153.57,91.3 153.57,90.39 153.96,90 153.96,86.7 156.06,84.6 156.06,69.91 159.42,66.55 159.42,63.01 167.9,54.52 171.3,54.52 172.42,53.41 180.02,53.41 181.72,55.11 187.56,55.11 v3(188.12,55.67)
KSO0: length 103.2
  TOP w0.114: v3(184.31,58.71) 185.6,57.42 186.72,57.42 187.41,56.73 190.4,56.73 191.22,55.92 193.99,55.92 195.43,57.37 198.29,57.37 198.51,57.59 UE1.36 ; v3(163.28,116.85) 163.39,116.97 JKB.7 163.39,118.42 v4(162.44,119.37)
  BOTTOM w0.114: v3(184.31,58.71) 183.83,58.23 179.04,58.23 177.44,56.63 175.67,56.63 174.25,58.05 170.82,58.05 166.48,62.4 166.48,63.53 157.79,72.22 157.79,85.41 155.48,87.72 155.48,89.73 157.09,91.33 157.09,92.53 159.73,95.18 159.73,95.72 161.21,97.2 161.21,110.74 162.78,112.31 162.78,116.36 v3(163.28,116.85)
KSO1: length 102.4
  TOP w0.114: RPE2.8 199.69,60.35 v3(199.52,60.19) 199.24,60.19 198.71,59.65 198.33,59.65 198.11,59.44 UE1.37 ; v4(164.5,119.5) 165.39,118.6 JKB.11 165.39,117.37 165.16,117.13 165.16,116.27 164.8,115.91 v3(164.8,115.64)
  BOTTOM w0.114: v3(164.8,115.64) 164.8,112.86 162.18,110.24 162.18,96.8 160.69,95.32 160.69,94.78 158.05,92.13 158.05,87.18 158.83,86.4 158.83,72.84 172.4,59.27 175.75,59.27 176.29,58.73 179.98,58.73 182.19,60.94 196.3,60.94 197.56,59.68 199.02,59.68 v3(199.52,60.19)
KSO2: length 99.1
  TOP w0.114: JKB.13 166.39,117.25 166.07,116.93 166.07,115.89 v3(165.84,115.66) ; RPE2.7 199.19,61.66 199.02,61.83 198.01,61.83 197.62,62.22 197.24,62.22 v2(197.03,62.02) 197.03,61.15 v3(197.8,60.39) 197.71,60.31 UE1.38
  BOTTOM w0.114: v3(165.84,115.66) 165.84,113.22 162.66,110.04 162.66,95.43 161.2,93.98 160.57,93.98 158.58,91.98 158.58,89.17 159.37,88.38 159.37,73.04 171.22,61.18 197,61.18 v3(197.8,60.39)
KSO3: length 96
  TOP w0.114: UE1.39 197.31,60.44 196.68,61.08 196.68,63.36 197.03,63.72 197.03,63.92 v2(196.91,64.05) 196.81,64.15 196.48,64.15 v3(196.3,63.97) ; v3(168.79,116.85) 168.89,116.96 JKB.18
  BOTTOM w0.114: v3(196.3,63.97) 196.14,63.82 192.87,63.82 191.88,62.83 174.1,62.83 173.67,62.39 172.63,62.39 160.64,74.39 160.64,88.91 159.87,89.68 159.87,91.57 161.08,92.77 161.82,92.77 163.87,94.81 163.87,109.49 168.41,114.04 168.41,116.47 v3(168.79,116.85)
KSO4: length 98.5
  TOP w0.114: v3(166.71,116.88) 166.89,117.06 JKB.14 ; v3(167.34,65.78) 167.82,66.26 v4(169.22,66.26) 178.11,66.26 178.95,65.42 188.94,65.42 191.38,67.86 192.64,67.86 194.52,65.98 195.89,65.98 196.2,65.67 196.2,64.76 195.79,64.35 195.79,63.84 196.42,63.21 196.42,60.95 197.01,60.36 197.01,59.73 196.91,59.63 UE1.40
  BOTTOM w0.114: v3(166.71,116.88) 166.33,116.5 166.33,113.36 162.9,109.94 162.9,95.33 161.3,93.73 160.68,93.73 158.83,91.89 158.83,89.3 159.62,88.51 159.62,73.5 v3(167.34,65.78)
KSO5: length 97.2
  TOP w0.114: UE1.41 196.51,59.39 195.94,59.96 v2(195.94,60.59) 196.22,60.59 196.51,60.3 v3(196.51,60.11) ; v3(164.17,115.64) 164.89,116.36 JKB.10
  BOTTOM w0.114: v3(164.17,115.64) 164.17,112.57 161.94,110.34 161.94,96.9 160.45,95.42 160.45,94.88 157.81,92.23 157.81,87.04 158.58,86.27 158.58,72.6 169.81,61.37 169.81,60.44 171.28,58.97 175.65,58.97 176.12,58.49 180.17,58.49 182.38,60.7 195.92,60.7 v3(196.51,60.11)
KSO6: length 96.1
  TOP w0.114: v4(168.87,119.42) 168.39,118.94 JKB.17 168.39,117.09 v3(168.13,116.83) ; UE1.42 196.11,59.3 195.36,60.06 195.36,61.1 196.16,61.9 196.16,62.83 195.71,63.28 v3(195.71,63.29)
  BOTTOM w0.114: v3(195.71,63.29) 192.68,63.29 191.98,62.59 174.2,62.59 173.77,62.15 172.49,62.15 160.38,74.26 160.38,88.81 159.62,89.57 159.62,91.65 160.98,93.01 161.66,93.01 163.63,94.98 163.63,109.64 168.13,114.14 v3(168.13,116.83)
KSO7: length 95.2
  TOP w0.114: v3(166.83,115.66) 166.83,116.19 167.39,116.75 JKB.15 167.39,118.69 v4(166.68,119.39) ; UE1.43 195.69,58.52 195.69,59.35 195.08,59.96 195.08,61.48 v3(195.61,62.02)
  BOTTOM w0.114: v3(195.61,62.02) 195.61,61.78 195.26,61.43 172.38,61.43 159.87,73.93 159.87,88.61 159.12,89.37 159.12,91.84 160.78,93.49 161.4,93.49 163.14,95.23 163.14,109.84 166.83,113.53 v3(166.83,115.66)
KSO8: length 94.8
  TOP w0.114: JKB.16 167.89,117.25 167.67,117.03 167.67,116.58 167.49,116.4 v3(167.49,115.61) ; v3(195.67,62.65) 195.57,62.75 194.57,62.75 v2(194.52,62.7) 194.49,62.68 194.49,61.81 194.84,61.47 194.84,59.82 195.31,59.34 UE1.44
  BOTTOM w0.114: v3(167.49,115.61) 167.49,113.85 163.39,109.74 163.39,95.08 161.56,93.25 160.88,93.25 159.37,91.74 159.37,89.47 160.13,88.71 160.13,74.08 172.32,61.89 173.89,61.89 174.33,62.32 192.28,62.32 192.44,62.16 193.47,62.16 193.96,62.65 v3(195.67,62.65)
KSO9: length 101.1
  TOP w0.114: v3(161.14,115.94) 161.42,116.22 161.42,116.98 161.89,117.45 JKB.4 ; v3(178.24,55.46) 180.68,57.9 v4(180.9,57.9) 181.13,57.9 182.68,59.45 185.45,59.45 186.62,58.28 186.62,57.88 187.48,57.01 190.56,57.01 191.4,56.17 193.86,56.17 194.91,57.23 UE1.45
  BOTTOM w0.114: v3(161.14,115.94) 160.56,115.36 160.56,113.34 159.51,112.29 159.51,96.58 159,96.07 159,95.48 156.36,92.83 156.36,91.63 154.76,90.03 154.76,87.3 156.84,85.22 156.84,70.45 162.48,64.81 162.48,63.64 170.01,56.11 172.46,56.11 172.98,55.59 174.43,55.59 174.55,55.46 v3(178.24,55.46)
KSO10: length 92.1
  TOP w0.114: UE1.46 194.51,61.08 194.11,61.48 194.11,63.16 195.71,64.76 v5(195.71,65.5) ; v3(171.39,116.47) JKB.23
  BOTTOM w0.114: v3(171.39,116.47) 170.87,116.47 170.08,115.69 170.08,113.76 168.64,112.31 168.64,105.87 166.92,104.15 166.92,102.7 166.45,102.23 166.45,95.66 162.77,91.98 162.77,76 174.03,64.75 183.04,64.75 183.66,64.13 188.91,64.13 189.62,64.84 193.33,64.84 193.53,64.63 194.85,64.63 v5(195.71,65.5)
KSO11: length 90.3
  TOP w0.114: v3(193.91,65.09) v4(193.91,64.38) 192.44,62.91 192.44,60.64 192.51,60.57 UE1.51 ; v3(172.01,113.96) 170.89,115.08 JKB.22
  BOTTOM w0.114: v3(172.01,113.96) 171.61,114.37 171.1,114.37 168.88,112.14 168.88,105.77 167.16,104.05 167.16,102.6 166.69,102.13 166.69,95.56 163.02,91.89 163.02,76.09 174.13,64.99 183.14,64.99 183.76,64.37 187.68,64.37 188.4,65.09 v3(193.91,65.09)
KSO12: length 86.8
  TOP w0.114: UE1.52 192.11,63.09 192.61,63.59 192.61,65.29 v5(192.33,65.57) ; v3(170.73,112.6) 169.39,113.94 JKB.19
  BOTTOM w0.114: v3(170.73,112.6) 171.96,111.37 171.96,107.83 167.89,103.75 167.89,102.3 167.42,101.83 167.42,95.26 163.83,91.67 163.83,76.33 174.38,65.78 187.56,65.78 188.09,66.31 191.6,66.31 v5(192.33,65.57)
KSO13: length 87.3
  TOP w0.114: JKB.20 169.89,114.36 v3(171.62,112.63) ; v3(191.67,65.57) 192.21,65.04 192.21,63.87 v4(192.16,63.82) 191.71,63.38 UE1.53
  BOTTOM w0.114: v3(191.67,65.57) 191.24,66 188.17,66 187.7,65.54 174.28,65.54 163.58,76.23 163.58,91.77 167.18,95.36 167.18,101.93 167.65,102.4 167.65,103.85 169.42,105.63 169.42,111.95 170.52,113.04 171.2,113.04 v3(171.62,112.63)
KSO14: length 85.9
  TOP w0.114: v3(171.38,113.91) 170.77,113.91 170.39,114.29 JKB.21 ; UE1.54 191.31,63.46 191.78,63.92 191.78,64.81 v5(191.04,65.55)
  BOTTOM w0.114: v3(171.38,113.91) 171.02,113.91 169.12,112 169.12,105.67 167.4,103.95 167.4,102.5 166.93,102.03 166.93,95.46 163.28,91.81 163.28,76.18 174.16,65.29 188.12,65.29 188.37,65.55 v5(191.04,65.55)
KSO15: length 87.8
  TOP w0.114: v3(172.22,116.52) 171.89,116.85 JKB.24 ; v3(191.17,64) 191.06,63.9 191.06,60.59 v4(190.91,60.44) UE1.55
  BOTTOM w0.114: v3(172.22,116.52) 171.81,116.93 170.87,116.93 169.75,115.81 169.75,113.81 168.4,112.45 168.4,105.97 166.68,104.26 166.68,102.8 166.21,102.33 166.21,95.76 162.52,92.07 162.52,90.54 161.69,89.72 161.69,76.74 173.93,64.51 182.94,64.51 183.57,63.87 189.06,63.87 189.64,64.45 190.71,64.45 v3(191.17,64)
KSO16: length 95.8
  TOP w0.114: v4(191.74,66.95) 191.68,66.89 191.63,66.89 190.1,65.36 190.1,64.47 190.51,64.05 v3(190.51,64) UE1.56 ; JKB.31 175.39,117.11 v3(175.57,116.93)
  BOTTOM w0.114: v3(190.51,64) 189.54,64 189.16,63.62 183.49,63.62 182.84,64.26 173.81,64.26 161.45,76.62 161.45,89.98 162.24,90.77 162.24,92.13 165.97,95.86 165.97,101.41 164.88,102.5 164.88,103.14 167.49,105.75 167.49,111.95 169.42,113.88 169.42,115.86 170.77,117.21 172.98,117.21 174,116.19 174.83,116.19 v3(175.57,116.93)
KSO17: length 102
  TOP w0.114: v3(176.54,116.91) 175.89,117.55 JKB.32 ; v3(189.92,63.29) 187.99,63.29 187.48,63.79 185.48,63.79 v4(185.22,63.53) 185.22,63.19 186.16,62.25 188.17,62.25 190.11,60.3 UE1.57
  BOTTOM w0.114: v3(176.54,116.91) 175.74,117.7 170.29,117.7 168.71,116.12 168.71,113.98 164.11,109.38 164.11,94.69 161.95,92.53 161.18,92.53 160.13,91.48 160.13,89.78 160.94,88.97 160.94,76.29 174.16,63.07 189.71,63.07 v3(189.92,63.29)
LAN_PWRON: length 294.9
  TOP w0.114: UE1.97 187.31,42.36 186.44,41.49 180.19,41.49 179.43,42.26 176.14,42.26 172.68,38.8 171.3,38.8 167.32,34.81 159.39,34.81 157.79,33.21 153.45,33.21 v3(150.25,36.41) ; v3(56.23,112.47) v4(57.12,112.47) 58.17,113.53 RL25.1
  IN2 w0.14: v3(150.25,36.41) 151.24,37.41 151.24,40.88 149.1,43.02 141.71,43.02 140.26,44.46 136.58,44.46 135.31,43.19 128.95,43.19 128.05,42.29 128.05,34.62 123.75,30.33 123.75,17.17 122.2,15.61 50.34,15.61 37.93,28.02 37.93,30.06 38.26,30.39 38.26,34.03 33.33,38.95 33.33,64.28 32.52,65.09 32.52,66.71 30.94,68.29 30.94,70.42 31.35,70.83 31.35,72.76 33.1,74.5 33.1,76.23 34.72,77.85 34.72,78.34 38.12,81.74 38.12,82.88 40.4,85.17 40.4,93.68 50.13,103.41 50.13,106.05 53.19,109.12 53.19,110.77 54.9,112.47 v3(56.23,112.47)
LAN_PWRON#: length 12
  TOP w0.114: RL22.2 58.76,116.98 v4(59.37,116.37)
  TOP w0.254: RL22.2 RL24.1 58.5,118.68 58.48,118.68 58.22,118.94 58.22,123.1 57.82,123.51 55.91,123.51 55.06,122.66 QL3.1
LAN_PWRON_R: length 7.5
  TOP w0.114: RL25.2 57.23,114.92 v4(56.24,114.92)
  TOP w0.254: RL25.2 RL23.1 57.26,116.05 57,116.31 57,118.86 57.31,119.17 57.31,120.28 QL3.2
LAN_WAKE#: length 353.3
  TOP w0.114: v3(196.65,46.95) 198.51,45.09 UE1.125 ; RL18.1 54.24,119.57 v3(55,119.57) 55.96,119.57 v3(56.24,119.29) ; v3(198.41,60.14) 198.41,60.67 198.19,60.89 RPE2.5
  IN1 w0.14: v3(198.41,60.14) 197.63,59.36 197.63,52.43 197.26,52.06 197.26,47.56 v3(196.65,46.95)
  IN2 w0.14: v3(56.24,119.29) 55.37,119.29 55.23,119.15 55.23,116.66 49.07,110.5 49.07,106.66 39.34,96.94 39.34,85.61 37.05,83.32 37.05,82.18 33.6,78.73 33.6,78.24 33.55,78.19 33.55,78.19 32.03,76.67 32.03,74.95 30.13,73.05 30.13,71.72 29.83,71.41 29.83,67.1 30.61,66.31 30.61,63.9 31.27,63.24 31.27,61.08 32.12,60.23 32.12,38.38 36.32,34.19 36.32,27.43 49.21,14.54 122.69,14.54 124.86,16.71 124.86,29.87 129.15,34.16 129.15,41.56 129.48,41.89 146.02,41.89 146.92,40.98 v3(146.92,40.55)
  IN3 w0.114: v3(149.54,20.12) 150.23,20.82 169.4,20.82 171.56,22.98 175.16,22.98 184.56,32.37 190.14,32.37 192.89,35.13 192.89,37.73 195.74,40.58 195.74,41.11 196.5,41.87 196.5,46.8 v3(196.65,46.95)
  BOTTOM w0.114: v3(146.92,40.55) 146.92,38.6 147.61,37.91 147.61,22.73 149.54,20.8 v3(149.54,20.12)
LAN_WAKE#_R: length 5.9
  TOP w0.114: RL18.2 RL17.2 52.41,120.59 52.41,120.69 v4(51.95,121.15) 51.9,121.2 51.16,121.2 50.7,121.66 49.84,121.66 49.51,121.32 UL1.2
LAN_XTALI: length 6.5
  TOP w0.114: UL1.10 46.31,121.65 46.03,121.93 45.4,121.93 v2(45.29,121.83) 45.19,121.83 44.91,122.11 44.81,122.11 44.58,122.34 CL8.1 44.58,123.2 45.27,123.89 45.27,124.9 YL1.3
LAN_XTALO: length 7
  TOP w0.114: UL1.9 46.71,121.15 46.62,121.24 46.62,121.83 v2(46.59,121.86) 46.26,122.19 45.68,122.19 45.45,122.42 CL7.1 45.65,122.93 45.65,125.62 YL1.1
LANGND: length 2.3
  TOP w0.254: v3(29.95,118.76) 29.95,116.68 v4(29.83,116.55)
  vias: v3(3.71,129.5) v3(3.82,131.66) v3(6.91,131.64) v3(7.09,129.98) v3(8.13,127.65) v3(9.28,109.36) v3(11.41,127.67) v3(12.81,117.34) v3(13.57,122.24) v3(13.62,111.8) v3(13.87,129.97) v3(15.37,131.64) v3(16.16,126.33) v3(16.85,124.25) v3(17.23,120.03) v3(17.23,116.75) v3(17.51,130.82) v3(17.71,108.93) v3(17.89,117.69) v3(17.89,116.75) v3(18.34,108.93) v3(18.85,120.13) v3(19.23,121.96) v3(19.26,128.69) v3(20.12,122.67) v3(20.12,121.91) v3(20.48,125.87) v3(20.49,125.18) v3(20.48,112.84) v3(20.48,112.21) v3(20.53,110.91) v3(20.53,110.28) v3(20.53,109.62) v3(20.53,108.98) v3(22.84,128.72) v3(29.85,108.27) v3(29.95,123.84) v3(29.95,113.68)
LANPHYPC: length 355.1
  TOP w0.114: v3(52.94,121.6) RL9.2 52.79,120.94 52.18,121.55 51.15,121.55 50.64,122.06 v4(50.25,122.06) 49.79,122.06 49.11,121.38 UL1.3
  IN2 w0.14: v3(152.13,57.37) 151.62,56.86 144.68,56.86 141.2,60.34 138.96,60.34 137.51,61.79 134.33,61.79 132.32,63.81 122.52,63.81 121.85,63.13 121.35,63.13 v3(120.68,63.81) ; v3(52.94,121.6) 52.6,121.26 52.6,114.79 48.53,110.72 48.53,106.88 38.8,97.16 38.8,85.83 36.52,83.54 36.52,82.4 33.06,78.95 33.06,78.48 31.5,76.91 31.5,75.17 29.75,73.42 28.23,73.42 27.36,72.56 27.36,69.94 28.23,69.08 28.23,67.4 28.94,66.69 29.37,66.69 30.05,66 30.05,63.59 30.71,62.93 30.71,55.79 31.59,54.92 31.59,38.16 35.78,33.97 35.78,26.9 49.56,13.12 119.45,13.12 122.12,10.45 138.08,10.45 140.79,13.16 145.72,13.16 150.7,18.14 152.57,18.14 v3(152.84,18.4)
  BOTTOM w0.076: 101.63,75.91 101.63,78.68 99.71,80.6 99.71,81.92 99.51,82.11 99.51,82.48 99.56,82.59 99.56,82.71 99.5,82.93 99.5,83.07 99.55,83.23 99.55,83.31 99.77,84.01 99.77,84.01 99.94,84.19 UC1.AW17
  BOTTOM w0.102: 104.58,69.56 104.58,69.57 102.5,71.66 102.5,75.05 101.63,75.91
  BOTTOM w0.114: 104.58,69.56 107.25,66.89 109.99,66.89 113.44,63.44 118.78,63.44 119.14,63.81 v3(120.68,63.81) ; v3(152.13,57.37) 154.76,54.74 154.76,47.49 154.4,47.13 154.4,46.16 154.76,45.81 154.76,40.05 153.47,38.76 153.47,19.04 v3(152.84,18.4)
LG_1PH: length 3.9
  TOP w0.254: v4(142.96,76.6) 142.96,77.18 v3(142.98,77.21)
  IN1 w0.762: 142.68,82.18 142.68,78.86
  vias: v3(142.35,77.21) v3(142.83,83.63) v3(142.86,83)
LG_A1: length 15.1
  IN3 w1.016: 129.47,104.18 130.41,105.12 144.18,105.12
  vias: v2(129.47,103.49) v3(129.04,102.96) v3(129.7,102.96) v3(144.25,107.51) v3(144.33,101.97) v3(145.01,107.51) v3(145.09,101.97)
LG_B1: length 14.7
  TOP w0.114: 46.59,60.11 v3(46.62,60.14) ; v4(40.8,60.92) v3(40.8,60.19)
  IN3 w1.016: 39.78,72.25 43.52,68.52 43.52,59.91
  vias: v3(38.87,72.79) v3(38.87,72.15) v3(40.77,59.48) v3(46.62,59.27)
LID_SW#: length 233
  TOP w0.114: v3(234.65,141.16) 234.22,141.59 v4(234.22,141.95) 234.22,145.99 234.52,146.29 D11.1 ; JU3LF.11 244.9,172.55 245.08,172.72 248.32,172.72 249.56,171.48 249.56,163.67 248.7,162.81 248.7,161.85 248.34,161.5 248.34,158.17 244.75,154.58 244.75,141.98 240.98,138.21 237.3,138.21 v3(236.89,138.62) ; RPE3.5 176.75,63.43 178.01,62.17 184.49,62.17 v3(184.79,61.86)
  TOP w0.203: UE1.109 192.11,41.3 v3(192.03,41.21)
  IN1 w0.14: v3(219.13,39.03) 217.91,40.25 217.91,45.96 v3(218.22,46.27) ; v3(192.03,41.21) 191.42,41.82 189.16,41.82 186.16,44.82 186.16,60.49 v3(184.79,61.86)
  BOTTOM w0.114: v3(192.03,41.21) 192.7,41.88 195.53,41.88 197.16,40.25 212.68,40.25 213.65,39.28 218.88,39.28 v3(219.13,39.03) ; v3(234.65,141.16) 236.89,138.93 v3(236.89,138.62) 236.89,138.24 236.45,137.81 231.34,137.81 225.67,132.15 225.67,114.84 218.34,107.5 218.34,96.87 216.78,95.32 216.78,94.7 217.93,93.56 217.93,46.56 v3(218.22,46.27)
LOGO_LED#: length 266.6
  TOP w0.114: v3(88.7,131) 88.7,131.66 93.33,136.29 94.21,136.29 95.97,138.04 96.14,138.04 JLCD.10 ; v3(221.88,10.65) JAUF.11 ; v3(196.32,55.44) 198.76,55.44 200.53,53.67 UE1.24
  IN2 w0.14: v3(88.7,131) 90.56,131 91.37,130.19 101.19,130.19 102.92,128.46 117.07,128.46 118.42,127.11 137.23,127.11 139.39,124.95 139.39,122.81 139.85,122.35 141.73,122.35 v3(142.45,123.08) ; v3(150.98,80.15) 150.98,75.55 152.84,73.7 152.84,73.09 156.52,69.41 156.52,64.88 161.14,60.26 165.51,60.26 166.05,59.73 174.55,59.73 175.42,60.59 182.55,60.59 183.61,59.54 184.59,59.54 185.6,58.52 187.39,58.52 190.48,55.44 v3(196.32,55.44)
  IN3 w0.114: v1(212.2,53.63) 211.49,52.92 211.49,51.17 217.76,44.9 217.76,28.77 223.71,22.82 223.71,12.48 v3(221.88,10.65)
  BOTTOM w0.114: v3(142.45,123.08) 144.76,123.08 146.77,121.07 146.77,119.15 147.92,118 148.65,118 156.17,110.47 156.17,97.64 154.74,96.2 152.46,96.2 149.95,93.7 149.95,88.38 149.64,88.06 149.64,85.42 150.02,85.04 150.02,81.12 v3(150.98,80.15) ; D1.2 91.61,130.52 91.09,130.52 90.61,131 v3(88.7,131) ; v3(196.32,55.44) 198.48,55.44 202.83,51.09 205.11,51.09 205.82,51.81 207.03,51.81 207.94,52.72 211.28,52.72 v1(212.2,53.63)
LPC_AD0: length 149
  TOP w0.114: UE1.10 202.25,48.07 202.95,47.36 204.88,47.36 205.42,47.89 206.94,47.89 v4(207.37,48.33) 207.68,48.33 207.96,48.05 209.35,48.05 v3(209.71,48.4)
  IN2 w0.14: v3(209.71,48.4) 211.25,46.86 211.25,45.04 207.79,41.58 202.9,41.58 201.44,43.04 191.98,43.04 189.69,45.33 189.69,47.51 187,50.2 181.31,50.2 180.75,49.65 176.17,49.65 174.26,51.56 169.03,51.56 168.79,51.32 165.64,51.32 160.77,56.2 159.8,56.2 152.95,63.04 149.29,63.04 143.74,68.59 132.39,68.59 132.14,68.85 130.36,68.85 129.57,69.64 124.72,69.64 124.18,70.17 121.83,70.17 121.55,69.89 119.17,69.89 117.9,68.62 v3(117.25,68.62)
  BOTTOM w0.076: UC1.AY13 102.37,83.48 102.26,83.37 102.16,83.26 102.09,83.05 102.09,82.93 102.15,82.7 102.15,82.56 102.1,82.44 102.1,82.17 102.29,81.97 102.29,81.03 104.62,78.7
  BOTTOM w0.102: 104.86,75.18 104.86,78.47 104.62,78.7
  BOTTOM w0.114: v3(117.25,68.62) 116.76,68.12 116.07,68.12 115.25,68.95 111.77,68.95 111.18,69.55 109.54,69.55 104.86,74.24 104.86,75.18
LPC_AD1: length 145
  TOP w0.114: UE1.9 202.26,47.67 202.83,47.11 205.09,47.11 205.57,47.59 208.92,47.59 v4(208.97,47.64) 209.01,47.68 v3(209.72,47.68)
  IN2 w0.14: v3(117.2,69.99) 117.38,69.81 118.72,69.81 119.06,70.16 121.44,70.16 121.72,70.44 124.29,70.44 124.83,69.9 129.68,69.9 130.47,69.12 132.25,69.12 132.5,68.86 143.85,68.86 149.38,63.34 153.04,63.34 159.91,56.47 160.88,56.47 165.72,51.63 168.59,51.63 168.79,51.83 174.48,51.83 175.75,50.56 182.12,50.56 183.04,51.47 186.19,51.47 189.97,47.69 189.97,45.43 192,43.4 201.46,43.4 203.01,41.85 207.68,41.85 210.95,45.12 210.95,46.45 v3(209.72,47.68)
  BOTTOM w0.076: 104.27,79.56 102.63,81.19 102.63,82.52 102.37,82.78 UC1.BA13
  BOTTOM w0.102: 104.27,79.56 105.33,78.5 105.33,76.01
  BOTTOM w0.114: 105.33,76.01 105.33,74.45 108.31,71.46 111.26,71.46 112.86,69.86 117.07,69.86 v3(117.2,69.99)
LPC_AD2: length 149
  TOP w0.114: v3(210.5,48.45) 210.5,47.74 209.99,47.24 205.98,47.24 v4(205.9,47.16) 205.59,46.85 202.67,46.85 202.26,47.27 UE1.8
  IN2 w0.14: v3(210.5,48.45) 210.5,48.1 211.54,47.06 211.54,44.62 208.24,41.31 202.72,41.31 201.28,42.76 191.85,42.76 189.39,45.23 189.39,47.44 186.89,49.94 182.86,49.94 182.04,49.11 180.85,49.11 180.63,49.34 176.1,49.34 174.14,51.3 169.3,51.3 169.04,51.04 165.55,51.04 160.66,55.93 159.69,55.93 153.09,62.52 142.86,62.52 137.49,67.89 130.94,67.89 129.46,69.37 124.61,69.37 124.07,69.9 121.94,69.9 121.66,69.62 119.28,69.62 117.75,68.09 117.07,68.09 116.59,68.57 v3(116.59,68.62)
  BOTTOM w0.076: 104.94,78.63 102.46,81.11 102.46,82.05 102.37,82.15 UC1.BB13
  BOTTOM w0.102: 105.1,75.59 105.1,78.48 104.94,78.63
  BOTTOM w0.114: 105.1,75.59 105.1,74.33 109.62,69.81 111.28,69.81 111.89,69.2 115.35,69.2 115.93,68.62 v3(116.59,68.62)
LPC_AD3: length 145.4
  TOP w0.114: UE1.7 202.28,46.87 202.55,46.6 205.44,46.6 205.7,46.34 209.2,46.34 v3(209.48,46.62) v4(210.47,46.62)
  IN2 w0.14: v3(116.82,70.52) 117.54,70.52 117.92,70.14 118.67,70.14 118.95,70.42 120,70.42 120.76,71.19 121.21,71.19 121.7,70.7 124.4,70.7 124.94,70.17 129.79,70.17 130.58,69.38 132.36,69.38 132.61,69.13 143.96,69.13 149.49,63.6 153.15,63.6 160.02,56.73 160.99,56.73 164.86,52.86 166.59,52.86 167.07,52.38 174.33,52.38 175.88,50.83 182.01,50.83 182.93,51.74 186.3,51.74 190.24,47.8 190.24,45.54 192.11,43.66 201.57,43.66 203.12,42.11 207.56,42.11 210.67,45.23 210.67,45.81 209.86,46.62 v3(209.48,46.62)
  BOTTOM w0.076: UC1.AY12 102.94,83.77 102.63,83.47 102.63,83.04 102.8,82.88 102.8,81.28 103.71,80.37
  BOTTOM w0.102: 105.55,76.44 105.55,78.52 103.71,80.37
  BOTTOM w0.114: v3(116.82,70.52) 116.4,70.11 112.97,70.11 111.39,71.69 108.44,71.69 105.55,74.58 105.55,76.44
LPC_FRAME#: length 158.2
  TOP w0.114: RPE3.8 177.87,64.92 178.42,64.37 179.34,64.37 v3(179.89,63.82) 184.2,63.82 185.38,65.01 188.23,65.01 v3(188.65,64.58) ; UE1.6 202.3,46.47 203.38,45.38 204.53,45.38 204.78,45.63 v4(204.78,45.81) 204.55,46.04 v3(203.89,46.04)
  IN1 w0.14: v3(180.7,51.35) 180.7,53.63 179.91,54.42 179.91,60.9 177.4,63.41 177.4,64 177.65,64.25 179.46,64.25 v3(179.89,63.82)
  IN2 w0.14: v3(203.89,46.04) 202.43,47.51 202.41,47.51 200.82,49.1 200.82,55.13 197.46,58.49 196.53,58.49 194.18,60.83 194.18,62.21 191.93,64.45 188.78,64.45 v3(188.65,64.58) ; v3(180.7,51.35) 175.75,51.35 174.45,52.65 167.18,52.65 166.71,53.13 164.97,53.13 161.1,57 160.13,57 153.26,63.87 149.6,63.87 144.07,69.39 132.72,69.39 132.47,69.65 130.69,69.65 129.9,70.44 125.05,70.44 124.51,70.97 121.81,70.97 121.33,71.45 120.65,71.45 120.53,71.34 116.77,71.34 116.13,70.7 v3(116.13,70.55)
  BOTTOM w0.076: UC1.BA12 102.96,83.28 102.96,81.37 103.79,80.54
  BOTTOM w0.102: 103.79,80.54 105.78,78.55 105.78,76.86
  BOTTOM w0.114: v3(116.13,70.55) 112.91,70.55 111.56,71.9 108.54,71.9 105.78,74.65 105.78,76.86
LX_1.35V: length 8.1
  TOP w0.254: v4(137.06,34.23) v3(137.06,34.84)
  IN3 w0.762: 137.12,34.05 137.12,26.58
  vias: v3(137.06,35.47) v3(137.29,25.8) v3(137.29,25.11)
LX_CHG: length 19.3
  TOP w0.114: v3(181.44,170.12) 180.88,169.56 v4(180.63,169.56)
  IN3 w0.762: 182,169.38 185.55,169.38 187.69,167.25 199.32,167.25
  vias: v3(180.8,170.4) v3(200.06,167.4) v3(200.77,167.4)
MAINPWON_EC: length 316.8
  TOP w0.114: v3(74.86,19.39) 74.86,17.41 75.37,16.9 75.37,12.84 71.68,9.15 PD2.2 ; UE1.79 186.84,51.27 188.96,53.38 v3(191.37,53.38)
  IN1 w0.14: v3(191.37,53.38) 191.37,57.09 196.3,62.02 196.3,63.11 198.05,64.86 198.05,67.88 201,70.83 201.66,70.83 202.44,71.61 202.44,72.61 204.38,74.56 204.38,95.08 203.8,95.66 203.8,102.94 204.79,103.94 204.79,119.08 206.03,120.31 206.03,126.91 207.96,128.84 v3(207.96,130.39) ; v1(159.59,13.27) 147.3,13.27 143.78,9.75 139.72,9.75 135.85,5.89 124.1,5.89 113.77,16.22 78.03,16.22 v3(74.86,19.39)
  IN3 w0.114: v3(191.37,53.38) 189.41,51.42 189.41,44.54 188.19,43.32 186.67,43.32 185.72,42.38 185.72,34.43 175.08,23.79 170.95,23.79 168.71,21.55 v3(161.58,21.55) ; v1(159.59,13.27) 151.8,13.27 148.97,10.45 148.97,2.59 149.4,2.16 163.04,2.16 163.71,2.83 171.95,2.83 172.98,3.87 v3(172.98,3.9)
  BOTTOM w0.114: v3(161.58,21.55) 161.58,15.25 v1(159.59,13.27) ; v3(207.96,130.39) 207.96,129 208.46,128.49 PR13.1
  BOTTOM w0.254: v3(172.98,3.9) PR217.2 173.82,5.12 173.41,5.53 PQ201.5
MCT1: length 2.4
  BOTTOM w0.762: 25.82,121.77 26.39,121.2 TL1.22 27.96,121.2
  vias: v4(26.08,125.98)
MCT2:
  vias: v4(25.23,120.44)
MCT3:
  vias: v4(25.46,112.99)
MCT4: length 1.8
  BOTTOM w0.762: 25.89,111.9 26.3,112.31 TL1.15
  vias: v4(25.75,108.04)
MDI_0+: length 10.9
  TOP w0.114: v5(43.21,120.64) 43.32,120.64 44.21,119.75 UL1.13
  BOTTOM w0.114: TL1.1 37.79,123.74 38.14,123.4 38.63,123.4 39.57,122.46 39.57,120.48 39.67,120.38 39.93,120.38 39.97,120.42 DL1.9 DL1.1 41.65,120.42 41.69,120.38 42.28,120.38 42.44,120.54 43.11,120.54 v5(43.21,120.64)
MDI_0-: length 10.8
  TOP w0.114: v5(43.11,119.93) 43.44,119.93 44.01,119.35 UL1.14
  BOTTOM w0.114: v5(43.11,119.93) 42.92,120.12 42.61,120.12 42.46,119.96 41.72,119.96 41.68,119.92 DL1.2 DL1.8 39.97,119.92 39.93,119.96 39.5,119.96 39.15,120.31 39.15,122.29 38.45,122.98 38.16,122.98 37.65,122.47 TL1.2
MDI_1+: length 8.7
  TOP w0.114: v5(43.01,118.3) 43.19,118.12 43.95,118.12 43.98,118.15 UL1.17
  BOTTOM w0.114: TL1.5 37.88,118.66 38.31,118.24 38.57,118.24 39.19,118.86 39.76,118.86 39.82,118.92 DL1.7 DL1.4 41.58,118.92 41.62,118.88 42.06,118.88 42.75,118.19 42.89,118.19 v5(43.01,118.3)
MDI_1-: length 8.7
  TOP w0.114: v5(42.98,117.67) 43.14,117.82 43.97,117.82 44.04,117.75 UL1.18
  BOTTOM w0.114: v5(42.98,117.67) 42.98,117.69 42.9,117.77 42.58,117.77 41.89,118.46 41.67,118.46 41.63,118.42 DL1.5 DL1.6 39.82,118.42 39.8,118.44 39.36,118.44 38.74,117.82 38.19,117.82 37.76,117.39 TL1.6
MDI_2+: length 9
  TOP w0.114: v5(42.99,117.02) 43.11,116.91 43.9,116.91 43.95,116.95 UL1.20
  BOTTOM w0.114: TL1.7 37.77,116.12 38.31,115.58 39.65,115.58 39.69,115.62 DL2.9 DL2.1 41.23,115.62 41.34,115.73 41.34,116.29 41.94,116.89 42.86,116.89 v5(42.99,117.02)
MDI_2-: length 9.1
  TOP w0.114: v5(43.01,116.35) 43.31,116.65 43.9,116.65 43.99,116.55 UL1.21
  BOTTOM w0.114: v5(43.01,116.35) 42.88,116.47 42.12,116.47 41.76,116.12 41.76,115.56 41.32,115.12 DL2.2 DL2.8 39.64,115.12 39.6,115.16 38.02,115.16 37.71,114.85 TL1.8
MDI_3+: length 12.4
  TOP w0.114: v5(43.01,115.7) 43.15,115.56 43.47,115.56 43.58,115.67 44.01,115.67 44.09,115.75 UL1.23
  BOTTOM w0.114: v5(43.01,115.7) 43.01,115.69 42.87,115.55 42.63,115.55 42.25,115.16 42.25,114.25 42.08,114.08 41.54,114.08 41.5,114.12 DL2.4 DL2.7 39.61,114.12 39.57,114.08 39.36,114.08 39.03,113.76 39.03,111.11 38.54,110.62 38.07,110.62 37.64,111.04 TL1.11
MDI_3-: length 12.3
  TOP w0.114: v5(43.01,115.05) 43.21,115.25 43.62,115.25 43.72,115.35 UL1.24
  BOTTOM w0.114: v5(43.01,115.05) 42.93,115.13 42.81,115.13 42.67,114.99 42.67,114.07 42.25,113.66 41.54,113.66 41.5,113.62 DL2.5 DL2.6 39.66,113.62 39.62,113.66 39.53,113.66 39.45,113.58 39.45,110.94 38.71,110.2 38.06,110.2 37.63,109.77 TL1.12
ME_FLASH: length 122.2
  TOP w0.114: RC21.1 98.41,70.52 98.41,70.07 97.85,69.51 v4(97.85,68.37) 97.85,67.17 106.56,58.46 121.79,58.46 124.52,61.19 v3(125.6,61.19) ; UE1.104 190.11,41.84 189.48,41.21 189.48,39.15 188.68,38.34 187.76,38.34 186.57,37.15 175.87,37.15 174.55,38.47 172.27,38.47 169.27,35.47 v3(168.97,35.47)
  IN2 w0.14: v3(168.97,35.47) 167.29,37.15 167.29,43.66 166.63,44.32 163.85,44.32 153.37,54.8 144.48,54.8 140.59,58.69 138.35,58.69 136.85,60.19 132.13,60.19 131.55,60.77 130.07,60.77 129.34,61.51 125.91,61.51 v3(125.6,61.19)
MIC_CLK_R: length 3.8
  TOP w0.114: UA1.40 212.27,22.59 v2(213.29,23.61) 213.29,24.04 RA31.2
MIC_HW_EN: length 1.4
  TOP w0.114: v3(103.92,91.15) 103.83,91.07 RC355.2
  BOTTOM w0.076: UC1.AH11 103.7,90.94 v3(103.92,91.15)
ML0N: length 3.3
  TOP w0.114: CVG15.2 33.53,88.89 33.08,88.89 v3(32.89,88.7) 32.73,88.53 31.35,88.53 31.21,88.67 UVG2.5
ML0P: length 3.3
  TOP w0.114: CVG16.2 33.54,88.66 33.18,88.66 32.82,88.3 31.32,88.3 31.19,88.17 UVG2.4
ML1N: length 4.1
  TOP w0.114: UVG2.8 31.28,90.17 31.4,90.06 31.76,90.06 32.14,90.43 32.14,90.89 v3(32.58,91.34) 32.93,91.68 33.53,91.68 CVG17.2
ML1P: length 4.1
  TOP w0.114: CVG18.2 33.54,91.45 33.03,91.45 32.37,90.79 32.37,90.34 v3(32.11,90.08) 31.86,89.83 31.37,89.83 31.22,89.67 UVG2.7
MPLL_PVDD: length 44
  TOP w0.305: v4(136,162.96) 135.85,162.8 135.85,158.69
  TOP w0.381: CV218.1 CV219.1 138.97,155.23 CV220.1
  IN2 w0.254: v1(134.63,157.96) 135.47,157.96 136.84,156.59 136.84,155.21 136.58,154.95 136.58,147 136.56,146.98 136.56,140.68 136.76,140.48 136.76,137.25
  IN2 w0.381: 136.76,137.25 136.55,137.04 136.55,135.97 135.39,134.81 132.92,134.81 132.34,134.23 v3(132.34,133.44)
  BOTTOM w0.381: v3(132.34,133.44) 131.91,133.44 131.1,132.63 129.06,132.63 128.56,132.12 127.59,132.12 LV3.2 ; UV1.H7 134.23,158.36 v1(134.63,157.96) 134.23,157.56 UV1.H8
MUX_CAD: length 2.9
  TOP w0.114: RX21.1 v2(28.5,58.21) 28.12,58.59 27.44,58.59 27.27,58.76 UX1.42
MUX_CFG0: length 2.9
  TOP w0.114: UX1.44 28.63,60.55 28.78,60.39 29.67,60.39 RX18.1 RX17.2
MUX_CFG1: length 3
  TOP w0.114: UX1.29 22.07,58.73 21.82,58.49 v4(21.82,58.18) 21.93,58.08 21.93,57.29 RX20.1 RX19.2
MUX_DDCBUF: length 4.2
  TOP w0.114: RX12.1 RX9.2 28.78,68.64 27.97,67.83 v2(27.97,67.72) 27.96,67.72 27.57,67.32 27.41,67.32 26.87,66.78 UX1.2
MUX_I2C_CTL_EN: length 4.3
  TOP w0.114: v4(23.12,57.01) 23.39,57.28 RX13.1 RX14.2 25.12,57.28 25.12,57.29 25.53,57.7 25.53,58.54 25.67,58.67 UX1.38
MUX_MODE: length 4.8
  TOP w0.114: v4(31.91,65.57) 31.65,65.83 RX11.2 30.79,65.65 30.79,65.57 30.41,65.19 30.31,65.19 RX10.1 30.05,64.71 29.38,64.04 28.94,64.04 28.84,64.15 UX1.53
MUX_PEQ: length 4.7
  TOP w0.114: RX4.1 24.75,70.24 24.75,69.1 RX3.2 24.28,67.81 v2(24.47,67.63) UX1.8
MUX_PRE: length 4.1
  TOP w0.229: UX1.20 20.31,63.35 v3(20.25,63.29)
  BOTTOM w0.254: RX5.1 20.12,63.41 v3(20.25,63.29) 20.5,63.54 20.5,64.02 20.81,64.33 v2(20.91,64.33) 21.06,64.17 RX6.2
MUX_RT: length 3.8
  TOP w0.229: UX1.23 20.51,62.15 20.45,62.09 v3(20.3,62.09)
  BOTTOM w0.254: RX8.2 21.06,61.46 20.86,61.25 v2(20.78,61.25) 20.76,61.25 20.3,61.71 v3(20.3,62.09) 20.25,62.14 RX7.1
MUX_SW: length 8.9
  TOP w0.114: UX1.45 28.69,60.95 28.96,60.67 31.65,60.67 32.06,60.26 32.06,58.97 31.43,58.33 RX15.1 RX16.2 v4(31.96,57.44)
MVREFDA: length 32.9
  IN2 w0.381: v1(137.09,148.66) 137.67,149.24 139.43,149.24 139.86,148.81 139.86,145.3 139.6,145.05 139.6,140.53 138.97,139.89 138.97,133.69 137.93,132.65 134.37,132.65 132.92,131.21 130.94,131.21 v3(130.23,131.92)
  BOTTOM w0.381: UV1.L18 136.6,149.15 v1(137.09,148.66) ; v3(130.23,131.92) 130.1,131.92 129.42,131.23 RV18.2 RV20.1 CV73.1
MVREFDB: length 33.1
  IN2 w0.381: v3(143.13,153.67) 142.33,153.67 141.56,152.9 141.56,151.1 141.62,151.03 141.62,138.38 141.6,138.36 141.6,135.31 140.19,133.9 140.19,132.91 139.3,132.02 v3(134.75,132.02)
  BOTTOM w0.114: v4(135.54,131.89) 135.41,132.02 v3(134.75,132.02)
  BOTTOM w0.381: v3(134.75,132.02) 134.75,131.64 134.83,131.56 RV21.1 CV74.1 RV19.2 ; UV1.Y12 143.6,154.14 v3(143.13,153.67)
MVREFSA: length 25.8
  IN2 w0.381: v3(132.16,131.87) 132.94,132.64 132.94,132.69 134.26,134.01 137.28,134.01 137.89,134.63 137.89,140.88 137.67,141.09 137.67,141.95 138.41,142.69 138.41,146.27 v1(137.04,147.64)
  BOTTOM w0.114: v4(133.31,131.87) v3(132.16,131.87)
  BOTTOM w0.381: CV75.1 RV24.1 RV22.2 132.06,131.76 v3(132.16,131.87) ; v1(137.04,147.64) 137.04,147.72 UV1.L20
MVREFSB: length 32.6
  IN2 w0.381: v3(138.18,129.82) 141.52,133.15 141.52,133.78 142.88,135.14 142.88,137.99 143.95,139.05 143.95,152.64 145.06,153.75 v1(145.06,154.68)
  BOTTOM w0.114: v4(137.45,131.82) 137.45,130.72 CV76.1
  BOTTOM w0.381: v1(145.06,154.68) 144.6,154.22 UV1.AA12
  BOTTOM w0.508: RV23.2 RV25.1 CV76.1 137.67,130.67 138.18,130.16 v3(138.18,129.82)
Net_13: length 0.6
  BOTTOM w0.076: 75.02,102.24 v3(74.56,101.83)
Net_18: length 0.6
  BOTTOM w0.076: 106.11,86.1 106,86.1 v3(105.65,85.75)
Net_258: length 5.6
  BOTTOM w0.114: v4(10.6,97.19) 7.84,94.43 6.1,94.43
NTC_V_1: length 150.1
  TOP w0.254: v3(96.65,96.69) 96.73,96.69
  TOP w0.381: 96.73,96.69 PRT7.1
  IN1 w0.203: v3(125.66,93.54) 125.76,93.54 125.89,93.4 134.36,93.4 134.91,92.85 141.4,92.85 143.43,90.82 v3(144.68,90.82)
  IN2 w0.203: v3(96.65,96.69) 96.98,96.36 101.96,96.36 102.7,97.09 108.59,97.09 108.9,97.4 115.02,97.4 115.58,97.96 115.58,98.39 115.93,98.74 116.65,98.74 117.15,98.25 120.49,98.25 120.86,98.62 122.14,98.62 122.89,97.87 122.89,96.51 125.66,93.74 v3(125.66,93.54)
  IN3 w0.254: v3(145.8,97.73) 146.06,97.47 149.38,97.47 149.89,97.98 149.89,100.27 152.15,102.53 159.02,102.53 164.21,107.72 170.96,107.72 172.01,108.77 183.45,108.77 185.35,110.67 202.84,110.67 v3(203.18,111.01)
  BOTTOM w0.203: v3(145.8,97.73) 144.79,96.71 144.79,90.92 v3(144.68,90.82)
  BOTTOM w0.508: v3(203.18,111.01) 207.07,114.9 v4(207.07,129.43) 207.07,130.47 207.78,131.18 209.35,131.18 PR12.1
ODD_DA#: length 161.5
  IN2 w0.14: v1(151.69,76.18) 151.82,76.3 151.82,77.45 152.43,78.06 152.43,79.59 149.21,82.82 149.21,95.11 150.12,96.03 150.12,98.89 149.43,99.58 146.06,99.58 143.7,97.22 133,97.22 130.74,99.48 126.77,99.48 125.57,100.67 124.29,100.67 123.75,101.21 123.75,102.45 123.53,102.68 122.76,102.68 121.8,101.72 121.43,101.72 120.42,100.71 117.53,100.71 117.48,100.76 116.87,100.76 116.31,100.2 114.99,100.2 113.67,101.51 110.8,101.51 v3(110.29,101)
  IN3 w0.114: v5(222.71,60.34) 221.33,60.34 217.47,64.2 201.73,64.2 199.02,66.92 191.09,66.92 189.62,65.44 170.49,65.44 167.16,68.77 157.97,68.77 157.74,68.55 149.76,68.55 149.36,68.95 149.36,69.71 149.82,70.17 150.63,70.17 151.11,70.65 151.11,75.59 v1(151.69,76.18)
  BOTTOM w0.076: UC1.H2 108.86,100.79 109.1,100.55 109.58,100.55 110.04,101 v3(110.29,101)
  BOTTOM w0.114: RC409.2 223.77,60.38 R150.1 222.74,60.36 v5(222.71,60.34)
ODD_DA#_R: length 5.9
  BOTTOM w0.114: R150.2 224.67,59.37 v4(224.85,59.2) 226.55,57.49 JODD.11
ODD_DETEC#: length 184.3
  TOP w0.114: JODD.8 226.24,56.05 226.24,60.36 v4(224.77,61.84) 222.66,63.95 v3(218.52,63.95)
  IN1 w0.14: v3(216.11,109.39) 215.74,109.02 215.74,107.02 215.02,106.3 215.02,69.81 218.52,66.31 v3(218.52,63.95)
  IN2 w0.14: v3(113.24,100.45) 113.24,99.9 114.5,98.64 115.02,98.64 115.58,99.21 116.85,99.21 117.24,98.81 120.15,98.81 120.92,99.58 125.11,99.58 126.28,98.41 130.3,98.41 132.61,96.1 143.59,96.1 144.66,95.04 147.55,95.04 v1(148.77,96.26)
  IN3 w0.114: v3(216.11,109.39) 214.94,108.22 172.24,108.22 169.38,105.36 164.04,105.36 159.81,101.13 154.4,101.13 149.7,96.43 148.95,96.43 v1(148.77,96.26)
  BOTTOM w0.076: RC386.1 115.12,99.61 RC86.2 114.11,99.61 113.37,100.32 v3(113.24,100.45) 113.24,100.9 112.71,101.43 110.04,101.43 109.75,101.13 108.39,101.13 108.06,100.8 UC1.H3
ODD_EN: length 167.5
  TOP w0.114: v4(219.84,45.46) v3(218.37,45.46)
  IN2 w0.14: v3(165.87,55.18) 165.87,55.49 164.27,57.09 163.14,57.09 155.86,64.36 155.86,69.05 154.9,70.02 152.14,70.02 149.57,72.58 149.57,76.79 148.22,78.14 148.22,90.16 148.9,90.84 148.9,95.26 149.82,96.18 149.82,98.82 149.38,99.25 146.11,99.25 143.81,96.95 132.89,96.95 130.63,99.21 126.66,99.21 125.48,100.39 124.14,100.39 123.08,101.45 121.54,101.45 120.53,100.44 117.49,100.44 117.39,100.54 116.96,100.54 116.4,99.98 114.9,99.98 113.58,101.3 111.22,101.3 v3(110.93,101)
  IN3 w0.114: v3(218.37,45.46) 218.09,45.73 217.33,45.73 211.77,51.3 211.77,52.52 v3(212.2,52.95)
  BOTTOM w0.076: UC1.J3 108.53,100.13 108.77,100.37 109.06,100.37 109.06,100.37 109.18,100.37 109.62,100.37 109.87,100.62 110.55,100.62 v3(110.93,101)
  BOTTOM w0.114: v3(165.87,55.18) 165.87,54.35 167.09,53.13 188.54,53.13 191.06,55.65 195.4,55.65 196.55,54.5 199.04,54.5 202.72,50.81 208.18,50.81 209.73,52.36 211.61,52.36 v3(212.2,52.95) ; v3(218.37,45.46) 218.7,45.12 R153.1 220.45,46.45 U150.3
ON/OFF#: length 189.7
  TOP w0.114: v3(236.05,138.27) 236.35,137.97 241.08,137.97 245.04,141.92 245.04,154.53 248.6,158.08 248.6,161.41 248.94,161.75 248.94,162.71 249.84,163.61 249.84,171.54 248.42,172.96 245.14,172.96 245.06,173.05 JU3LF.12
  TOP w0.203: UE1.110 192.51,43.9 v3(192.14,44.27)
  IN3 w0.114: v3(217.35,61.63) 215.28,63.7 208.61,63.7 203.08,58.17 203.08,55.73 203.01,55.65 203.01,54.42 203.27,54.15 203.27,53.19 201.5,51.42 201.5,49.98 200.33,48.8 200.33,42.59 v3(201,41.92)
  BOTTOM w0.114: v3(236.05,138.27) 231.45,138.27 226.93,133.75 220.55,133.75 219.45,132.64 SW1.4 SW1.3 219.45,124.06 220.83,122.67 R71.2 ; R71.2 220.83,110.38 217.91,107.46 217.91,96.79 216.54,95.42 216.54,92.27 217.35,91.45 v3(217.35,61.63) ; R71.2 222.59,122.29 J1.2 ; v3(192.14,44.27) 193.3,43.12 199.8,43.12 v3(201,41.92)
ONEDOCK_DET#: length 290.9
  TOP w0.114: v3(164.29,89.73) 163.15,88.58 151.42,88.58 151.06,88.94 v3(151.06,89.32) ; RC372.1 129.5,87.54 129.83,87.87 129.83,90.08 130.1,90.36 131.86,90.36 132.24,90.74 136.3,90.74 136.68,90.36 137.39,90.36 137.67,90.08 137.67,86.22 138.11,85.79 141.89,85.79 v3(142.91,86.81) ; JU3LF.10 246.82,172.05 249.31,169.56 249.31,165.47 248.46,164.62 248.46,161.95 248.09,161.58 248.09,158.26 244.5,154.67 244.5,142.07 240.95,138.51 238.26,138.51 v3(238.13,138.65)
  IN1 w0.14: v3(107.53,100.9) 107.79,100.9 108.75,101.86 108.75,102.46 109.96,103.67 113.32,103.67 118.13,108.49 119.37,108.49 121.9,111.02 121.9,112.68 121.67,112.91 121.67,114.98 122.06,115.37 131.05,115.37 132.03,116.35 134.64,116.35 137.81,113.18 150.19,113.18 151.39,111.98 151.39,106.35 156.33,101.41 156.33,97.55 152.1,93.32 152.1,90.97 151.06,89.93 v3(151.06,89.32)
  IN3 w0.114: v3(151.06,89.32) 150.45,89.32 148.44,87.31 143.41,87.31 v3(142.91,86.81) ; v3(217.3,95.09) 217.3,94.96 216.03,93.69 203.1,93.69 193.83,102.96 177.55,102.96 176.64,102.05 173.84,102.05 164.29,92.5 v3(164.29,89.73)
  BOTTOM w0.076: v3(107.53,100.9) 107.53,101.25 UC1.G4
  BOTTOM w0.114: v3(238.13,138.65) 236.78,137.3 231.17,137.3 226.68,132.81 R235.2 R233.2 R234.2 226.68,128.67 225.99,127.98 225.99,114.77 218.78,107.56 218.78,96.43 217.43,95.09 v3(217.3,95.09)
OPC_RCOMP: length 24.5
  TOP w0.114: v4(52.79,99.68) 52.79,100.22 v3(52.51,100.5)
  TOP w0.254: v3(52.51,100.5) 53.02,101 RC56.2
  IN3 w0.254: v3(72.53,100.54) 72,100.01 70.79,100.01 69.29,101.51 66.73,101.51 64.85,99.63 55.45,99.63 54.33,100.75 52.76,100.75 v3(52.51,100.5)
  BOTTOM w0.203: UC1.H65 v3(72.53,100.54)
OPCE_RCOMP: length 21.8
  TOP w0.114: v4(55.58,101.92) 55.02,101.92 v3(54.97,101.87)
  TOP w0.254: RC200.2 54.84,102 v3(54.97,101.87)
  IN3 w0.254: v3(71.51,100.54) 71.25,100.54 69.66,102.14 66.82,102.14 64.69,100.01 55.6,100.01 54.83,100.79 54.83,101.72 v3(54.97,101.87)
  BOTTOM w0.203: UC1.H66 v3(71.51,100.54)
OTP_N_002: length 2.5
  BOTTOM w0.114: PR12.2 209.3,130.21 v4(209.3,129.2)
  BOTTOM w0.203: PU1.7 209.39,130.28 PR12.2
OTP_N_003: length 2.8
  BOTTOM w0.114: v4(216.41,129.17) 215.45,129.17 PR13.2
  BOTTOM w0.203: PU1.3 215,129.63 PR13.2
P2: length 53.5
  TOP w0.114: PR104.2 v4(227.44,159.42)
  TOP w0.254: v3(223.4,160.57) 224.17,159.8 PQ103.3 225.95,159.8 PR104.2
  IN1 w0.254: v3(177.88,164.71) 178.03,164.56 179.46,164.56 180.86,163.16 208.85,163.16 212.46,159.55 222.38,159.55 v3(223.4,160.57)
  BOTTOM w0.254: PR112.1 178.16,164.99 v3(177.88,164.71)
P3:
  vias: v4(219.44,162.98)
PBTN_OUT#: length 109
  TOP w0.114: RC399.2 118.04,63.29 119.39,64.63 TP129.1 119.82,65.24 v3(120.07,65.49) ; UE1.86 184.53,48.47 184.21,48.15 v5(184.21,48.15)
  IN2 w0.14: v3(120.07,65.49) 120.48,65.91 122.73,65.91 124.03,64.61 129.47,64.61 130.79,65.93 131.48,65.93 134.81,62.59 140.15,62.59 142.51,60.23 152.87,60.23 159.72,53.38 161.27,53.38 166.5,48.15 175.24,48.15 176.18,47.21 183.5,47.21 184.21,47.92 v5(184.21,48.15)
  BOTTOM w0.076: 103.92,77.79 103.92,78.27 100.87,81.32 100.87,82.72 UC1.BA15
  BOTTOM w0.114: 103.92,77.79 103.92,73.69 109.02,68.58 110.69,68.58 113.2,66.07 118.14,66.07 118.71,65.49 v3(120.07,65.49)
PC_BEEP: length 8.4
  TOP w0.114: UA1.10 207.37,23.68 207.04,24.02 207.04,24.73 205.37,26.41 205.37,27.83 204.1,29.1 v4(203.97,29.1) CA24.2
PCH_BEEP: length 137.8
  TOP w0.114: CA23.1 201.4,27.29 200.21,28.49 198.05,28.49 197.66,28.88 196.66,28.88 196.43,29.11 DA1.3 195.45,29.14 192.35,29.14 189.95,31.54 170.92,31.54 v3(169.96,32.5) ; RC300.1 120.63,75.81 RC95.1 120.63,76.27 119.41,77.48 v4(119.21,77.48) 119.16,77.54 v3(119.16,78.09)
  IN1 w0.076: v3(107.56,85.05) 107.77,85.26 110.34,85.26 111.7,83.9 111.7,81.4 112.09,81.01
  IN1 w0.14: 112.09,81.01 115.41,81.01 118,78.42 118.22,78.42 118.55,78.09 v3(119.16,78.09) 119.75,78.69 122.86,78.69 126.07,75.48 127.08,75.48 129.34,73.22 129.34,71.59 130.38,70.56 134.39,70.56 135.1,69.85 146.65,69.85 147.43,69.08 149.05,69.08 149.89,69.92 151.24,69.92 155.43,65.72 155.43,64.15 162.11,57.47 162.11,40.35 v3(169.96,32.5)
  BOTTOM w0.076: v3(107.56,85.05) 107.25,84.74 UC1.AW5
PCH_CMOS_ON: length 203.3
  IN1 w0.076: 112.21,81.29 111.93,81.57 111.93,83.89 110.41,85.41 107.83,85.41 107.09,86.15 107.09,87.23 v3(106.57,87.76)
  IN1 w0.14: v3(161.09,75.48) 161.69,76.07 161.69,85.73 160.86,86.55 160.86,89.7 159.6,90.97 159.6,92.93 160.89,94.22 160.89,95.23 163.62,97.96 163.62,111.63 152.86,122.39 134.97,122.39 134.47,122.89 129.05,122.89 128.16,123.78 126.97,123.78 125.97,122.77 116.49,122.77 114.18,120.46 108.31,120.46 105.56,123.21 105.56,124.06 105.26,124.36 105.26,125.34 100.51,130.09 97.01,130.09 91.6,135.5 v3(91.6,138.34) ; 112.21,81.29 115.53,81.29 117.86,78.96 123.07,78.96 125.18,76.85 126.85,76.85 127.44,76.27 127.44,75.5 129.65,73.29 129.65,71.74 130.57,70.82 134.61,70.82 135.31,70.12 147.35,70.12 v3(147.83,69.64)
  IN3 w0.114: v3(147.83,69.64) 150.48,72.28 150.48,76.14 151.26,76.93 159.65,76.93 v3(161.09,75.48)
  BOTTOM w0.076: v3(106.57,87.76) 106.57,88.07 107.02,88.53 UC1.AM5
  BOTTOM w0.114: U4.3 93.72,140.57 93.22,140.07 92.77,140.07 92.11,139.41 R2.1 91.6,138.9 v3(91.6,138.34)
PCH_EDP_PWM: length 139.4
  TOP w0.114: JLCD.12 96.41,136.64 96.55,136.64 96.91,136.29 96.91,133.92 v2(97.01,133.82) 97.17,133.66 v3(97.17,133.3)
  IN1 w0.076: v3(104.04,96.53) 104.41,96.89 104.66,96.89 105.91,98.15 107.89,98.15 107.99,98.24
  IN1 w0.14: 107.99,98.24 110.08,100.33 111.2,100.33 111.82,100.95 113.39,100.95 114.15,100.19 116.11,100.19 117.06,99.25 120,99.25 120.45,99.7 123.58,99.7 123.75,99.86 125.2,99.86 127.86,97.21 144.48,97.21 145.75,98.48 146.99,98.48 148.16,97.31 149.83,97.31 152.38,99.86 152.38,102.3 152.99,102.91 v3(152.99,103.7)
  IN2 w0.14: v3(140.14,123.13) 140.14,124.96 137.45,127.64 118.64,127.64 117.27,129.01 103.12,129.01 101.26,130.88 99.22,130.88 97.17,132.92 v3(97.17,133.3)
  BOTTOM w0.076: v3(104.04,96.53) 103.85,96.78 UC1.R11
  BOTTOM w0.114: v3(140.14,123.13) 140.72,122.54 144.89,122.54 146.46,120.97 146.46,119.12 147.86,117.72 148.58,117.72 152.99,113.31 v3(152.99,103.7)
PCH_ENVDD: length 66.2
  TOP w0.114: v3(99.55,126.13) 99.55,123 97.67,121.12 97.67,120.39 v3(97.64,120.36)
  IN3 w0.076: v3(102.77,95.46) 102.73,95.46 101.23,96.97 97.8,96.97 97.53,97.23 97.53,97.82 97.77,98.06 97.77,98.44 97.54,98.67 96.81,98.67 96.17,99.3 96.17,99.68 95.08,100.78 90.71,100.78 90.53,100.96 90.53,101.95 90.13,102.35 90.13,102.94 90.72,103.53 90.72,105.69
  IN3 w0.114: 90.72,105.69 92.55,107.52 92.55,108.14 93.55,109.15 93.55,114.57 95.37,116.38 95.37,117.2 97.84,119.67 97.84,120.16 v3(97.64,120.36)
  BOTTOM w0.076: v3(102.77,95.46) 102.57,95.71 UC1.U13
  BOTTOM w0.114: v3(99.55,126.13) 93.48,126.13 89.13,130.47 88.5,130.47 88.25,130.72 88.25,131.54 88.95,132.24 R18.1 88.95,133.86 89.72,134.63 89.72,135.22 89.21,135.73 U3.4
PCH_HDA_BCLK: length 150.1
  TOP w0.114: v3(123.18,61.44) 123.07,61.56 122.35,61.56 120.37,59.58 109.36,59.58 105.9,63.04 v4(105.9,63.44) 105.9,64.69 105.14,65.45 RPC2.2 ; UA1.5 209.37,23.91 210.47,25.01 210.47,28.35 209.1,29.72 205.39,29.72 203.07,32.04 191.16,32.04 190.45,32.76 172.93,32.76 172.62,33.06 169.81,33.06 v3(169.25,32.5)
  IN1 w0.14: v3(169.25,32.5) 166.2,32.5 160,38.7 155.68,38.7 153.41,40.97 153.41,41.17 154.79,42.54 154.79,42.72 154.51,43 154.33,43 152.95,41.62 152.76,41.62 152.5,41.88 152.5,42.08 153.86,43.45 153.86,43.64 153.6,43.9 153.4,43.9 152.04,42.54 151.84,42.54 151.58,42.8 151.58,43 152.94,44.36 152.94,44.56 152.68,44.82 152.49,44.82 151.12,43.46 150.92,43.46 150.66,43.72 150.66,43.92 152,45.25 152,45.45 151.74,45.71 151.54,45.71 150.21,44.37 150.01,44.37 149.18,45.2 139.6,45.2 136.84,47.97 131.32,47.97 126.03,53.27 126.03,56.6 123.93,58.7 123.93,60.7 v3(123.18,61.44)
