# Allegro board Lenovo ThinkPad E460 E560 BE560 NM-A561 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_CRX_GTX_P0: length 62.9
  TOP w0.114: CV1.2 137.04,130.06 137.04,127.9 135.77,126.63 135.77,124.25 v3(135.61,124.09)
  IN3 w0.114: v3(135.61,124.09) 135.77,123.94 135.77,123.47 130.91,118.61 108.13,118.61 106.81,117.29 102.19,117.29 99.09,114.19 98.8,114.19 96.6,111.99 96.6,106.27 95.99,105.66 95.99,105.2 95.99,105.2 95.99,102.35 v3(96.51,101.83)
  BOTTOM w0.076: UC1.E23 96.1,102.24 v3(96.51,101.83)
PCIE_CRX_GTX_P1: length 62
  TOP w0.114: v3(133.54,123.89) 133.33,123.89 133.2,124.02 133.2,126.02 135.26,128.08 135.26,130.16 135.52,130.42 CV3.2
  IN3 w0.114: v3(133.54,123.89) 133.2,123.56 133.2,123.25 129.68,119.72 116.7,119.72 116.14,119.17 107.99,119.17 106.62,117.79 101.87,117.79 98.77,114.7 98.58,114.7 95.92,112.03 95.92,106.44 95.41,105.93 95.41,103.47 94.92,102.98 94.92,102.48 95.13,102.27 95.4,102.27 v3(95.59,102.47)
  BOTTOM w0.076: v3(95.59,102.47) 95.37,102.24 UC1.E25
PCIE_CRX_GTX_P2: length 61.4
  TOP w0.114: v3(131.58,123.92) 131.3,124.2 131.3,126.3 133.43,128.44 133.43,130.09 CV5.2
  IN3 w0.114: v3(93.77,102.47) 93.45,102.78 93.45,103.87 93.94,104.35 93.94,105.86 95,106.92 95,113.15 97.31,115.46 98.54,115.46 101.59,118.51 106.29,118.51 107.68,119.9 111.98,119.9 113.1,121.02 117.6,121.02 118.16,120.46 128.59,120.46 131.25,123.12 131.25,123.58 v3(131.58,123.92)
  BOTTOM w0.076: v3(93.77,102.47) 93.99,102.24 UC1.E27
PCIE_CRX_GTX_P3: length 65.5
  TOP w0.114: v3(128.99,123.66) 129.17,123.66 129.34,123.48 129.34,123.3 129.25,123.2 128.68,123.2 128.38,123.5 128.38,126.31 131.2,129.13 131.2,130.09 131.53,130.42 CV7.2
  IN3 w0.114: v3(92.85,101.2) 92.66,101.39 92.41,101.39 92.12,101.68 92.12,102.82 92.44,103.14 92.44,105.56 94.09,107.21 94.09,113.54 96.95,116.4 98.19,116.4 101.64,119.85 105.26,119.85 105.47,120.05 106.3,120.05 107.11,120.87 111.58,120.87 112.8,122.09 114.69,122.09 114.99,122.39 118.33,122.39 119.32,121.4 128.2,121.4 129.42,122.62 129.42,123.41 129.17,123.66 v3(128.99,123.66)
  BOTTOM w0.076: UC1.F30 v3(92.85,101.2)
PCIE_CTX_C_GRX_N0: length 61.4
  IN3 w0.114: v3(96.5,119.74) 96.79,120.03 96.79,120.61 97.99,121.81 104.76,121.81 105.09,121.48 105.59,121.48 107.52,123.41 110.72,123.41 111.44,124.12 118.73,124.12 119.47,123.38 124.23,123.38 126.57,125.72 141.37,125.72 143.61,127.95 144.42,127.95 144.66,128.19 144.66,128.56 v3(144.45,128.77)
  BOTTOM w0.084: 144.6,132.02 144.6,132.03 144.62,132.04 144.62,133.46 144.35,133.72 144.35,134.1 144,134.46 UV1.Y37
  BOTTOM w0.114: CC86.1 96.78,118.94 96.78,119.46 v3(96.5,119.74) ; v3(144.45,128.77) 144.6,128.92 v3(144.6,129.61) 144.6,132.02
PCIE_CTX_C_GRX_N1: length 61.5
  IN3 w0.114: v1(99.13,119.67) 98.95,119.67 98.76,119.86 98.76,119.99 99.11,120.34 105.02,120.34 105.24,120.56 105.96,120.56 106.85,121.45 111.26,121.45 112.93,123.13 118.44,123.13 119.1,122.47 125.91,122.47 128.12,124.68 141.67,124.68 143.78,126.79 144.5,126.79 v3(144.8,126.49)
  BOTTOM w0.084: UV1.W36 143.41,134.95 143.44,134.8 143.47,134.68 143.48,134.64 143.56,134.44 143.56,134.29 143.54,134.24 143.46,134.12 143.42,134.07 143.42,132.59 143.24,132.41 143.24,132.07 143.21,132.04 143.21,132.02
  BOTTOM w0.114: CC88.1 99.17,118.48 98.79,118.86 98.79,119.5 98.96,119.67 v1(99.13,119.67) ; 143.21,132.02 v3(143.21,129.92) 143.21,127.83 144.25,126.79 144.5,126.79 v3(144.8,126.49)
PCIE_CTX_C_GRX_N2: length 61.5
  IN3 w0.114: v3(141.43,127.42) 141.56,127.42 141.81,127.67 141.81,128.03 141.61,128.23 141.31,128.23 139.35,126.28 124.9,126.28 122.84,124.22 120.7,124.22 120.29,124.63 108.22,124.63 107.81,124.22 106.29,124.22 104.38,122.32 97.8,122.32 96.26,120.78 95.68,120.78 95.39,120.5 95.39,120.29 v1(95.71,119.97)
  BOTTOM w0.084: UV1.V37 142.84,134.32 142.84,133.14 141.88,132.18 141.87,132.19 141.86,132.19 141.85,132.18
  BOTTOM w0.114: v3(141.43,127.42) 141.71,127.7 v3(141.71,129.53) 141.71,132.04 141.85,132.18 ; v1(95.71,119.97) 95.43,119.69 95.43,119.22 95.15,118.94 95.15,118.76 CC90.1
PCIE_CTX_C_GRX_N3: length 64
  IN3 w0.114: v1(93.3,119.8) 93.59,120.1 93.59,120.4 94.89,121.69 95.72,121.69 97.25,123.23 103.45,123.23 105.92,125.69 122.55,125.69 124.64,127.78 139.42,127.78 140.49,128.85 140.49,129.27 140.34,129.43 v3(140.16,129.43)
  BOTTOM w0.084: 141.33,133.1 141.35,133.11 141.37,133.11 141.61,133.35 141.61,133.87 141.87,134.13 141.95,134.25 141.97,134.3 141.97,134.34 141.96,134.44 141.88,134.64 141.87,134.66 141.87,135.08 141.8,135.16 UV1.U36
  BOTTOM w0.114: v3(140.16,129.43) 140.37,129.43 140.54,129.61 v3(140.54,130.32) 140.54,131.07 140.85,131.38 140.85,132.61 141.33,133.1 ; CC24.1 94.67,115.74 94.67,116 94.56,116.12 94.12,116.12 93.81,116.43 93.81,117.8 93.58,118.03 93.58,119.52 v1(93.3,119.8)
PCIE_CTX_C_GRX_P0: length 61.4
  IN3 w0.114: v3(145.24,128.77) 145.04,128.77 144.86,128.59 144.86,128.11 144.51,127.75 143.69,127.75 141.46,125.52 126.66,125.52 124.32,123.17 119.38,123.17 118.64,123.92 111.52,123.92 110.81,123.2 107.61,123.2 105.68,121.27 105.01,121.27 104.68,121.6 98.07,121.6 97,120.53 97,119.92 97.17,119.74 v3(97.29,119.74)
  BOTTOM w0.084: UV1.AA38 144.64,134.36 144.55,134.27 144.55,133.8 144.82,133.54 144.82,132.04 144.83,132.03 144.83,132.02
  BOTTOM w0.114: 144.83,132.02 v3(144.83,130.87) 144.83,129.03 145.09,128.77 v3(145.24,128.77) ; CC87.1 97.01,118.68 97.01,119.46 v3(97.29,119.74)
PCIE_CTX_C_GRX_P1: length 61.5
  IN3 w0.114: v3(144.8,127.28) 144.5,126.99 143.69,126.99 141.59,124.88 128.04,124.88 125.83,122.67 119.18,122.67 118.52,123.33 112.85,123.33 111.17,121.66 106.76,121.66 105.87,120.77 105.15,120.77 104.93,120.54 99.03,120.54 98.56,120.08 98.56,119.89 v1(98.34,119.67)
  BOTTOM w0.084: UV1.Y35 143.63,135.19 143.63,134.84 143.66,134.65 143.74,134.51 143.76,134.44 143.76,134.27 143.74,134.23 143.69,134.15 143.6,134.02 143.58,134 143.58,132.52 143.4,132.34 143.4,132.07 143.43,132.04 143.43,132.02
  BOTTOM w0.114: v1(98.34,119.67) 98.56,119.45 98.56,118.81 CC89.1 ; v3(144.8,127.28) 144.53,127.01 144.35,127.01 143.43,127.93 v3(143.43,131.28) 143.43,132.02
PCIE_CTX_C_GRX_P2: length 61.5
  IN3 w0.114: v3(142.22,127.42) 142.02,127.62 142.02,128.11 141.7,128.44 141.22,128.44 139.27,126.48 124.81,126.48 122.76,124.42 120.78,124.42 120.38,124.83 108.13,124.83 107.73,124.42 106.2,124.42 104.3,122.52 97.71,122.52 96.18,120.98 95.59,120.98 95.19,120.58 95.19,120.24 v1(94.92,119.97)
  BOTTOM w0.084: 142.01,132.02 142.01,132.04 143.03,133.06 143.03,134.19 UV1.W38
  BOTTOM w0.114: 142.01,132.02 141.94,131.94 v3(141.94,128.16) 141.94,127.7 v3(142.22,127.42) ; v1(94.92,119.97) 95.2,119.69 95.2,119.31 94.93,119.04 94.93,118.86 CC23.1
PCIE_CTX_C_GRX_P3: length 64
  IN3 w0.114: v1(94.09,119.8) 93.8,120.1 93.8,120.32 94.97,121.49 95.8,121.49 97.34,123.03 103.54,123.03 106,125.49 122.64,125.49 124.72,127.57 139.5,127.57 140.7,128.77 140.7,129.17 v3(140.95,129.43)
  BOTTOM w0.084: UV1.V35 142.05,135.21 142.05,134.71 142.06,134.65 142.14,134.51 142.16,134.38 142.16,134.28 142.15,134.24 142.1,134.16 141.97,133.97 141.81,133.79 141.81,133.27 141.51,132.97 141.51,132.95 141.5,132.93
  BOTTOM w0.114: 141.5,132.93 141.08,132.52 v3(141.08,131.56) 141.08,131.28 140.77,130.98 140.77,129.61 v3(140.95,129.43) ; CC91.1 94.9,115.89 94.9,116.1 94.65,116.35 94.21,116.35 94.04,116.52 94.04,117.9 93.81,118.12 93.81,119.52 v1(94.09,119.8)
PCIE_RCOMP: length 17
  TOP w0.114: v4(118.57,109.41) 117.48,109.41 RC385.2 117.33,109.06 117.13,108.85 117.13,108.65 v3(117.35,108.42)
  IN1 w0.14: v3(117.35,108.42) 117.35,108.24 116.74,107.63 114.66,107.63 113.39,106.36 110.49,106.36 107.8,103.68 107.8,103.44 107.42,103.06 107.42,102.33 107.07,101.97 106.71,101.97 v3(106.57,101.83)
  BOTTOM w0.114: UC1.F5 v3(106.57,101.83)
PCIE_WAKE#: length 28.5
  TOP w0.114: RPC18.6 v4(111.67,65.39) 111.67,65.92 112.58,66.83 113.03,66.83 113.69,67.49 v3(114.53,67.49)
  BOTTOM w0.076: 104.25,77.66 104.25,78.16 101.12,81.29 101.12,82.31 UC1.BB15
  BOTTOM w0.114: 104.25,77.66 104.25,73.73 109.15,68.82 110.88,68.82 112.3,67.4 114.45,67.4 v3(114.53,67.49)
PECI: length 5.6
  TOP w0.114: UE1.117 195.31,41.61 v2(195.92,41.01) 196.37,41.01 196.83,40.55 197.31,40.55 197.92,39.94 RE1.2 CE1.1
PG_VDD: length 4.5
  TOP w0.254: v3(210.83,149.95) 210.17,149.95 v4(209.16,148.95) 208.97,148.76 PR605.2 PR604.1
PLANARID0: length 17.8
  IN2 w0.14: v1(119.08,96.05) 119.08,96.2 118.24,97.04 115.75,97.04 115.37,96.66 113.75,96.66 112.43,95.34 111.39,95.34 110.22,94.17 v3(110.22,93.38)
  BOTTOM w0.076: UC1.AB1 110.09,93.5 110.2,93.38 v3(110.22,93.38)
  BOTTOM w0.114: RC74.1 121.47,92.42 121.47,93.83 121.28,94.02 121.28,94.64 RC70.2 120.33,95.59 120.33,95.79 120.07,96.05 v1(119.08,96.05)
PLANARID1: length 19.9
  TOP w0.114: v1(107.31,95.23) 108.07,94.46 112.83,94.46 113.09,94.21 113.59,94.21 114.48,93.32 117.47,93.32 v2(117.6,93.45) 117.66,93.38 118.55,93.38 118.95,92.98 119.41,92.98 119.63,93.19 119.63,94.02 119.88,94.27 119.88,96.05 119.17,96.76 RC435.1 118.31,97.07 RC434.2
  BOTTOM w0.076: UC1.U7 107,95.23 v1(107.31,95.23)
PLT_RST_VGA#: length 196.2
  TOP w0.114: v3(148.75,89.91) 151.31,89.91 151.59,89.63 v4(151.59,89.04) 151.77,88.86 161.83,88.86 v3(162.16,89.19)
  IN1 w0.14: v3(161.85,133.52) 162.11,133.52 162.62,133.01 162.62,131.61 163.89,130.34 163.89,125.52 165.16,124.25 165.16,121.58 161.37,117.79 161.37,116.63 161.6,116.4 161.6,114.03 163.89,111.75 163.89,95.32 162.16,93.59 v3(162.16,89.19) ; v3(128.38,95.34) 128.87,95.84 143.32,95.84 144.62,94.53 144.62,93.28 145,92.9 146.84,92.9 147.12,93.18 148.82,93.18 149.18,92.83 149.18,90.34 v3(148.75,89.91)
  IN3 w0.084: v1(145.73,139.1) 146.22,139.6 147.19,139.6 147.73,139.05 148.44,139.05 149.21,139.82 149.59,139.82 150.13,139.28 151.81,139.28 152.2,139.66 155.4,139.66 155.6,139.46 157.81,139.46 159.34,137.94 159.34,135.59
  IN3 w0.114: 159.34,135.59 161.41,133.52 v3(161.85,133.52) 161.98,133.64 164.14,133.64 165.69,132.09 171.08,132.09 171.76,132.78 178.01,132.78 178.43,133.2 201.53,133.2 202.7,134.36 207,134.36 213.85,141.21 216.03,141.21 217.92,143.1 217.92,144.74 217.25,145.41 217.25,146.34 217.75,146.85 218.49,146.85 219.89,148.25 v3(219.89,150.05)
  BOTTOM w0.084: v1(145.73,139.1) 145.27,139.56 UV1.AA30
  BOTTOM w0.114: UV15.4 124.88,93.69 126.27,92.29 126.88,92.29 127.69,93.11 RV207.2 127.74,93.49 RV167.1 128.68,94.4 RV9.2 128.66,94.6 128.38,94.88 v3(128.38,95.34) ; PR606.1 v3(219.89,150.05) ; v3(161.85,133.52) 161.79,133.52 161.41,133.14 161.41,132.69 161.92,132.18 162.11,132.18 162.43,131.87 162.43,129.32 DV4.1
PLTRST#: length 390.7
  TOP w0.114: v3(54.74,106.42) v4(52.63,106.42) RC26.1 50.53,108.52 UC3.2
  IN1 w0.076: 111.9,78.21 107.55,82.56 105.8,82.56 104.75,83.62 104.06,83.62 103.43,84.24 103.43,87.27 v3(103.82,87.66) 103.33,88.15 103.33,88.41 103.05,88.69 102.57,88.69 102.36,88.89 102.36,89.17 102.13,89.4 101.63,89.4 101.45,89.23 101.45,84.84 101.77,84.52 102,84.52 103.99,82.54 104.48,82.54 105.26,81.75 106.41,81.75 110.06,78.1 110.06,74.56 110.6,74.03 112.65,74.03 113.59,73.09 113.59,72.43 114.23,71.79
  IN1 w0.14: v3(159.99,68.3) 158.41,68.3 154.83,71.88 154.83,74.88 150.37,79.34 150.37,81.55 149.62,82.31 149.62,87.57 150.09,88.05 150.09,93.44 149.48,94.05 147.24,94.05 146.2,95.1 145.11,95.1 144.1,96.1 128.45,96.1 v3(127.74,95.39) ; v3(152.1,62.07) 149.78,64.39 141.07,64.39 136.99,68.47 134.04,68.47 133.29,69.22 129.31,69.22 127.15,71.39 123.5,71.39 122.33,72.56 122.02,72.56 120.86,73.71 120.86,74.59 120.26,75.19 119.38,75.19 118.83,74.64 116.41,74.64 112.85,78.21 111.9,78.21 ; v3(54.74,106.42) 47.35,99.02 47.35,98.23 39.62,90.5 39.62,85.01 32.42,77.81 32.42,72.92 34.99,70.34 34.99,61.62 35.95,60.67 35.95,58.05 33.72,55.83 33.72,53.75 47.71,39.77 49.76,39.77 51.67,37.86 51.67,26.91 52.25,26.33 52.25,24.42 52.58,24.09 53.83,24.09 55.33,25.6 63.42,25.6 66.47,22.55 79.31,22.55 82.94,26.18 104.34,26.18 104.97,26.81 113.87,26.81 116.11,29.05 116.11,38.62 119.08,41.59 122.09,41.59 125.9,45.41 125.9,47.7 124.97,48.63 124.97,55.41 118.42,61.96 118.42,63.79 118.9,64.28 118.9,65.22 118.24,65.88 118.24,68.29 116.83,69.71 116.83,69.71 116.55,69.98 116.04,69.98 114.23,71.79
  IN3 w0.114: v3(152.1,62.07) 152.1,63.92 156.49,68.3 v3(159.99,68.3)
  BOTTOM w0.076: UC1.AN10 104.22,88.05 v3(103.82,87.66)
  BOTTOM w0.114: UV15.1 126.7,94.99 127.23,94.45 RV207.1 127.69,95.34 v3(127.74,95.39)
PLTRST_FAR#: length 616.6
  TOP w0.114: v3(193.63,53.51) 194.27,52.87 UE1.22 203.19,52.87 203.23,52.82 CE13.2 ; CC9.1 45.5,108.6 45.5,109.51 v3(45.78,109.79) ; CC9.1 RC48.2 ; CC9.1 45.9,108.09 v4(45.9,107) ; v3(248.24,167.15) 247.45,167.94 v3(247.45,170.37)
  IN1 w0.14: v3(240.7,163.93) 240.7,162.24 238.47,160.01 238.47,150.36 228.3,140.19 228.3,138.63 224.1,134.43 224.1,123.25 216.88,116.03 216.88,113.31 v3(216.54,112.97) 216.88,112.63 216.88,107.35 215.56,106.02 215.56,70.03 219.41,66.17 219.41,60.19 216.78,57.56 216.78,47.73 v3(214.94,45.89) ; v3(153.7,119.47) 153.14,120.03 142.6,120.03 142.02,120.61 134.58,120.61 133.71,121.48 121.98,121.48 121.68,121.77 v3(121.68,122.03)
  IN2 w0.14: v3(216.54,112.97) 215.86,113.65 181.74,113.65 v3(180.75,114.64) ; v3(240.7,163.93) 243.11,163.93 244.91,165.72 246.81,165.72 v3(248.24,167.15) ; v3(45.78,109.79) 45.78,106.14 37.22,97.58 37.22,94.63 33.58,91 33.58,87.78 31.87,86.07 31.87,78.98 30.37,77.47 30.37,75.62 29.41,74.67 27.74,74.67 26.04,72.96 26.04,67.76 28.05,65.75 28.05,56.33 30.21,54.16 30.21,37.96 33.57,34.61 33.57,31.91 34.38,31.1 34.38,26.67 49.11,11.94 119.04,11.94 124.57,6.4 136.48,6.4 140.21,10.14 144.63,10.14 150.78,16.28 156.38,16.28 v3(156.83,16.73)
  IN3 w0.114: v3(156.27,62.47) 158.02,62.47 159.8,64.25 159.97,64.25 161.41,65.7 165.87,65.7 169.86,61.71 177.78,61.71 178.19,61.3 183.65,61.3 186.49,58.46 190.2,58.46 194.04,54.62 194.04,53.91 v3(193.63,53.51)
  BOTTOM w0.114: v3(121.68,122.03) 121.68,120.35 118.98,117.64 118.57,117.64 118.42,117.8 UTPM1.17 ; v3(214.94,45.89) 215.45,46.39 215.45,48.4 213.32,50.54 202.65,50.54 200.36,52.82 194.32,52.82 v3(193.63,53.51) ; JWLBT.66 v3(248.24,167.15) ; v3(247.45,170.37) 247.73,170.65 JWLBT.52 ; v3(156.83,16.73) 156.83,17.62 156.47,17.97 156.47,38.01 156.9,38.44 156.9,45.38 157.22,45.7 157.22,46.97 156.9,47.28 156.9,59.7 156.27,60.34 v3(156.27,62.47) ; v3(153.7,119.47) 154.21,118.96 176.43,118.96 v3(180.75,114.64)
PLTRST_NEAR#: length 171.4
  TOP w0.114: v3(52.25,34.15) 52.05,34.15 51.49,33.6 UW1.1 ; UL1.36 49.91,114.14 50.07,113.98 v3(50.55,113.98) 51.77,112.77 51.77,111.11 50.88,110.23 49.66,110.23 48.95,109.51 47.3,109.51 RC348.2 CC102.1 46.26,109.34 46.26,110.07 46.06,110.28 44.02,110.28 43.87,110.12 43.87,106.75 44.68,105.93 v3(44.68,105.91)
  IN1 w0.14: v3(85.17,131.94) 85.17,131.82 83.57,130.21 82.76,130.21 81.52,128.97 76.18,128.97 75.58,128.37 74.16,128.37 73.72,128.82 73.08,128.82 72.28,128.01 70.97,128.01 70.6,127.64 67.7,127.64 67.08,127.02 63.16,127.02 60.38,124.25 57.61,124.25 55.96,122.59 55.96,120.74 52.37,117.15 52.37,116.66 50.55,114.85 v3(50.55,113.98)
  IN3 w0.114: v3(44.68,105.91) 44.68,104.93 33.85,94.1 33.85,89.79 29.42,85.36 28.61,85.36 27.87,84.62 27.87,80.12 25.91,78.15 25.91,70.04 28.99,66.96 29.75,66.96 30.61,66.1 30.61,55.01 30.11,54.51 30.11,39.68 34.52,35.26 51.15,35.26 v3(52.25,34.15)
  BOTTOM w0.114: v2(88.04,129.81) USROM1.3 85.55,129.81 85.17,130.19 v3(85.17,131.94)
PM_SLP_A#: length 104.3
  TOP w0.114: UE1.76 184.82,52.47 184.28,51.93 179.38,51.93 179.2,51.75 178.95,51.75 v3(178.39,52.31) 178.36,52.34 TP128.1
  IN2 w0.076: v3(100.17,87.66) 100.69,87.13 100.69,84.87 100.99,84.57 101.63,84.57 102.74,83.46 106.57,83.46
  IN2 w0.14: 106.57,83.46 113.85,76.19 114.81,76.19 115.16,75.84 115.16,75.38 118.82,71.72 121.44,71.72 121.92,71.24 124.62,71.24 125.16,70.7 130.01,70.7 130.8,69.92 132.58,69.92 132.83,69.66 144.18,69.66 149.71,64.14 153.37,64.14 160.24,57.27 161.21,57.27 164.77,53.71 v3(165.08,53.71)
  IN3 w0.114: v3(178.39,52.31) 177.37,53.33 165.46,53.33 v3(165.08,53.71)
  BOTTOM w0.076: UC1.AN16 v3(100.17,87.66)
PM_SLP_S0#: length 28.9
  TOP w0.114: TC20.1 122.18,69.18 v3(122.26,69.18)
  IN1 w0.076: 112.43,76.88 107.05,82.26 105.48,82.26 104.72,83.02 104.17,83.02 102.91,84.28 v3(102.91,85.75)
  IN1 w0.14: 112.43,76.88 116.32,72.99 117.74,72.99 119.5,71.23 119.5,70.41 120.13,69.77 121.34,69.77 121.93,69.18 v3(122.26,69.18)
  BOTTOM w0.076: v3(102.91,85.75) 103.26,86.1 UC1.AT11
PM_SLP_S3#: length 130.1
  TOP w0.114: v3(198,51.98) 198.72,51.27 UE1.18 202.36,51.27 202.72,51.63 205.16,51.63 207.23,53.7 208.12,53.7 D65.1 208.65,54.24 D59.1 ; TP125.1 v3(164.98,55.13)
  IN2 w0.076: v3(101.08,87.02) 101.45,86.65 101.45,85 102.79,83.67 106.99,83.67
  IN2 w0.14: 106.99,83.67 114.18,76.47 114.94,76.47 115.43,75.98 115.43,75.49 118.93,71.99 121.48,71.99 121.98,72.48 122.37,72.48 123.35,71.5 124.74,71.5 125.27,70.97 130.12,70.97 130.91,70.18 132.69,70.18 132.94,69.93 144.34,69.93 149.87,64.4 153.48,64.4 160.35,57.53 161.32,57.53 163.72,55.13 v3(164.98,55.13)
  BOTTOM w0.076: UC1.AP15 v3(101.08,87.02)
  BOTTOM w0.114: v3(164.98,55.13) 164.55,54.7 164.55,53.28 166.16,51.67 177.04,51.67 177.23,51.86 197.87,51.86 v3(198,51.98)
PM_SLP_S4#: length 147
  TOP w0.114: UE1.21 197.85,52.47 195.43,50.05 190.53,50.05 v3(190.06,50.52) ; v3(186.24,35.47) 186.08,35.32 D64.1 ; v3(170.01,50.74) 170.14,50.74 170.41,51.02 TP126.1
  IN1 w0.14: v3(170.01,50.74) v3(170.01,53.94)
  IN2 w0.14: v3(190.06,50.52) 187.53,53.05 182.99,53.05 182.33,53.71 177.5,53.71 176.74,54.47 174.17,54.47 173.82,54.12 172.5,54.12 172.37,54.24 170.31,54.24 v3(170.01,53.94) ; v3(170.01,50.74) 165.47,50.74 160.55,55.67 159.56,55.67 153.66,61.57 143.06,61.57 137.32,67.31 130.63,67.31 129.1,68.84 124.72,68.84 124.3,68.42 119.85,68.42 117.96,66.53 117.96,65.65 v3(117.68,65.37)
  IN3 w0.114: v3(186.24,35.47) 187.51,36.74 187.51,42.3 189.79,44.58 189.79,50.26 v3(190.06,50.52)
  BOTTOM w0.076: 103.41,77.74 103.41,78.35 100.54,81.22 100.54,83.28 UC1.BA16
  BOTTOM w0.102: 103.41,77.74 103.41,75.12
  BOTTOM w0.114: v3(117.68,65.37) 117.46,65.58 113,65.58 110.49,68.1 108.77,68.1 103.41,73.46 103.41,75.12
PM_SLP_S5#: length 110.3
  TOP w0.114: TP127.1 178.75,50.56 v3(178.75,50.1) 180.22,50.1 181.77,51.65 184.41,51.65 184.82,52.07 UE1.77
  IN2 w0.14: v3(160.08,55.16) 159.69,55.16 153.55,61.3 142.95,61.3 137.21,67.04 130.39,67.04 129.96,66.61 129.29,66.61 128.3,67.6 125.72,67.6 125.53,67.79 123.4,67.79 122.99,67.39 122.09,67.39 121.33,68.15 120.01,68.15 118.29,66.44 v3(118.29,64.94)
  IN3 w0.114: v3(178.75,50.1) 175.88,52.97 162.26,52.97 v3(160.08,55.16)
  BOTTOM w0.076: UC1.AY16 100.51,83.77 100.21,83.47 100.21,83.04 100.38,82.88 100.38,81.17 103.21,78.34 103.21,77.92
  BOTTOM w0.102: 103.21,77.92 103.21,73.32 108.67,67.86
  BOTTOM w0.114: 108.67,67.86 110.39,67.86 112.9,65.34 117.03,65.34 117.46,64.91 118.27,64.91 v3(118.29,64.94)
PM_SMB_CLK: length 335.3
  TOP w0.114: JCP.2 34.54,95.7 34,95.7 33.79,95.49 29.7,95.49 27.82,97.37 27.82,104.69 v3(28.01,104.88) ; v3(122,26.94) 122,26.48 112.5,16.98 112.5,10.78 v3(111.89,10.17)
  IN3 w0.114: v1(77.97,133.01) 77.78,133.2 76.45,133.2 75.88,132.63 75.88,131.99 75.27,131.38 73.12,131.38 71.6,129.86 68.74,129.86 66.99,128.11 54.31,128.11 53.45,127.24 49.27,127.24 48.39,128.13 43.2,128.13 40.04,124.97 40.04,114.6 38.99,113.55 38.99,112.26 32.43,105.7 28.84,105.7 v3(28.01,104.88) 22.17,104.88 19.11,101.82 19.11,98.2 21.03,96.28 21.03,95.47 18.18,92.62 18.18,89.79 16.97,88.58 16.97,78.07 17.33,77.7 17.33,71.96 14.09,68.72 14.09,56.11 19.97,50.23 19.97,42.43 15.26,37.72 15.26,27.92 21.82,21.35 24.57,21.35 35.15,10.77 110.63,10.77 111.22,10.17 v3(111.89,10.17)
  BOTTOM w0.114: USROM1.6 79.38,129.81 RC106.1 78.8,130.39 78.8,131.05 78.2,131.65 QC1.1 77.18,131.74 77.18,131.9 77.97,132.69 v1(77.97,133.01) ; JDIMM1.202 122.62,27.78 122,27.16 v3(122,26.94) 122,26.81 122.24,26.57 123.55,26.57 124.25,27.27 124.25,30.69 126,32.44 126,33.37 125.25,34.12 125.25,43.17 124.77,43.65 122.76,43.65 122.62,43.51 JDIMM2.202
PM_SMB_DAT: length 335.4
  TOP w0.114: v3(121.34,26.84) 120.86,26.84 119.07,25.05 119.07,24.06 112.21,17.2 112.21,11.48 v3(111.37,10.64) ; v3(28.81,104.89) 28.28,104.36 28.28,102.12 28.78,101.61 28.78,100.57 28.58,100.37 28.58,98.21 v4(28.86,97.93) 29.14,97.65 33.53,97.65 33.57,97.7 34.54,97.7 JCP.6
  IN3 w0.114: v3(111.37,10.64) 111.18,10.64 110.76,11.06 35.27,11.06 24.69,21.64 21.95,21.64 15.55,28.04 15.55,37.53 20.26,42.24 20.26,50.35 14.38,56.23 14.38,68.6 17.62,71.84 17.62,88.69 18.54,89.61 18.54,92.41 21.33,95.2 21.33,96.39 19.4,98.32 19.4,101.7 22.09,104.38 28.3,104.38 v3(28.81,104.89) 29.24,105.32 32.53,105.32 39.28,112.08 39.28,113.42 40.33,114.48 40.33,124.85 43.32,127.83 48.27,127.83 49.15,126.95 53.57,126.95 54.43,127.81 67.11,127.81 68.86,129.57 71.75,129.57 73.27,131.09 75.38,131.09 76.38,132.09 76.38,132.44 v1(76.7,132.75)
  BOTTOM w0.114: JDIMM2.200 122.02,43.64 122.48,44.11 124.81,44.11 125.55,43.37 125.55,34.24 126.29,33.49 126.29,32.32 124.54,30.57 124.54,27.15 123.62,26.23 121.95,26.23 v3(121.34,26.84) 121.34,27.18 122.02,27.85 JDIMM1.200 ; v1(76.7,132.75) 76.38,132.44 76.38,130.85 75.89,130.35 QC1.4 76.03,129.99 76.41,129.99 76.54,129.86 RC107.1 77.22,128.54 USROM1.5
PME#: length 1.3
  TOP w0.076: TC120.1 103.74,85.75 v3(103.83,85.75)
  BOTTOM w0.076: v3(103.83,85.75) 103.52,85.45 UC1.AU11
PORTB_L: length 2.3
  TOP w0.203: RA19.1 213.39,19.32 213.32,19.39 UA1.32
PORTB_R: length 2.4
  TOP w0.203: RA24.1 213.06,20.21 v2(212.95,20.09) 212.64,19.79 UA1.33
PP: length 3.8
  BOTTOM w0.114: TP940.1 114.99,125.34 116.42,123.91 UTPM1.4
PROC_POPIRCOMP: length 21.9
  TOP w0.305: RC151.2 110.29,71.85 110.29,73.34 v3(109.63,74)
  IN3 w0.203: 101.57,82.37 100.25,83.69 100.25,84.21 99.72,84.74 99.72,85.31 v5(100.17,85.75)
  IN3 w0.254: 101.57,82.37 102.23,82.37 104.17,80.43 106.66,80.43 109.05,78.04 109.05,74.59 v3(109.63,74)
  BOTTOM w0.254: UC1.AT16 v5(100.17,85.75)
PS_0: length 13.7
  TOP w0.114: v4(160.99,128.13) 161.27,128.41 RV112.2
  TOP w0.305: v1(154.64,135.78) 158.3,135.78 160.84,133.24 160.84,131.41 CV213.1 RV113.1 RV112.2
  BOTTOM w0.305: UV1.AM34 154.38,135.78 v1(154.64,135.78)
PS_1: length 15.8
  TOP w0.254: v1(148.14,137.58) 148.32,137.58 150.88,135.02 150.88,133.39 151.87,132.4 v3(153.52,132.4)
  BOTTOM w0.254: v1(148.14,137.58) 148.14,138.22 UV1.AD31 ; v3(153.52,132.4) 153.52,131.38 154.36,130.55 v2(155.23,130.55) CV212.1 RV109.1 RV106.2
PS_2: length 1.6
  TOP w0.381: RV111.1 150.81,141.75 RV108.2
  BOTTOM w0.254: v1(149.51,138.37) 149.9,138.76 UV1.AG31
  vias: v2(151.09,139.33)
PS_3: length 24.8
  TOP w0.114: v3(158.6,133.85) 159.49,132.96 CV211.1 RV107.1 159.7,129.63 159.7,128.51 RV114.2 160.46,127.24 v4(160.46,126.46)
  IN3 w0.084: v1(147.05,137.58) 147.43,137.96 151.01,137.96 151.42,138.37 152.01,138.37 152.74,139.1 155.17,139.1 155.36,138.91 155.94,138.91 157.23,137.61 157.23,135.22 v3(158.6,133.85)
  BOTTOM w0.084: UV1.AD33 147.47,137.16 v1(147.05,137.58)
PSYS: length 165.9
  TOP w0.254: PR413.2 67.27,122.85 v3(66.43,122.85) 66.43,124.4 v4(68.23,126.2) 73.13,126.2 75.49,128.56 75.49,129.07 75.18,129.39 72.89,129.39 72.57,129.71 72.57,130.66 73.15,131.23 73.65,131.23 v1(74.22,131.8) ; v3(99.07,148.12) 99.04,148.15 96.9,148.15 83.1,134.34 v1(80.07,134.34)
  IN1 w0.14: v3(116.21,181.32) 117.46,181.32 123.32,187.19 154.29,187.19 154.62,186.86 154.62,186.3 155.05,185.87 162.16,185.87 166.12,181.9 166.12,179.62 169.02,176.73 169.02,172.33 v3(170.03,171.31)
  IN1 w0.254: v1(74.22,131.8) 74.22,131.87 74.73,132.37 75.11,132.37 75.3,132.18 76.96,132.18 77.49,132.72 77.49,133.21 77.77,133.49 79.03,133.49 79.88,134.34 v1(80.07,134.34)
  IN2 w0.254: v3(116.21,181.32) 115.63,180.74 111.36,180.74 100.08,169.46 100.08,150.56 98.79,149.26 98.79,148.4 v3(99.07,148.12)
  BOTTOM w0.203: v3(66.43,122.85) 66.57,122.71 PU401.46
  BOTTOM w0.254: PR124.1 171.23,170.65 PC127.2 170.52,171.31 v3(170.03,171.31)
PWM1_2PH: length 84.9
  TOP w0.254: v3(38.23,104.92) 38.94,104.92 44.19,99.68 44.19,97.61 41.45,94.87 41.45,92.18 40.82,91.56 40.82,78.72 39.59,77.48 37.93,77.48 37.62,77.18 v3(37.62,76.85)
  IN3 w0.254: v3(75.49,123.33) 75.49,123.08 75.11,122.7 73.77,122.7 73.11,123.36 66.17,123.36 63.05,120.23 56.17,120.23 54.44,118.51 51.54,118.51 46.64,113.6 46.28,113.6 45.42,112.74 44.53,112.74 41.94,110.15 41.94,108.78 38.23,105.07 v3(38.23,104.92)
  BOTTOM w0.203: PU401.16 74.22,122.31 74.63,122.72 v2(75.09,122.72) 75.49,123.13 v3(75.49,123.33)
  BOTTOM w0.254: PU403.2 37.72,76.63 37.62,76.72 v3(37.62,76.85)
PWM_1A: length 81.8
  TOP w0.254: v3(122.41,114.19) 122.41,120.87 122.84,121.3 122.84,122.75 120.94,124.65 v3(120.94,124.91)
  IN2 w0.254: v3(74.9,119.81) 77.22,122.14 77.22,125.87 78.66,127.31 84.88,127.31 85.53,126.66 87.91,126.66 88.65,125.92 98.43,125.92 99.11,125.24 103.03,125.24 104.1,126.3 116.23,126.3 117.5,125.03 120.81,125.03 v3(120.94,124.91)
  BOTTOM w0.203: v3(74.9,119.81) 74.8,119.91 PU401.22
  BOTTOM w0.254: v3(122.41,114.19) 122.41,113.76 122,113.35 v2(122,108.75) 122.02,108.74 122.02,108.73 124.03,106.71 124.03,103.13 124.67,102.5 124.67,101.89 125,101.56 125.56,101.56 125.63,101.63 PU402.2
PWM_1B: length 116.3
  TOP w0.254: v3(142.11,88.69) 142.11,89.18 142.63,89.7 142.63,91.7 141.08,93.24 141.08,95.3 139.62,96.76 131.72,96.76 129.81,98.67 127.4,98.67 124.44,101.63 124.44,106.4 124.03,106.8 124.03,107.09 122.33,108.79 122.33,110.71 120.12,112.92 v4(120.12,113.78) 120.12,117.26 119.94,117.44 119.94,118.35 120.28,118.68 120.28,120.64 118.22,122.7 115.07,122.7 114.46,122.09 113.91,122.09 113.53,122.47 v1(113.53,122.59)
  IN1 w0.254: v1(113.53,122.59) 113.42,122.59 112.5,121.68 109.38,121.68 109.32,121.62 108.83,121.62 106.84,123.61 v3(106.74,123.61)
  IN2 w0.254: v3(98.86,126.94) 95.74,126.94 95.48,126.68 88.98,126.68 88.6,127.06 88.6,127.32 87.85,128.07 78.32,128.07 76.19,125.94 74.17,125.94 71.88,123.65 69.25,123.65 67.71,122.11 67.71,118.14 v3(67.82,118.02)
  BOTTOM w0.254: v3(106.74,123.61) 106.69,123.61 102.42,127.88 99.37,127.88 98.86,127.37 v3(98.86,126.94) ; v3(142.11,88.69) 142.11,87.48 141.15,86.52 PU404.2
PWROK: length 15.9
  TOP w0.114: RC403.2 RC41.2 103.05,70.27 102.37,70.96 v4(102.37,72.23) 102.37,73.9 v3(102.04,74.23)
  BOTTOM w0.076: 100.32,78.54 100.32,78.93 99.16,80.09 99.16,80.87 98.59,81.44 98.59,82.04 98.45,82.18 98.45,82.72 UC1.BA20
  BOTTOM w0.102: v3(102.04,74.23) 101.91,74.23 100.32,75.82 100.32,78.54
Q27_G: length 2.1
  BOTTOM w0.114: Q27.2 118.27,125.52 117.35,126.43 R9491.1
REMOTE1+: length 138.4
  IN1 w0.254: v3(35.49,105.04) 36.05,105.6 36.66,105.6 38,104.26 39.75,104.26 42.68,107.19 44.97,107.19 48.4,110.62 48.4,111.94 49.38,112.92 49.38,116.54 51.12,118.28 52.48,118.28 55.25,121.05 55.25,122.88 57.35,124.98 60.12,124.98 62.87,127.73 66.78,127.73 67.4,128.35 70.31,128.35 70.62,128.66 70.62,129.12 71,129.5 72.62,129.5 72.89,129.77 75.53,129.77 75.67,129.91 80.63,129.91 89.01,138.29 89.01,139.94 99.17,150.1 99.17,168.29 106.56,175.68 116,175.68 117.36,177.04 v3(118.17,177.04)
  BOTTOM w0.114: v4(119.31,176.7) 118.97,177.04 v3(118.17,177.04)
  BOTTOM w0.254: v3(118.17,177.04) C2.1 117.69,178.24 U1.2 ; v3(35.49,105.04) C4.1 33.22,105.04 Q1.1 32.42,105.84 Q1.2
REMOTE1-: length 135.4
  IN1 w0.254: v3(117.66,176.5) 117.39,176.5 116.19,175.3 106.74,175.3 99.55,168.11 99.55,149.94 89.39,139.78 89.39,138.13 80.78,129.52 75.88,129.52 75.75,129.39 73.2,129.39 72.14,128.34 70.83,128.34 70.47,127.97 67.56,127.97 66.94,127.34 63.02,127.34 60.28,124.6 57.51,124.6 55.63,122.72 55.63,120.89 51.82,117.08 51.16,117.08 49.76,115.69 49.76,112.74 48.78,111.76 48.78,110.46 45.12,106.8 42.84,106.8 39.91,103.88 37.55,103.88 v3(36.38,105.04)
  BOTTOM w0.114: v3(117.66,176.5) 117.79,176.38 v4(117.79,175.68)
  BOTTOM w0.254: Q1.3 33.72,106.28 34.04,105.96 C4.2 35.46,105.96 v3(36.38,105.04) ; v3(117.66,176.5) 117.55,176.62 117.55,177.36 117.25,177.66 C2.2 117.19,177.82 U1.3
REMOTE2+: length 243.3
  TOP w0.254: v3(15.8,57.32) 17.18,55.95 18.07,55.95 21.39,52.62 27.34,52.62 28.99,50.97 28.99,42.1 33.93,37.16 42.84,37.16 48.14,42.46 v3(50.48,42.46)
  IN1 w0.254: v3(15.8,57.32) 16.47,57.32 18.5,59.35 18.5,65.47 20.12,67.1 20.12,70.98 18.98,72.13 18.98,73.67 20.12,74.81 20.12,83.38 23.29,86.55 23.29,87.9 34.55,99.16 34.55,105.34 36.38,107.18 42.04,107.18 42.43,107.57 44.81,107.57 47.02,109.78 47.02,111.1 49,113.08 49,116.7 50.96,118.66 52.32,118.66 54.82,121.16 54.82,122.99 57.2,125.36 59.96,125.36 62.71,128.11 66.61,128.11 67.45,128.94 68.41,128.94 68.85,129.38 69.91,129.38 70.42,129.88 72.38,129.88 73.37,130.88 75.19,130.88 75.75,130.32 80.22,130.32 88.22,138.31 88.22,140.04 98.47,150.3 98.47,168.83 105.96,176.32 115.63,176.32 115.68,176.27 v3(115.68,176.25)
  BOTTOM w0.114: v3(115.68,176.25) 116.01,175.92 v4(116.01,175.68)
  BOTTOM w0.254: v3(115.68,176.25) 116.41,176.98 C3.1 116.69,178.04 U1.4 ; Q2.1 50.13,39.29 Q2.2 50.13,40.84 50.48,41.19 C5.1 v3(50.48,42.46)
REMOTE2-: length 243.1
  TOP w0.254: v3(50.54,43.41) 48.56,43.41 42.68,37.54 34.09,37.54 29.37,42.26 29.37,51.12 27.49,53 21.55,53 18.12,56.43 17.46,56.43 15.89,57.99 v3(15.72,57.99)
  IN1 w0.254: v3(115.52,176.94) 115.31,176.72 105.8,176.72 98.08,169 98.08,150.46 87.81,140.2 87.81,138.47 81.34,131.99 79.81,131.99 79.56,131.74 79.56,131.23 79.3,130.98 78.86,130.98 78.42,131.42 77.78,131.42 77.65,131.29 73.25,131.29 72.22,130.27 70.26,130.27 69.75,129.76 68.69,129.76 68.26,129.33 67.29,129.33 66.45,128.49 62.55,128.49 59.81,125.74 57.04,125.74 54.41,123.12 54.41,121.29 52.8,119.67 51.44,119.67 48.62,116.85 48.62,113.24 46.64,111.26 46.64,109.94 44.65,107.95 39.27,107.95 38.94,108.27 36.94,108.27 34.07,105.4 34.07,99.22 22.91,88.06 22.91,86.7 19.74,83.54 19.74,74.97 18.6,73.83 18.6,71.95 19.74,70.8 19.74,67.25 18.12,65.63 18.12,59.51 16.6,57.99 v3(15.72,57.99)
  BOTTOM w0.114: v3(115.52,176.94) 115.15,176.57 v4(114.48,176.57)
  BOTTOM w0.254: v3(115.52,176.94) 115.85,177.26 115.85,177.42 C3.2 116.19,178.46 U1.5 ; v3(50.54,43.41) 51.39,42.56 C5.2 51.39,41.14 51.43,41.1 Q2.3
RF_OFF#: length 291.1
  TOP w0.114: RC376.2 122.48,73.65 v3(122.48,74.16) ; v4(161.65,52.11) v3(161.14,51.6)
  IN1 w0.14: v3(214.94,45.18) 217.05,47.28 217.05,57.45 219.68,60.08 219.68,66.28 215.82,70.14 215.82,105.91 217.15,107.24 217.15,115.92 224.36,123.14 224.36,134.32 228.63,138.58 228.63,140.14 238.74,150.25 238.74,159.9 241.92,163.08 241.92,167.68 243.11,168.87 247.83,168.87 v3(248.24,169.28) ; v3(161.14,51.6) 161.14,52.44 159.09,54.49 159.09,58.36 150.86,66.59 147.2,66.59 144.74,69.05 134.32,69.05 133.62,69.76 129.98,69.76 128.45,71.29 128.45,72.56 127.84,73.17 123.17,73.17 122.48,73.85 v3(122.48,74.16)
  IN2 w0.14: v3(214.94,45.18) 213.26,45.18 208.54,40.45 202.83,40.45 201.89,41.39 200.82,41.39 200.27,41.94 188.84,41.94 184.32,46.46 173.09,46.46 172.27,45.63 168.26,45.63 162.29,51.6 v3(161.14,51.6)
  IN3 w0.114: v3(122.48,74.16) 122.56,74.08 122.56,73.42 121.44,72.3 121.44,70.52 121.19,70.27 120.62,70.27 117.06,73.83 115.47,73.83 113.85,75.45 113.85,76.27 111.56,78.55 111.56,79.09 107.28,83.38 106.24,83.38 105.24,84.38 105.24,87.18 v3(104.74,87.68)
  BOTTOM w0.076: UC1.AN8 105.12,88.05 v3(104.74,87.68)
  BOTTOM w0.114: JWLBT.56 248.61,169.65 v3(248.24,169.28)
RJ45_ACTIVITY#: length 47.4
  TOP w0.114: v3(44.89,113.32) 45.83,113.32 46.31,113.81 UL1.27
  BOTTOM w0.114: JRJ452.10 17.24,113.8 19.23,111.8 19.23,109.64 20.55,108.32 20.55,106.26 21.08,105.74 29.56,105.74 30.36,104.94 30.36,104.49 32.29,102.56 33.65,102.56 35.33,104.24 38.34,104.24 40.24,106.14 40.24,112.84 40.42,113.02 44.58,113.02 v3(44.89,113.32)
RJ45_GND:
  vias: v3(21.27,114.19) v3(21.39,108.22) v3(21.39,107.58) v3(21.75,124.45) v3(21.75,123.81) v3(21.9,114.19) v3(22.38,118.86) v3(22.38,118.23) v3(22.38,117.57)
RJ45_LINKUP#: length 42.1
  TOP w0.114: UL1.26 45.91,113.97 45.68,113.73 45.37,113.73 44.76,114.34 42.65,114.34 41.43,115.56 41.43,121.96 v4(39.86,123.53) 36.23,127.16 17.78,127.16 16.11,125.5 JRJ452.12
RJ45_TXD0N: length 22.9
  IN1 w0.14: v1(25.61,122.78) 25.61,122.9 25.74,123.03 26.34,123.03 26.45,122.92 26.45,122.65 26.14,122.34 26.14,122.19 26.45,121.88 26.45,121.66 26.14,121.35 26.14,121.12 26.45,120.82 26.45,120.59 26.14,120.29 26.14,120.05 26.45,119.75 26.45,117.16 26.24,116.96 20.73,116.96 19.17,115.4 16.99,115.4 16.85,115.54 16.85,116.29 16.67,116.47 16.24,116.47 15.71,115.95 JRJ452.2
  BOTTOM w0.114: TL1.23 26.74,122.47 26.6,122.61 26.6,122.98 26.49,123.09 25.77,123.09 25.61,122.93 v1(25.61,122.78)
RJ45_TXD0P: length 22.9
  IN1 w0.14: v1(25.61,123.51) 26.52,123.51 26.92,123.11 26.92,116.97 26.43,116.49 20.92,116.49 19.37,114.93 JRJ452.1
  BOTTOM w0.114: TL1.24 27.31,123.51 v1(25.61,123.51)
RJ45_TXD1N: length 16.6
  IN1 w0.14: JRJ452.6 16.7,118.91 19.31,118.91 20.41,120.02 24.81,120.02 25.63,119.2 25.63,118.22 25.14,117.73 24.81,117.73 v5(24.75,117.67)
  BOTTOM w0.114: TL1.19 26.66,117.39 26.53,117.52 26.53,117.72 26.43,117.82 24.9,117.82 v5(24.75,117.67)
RJ45_TXD1P: length 16.5
  IN1 w0.14: JRJ452.3 15.82,116.97 16.64,117.79 16.64,118.21 16.87,118.44 19.5,118.44 20.61,119.55 24.62,119.55 25.16,119 25.16,118.42 24.97,118.23 24.82,118.23 v3(24.72,118.33)
  BOTTOM w0.114: v3(24.72,118.33) 24.85,118.2 v3(25.48,118.2) 26.4,118.2 26.54,118.35 26.54,118.54 26.66,118.66 26.66,118.66 TL1.20
RJ45_TXD2N: length 18.8
  IN3 w0.114: JRJ452.5 14.48,119.01 20.01,119.01 22.59,116.44 22.59,115.56 22.17,115.14 20.99,115.14 v5(20.99,115.14)
  BOTTOM w0.114: v5(20.99,115.14) 21.1,115.25 21.77,115.25 22.04,115.52 25.46,115.52 25.83,115.15 26.5,115.15 26.8,114.85 TL1.17
RJ45_TXD2P: length 18.8
  IN3 w0.114: v3(20.99,115.86) 20.91,115.94 20.91,116.32 21.01,116.42 21.34,116.42 21.48,116.28 21.48,115.6 21.62,115.46 22.04,115.46 22.27,115.69 22.27,116.31 19.88,118.7 15.74,118.7 15.58,118.54 JRJ452.4
  BOTTOM w0.114: TL1.18 26.76,116.12 26.21,115.57 26,115.57 25.63,115.94 v3(25.24,115.94) 21.87,115.94 21.6,115.67 21.18,115.67 v3(20.99,115.86)
RJ45_TXD3N: length 23.6
  IN3 w0.114: v5(25.44,109.48) 25.44,109.47 25.85,109.88 26.56,109.88 26.93,110.25 26.93,113.54 23.96,116.52 23.96,118.89 21.48,121.36 16.29,121.36 JRJ452.8
  BOTTOM w0.114: v5(25.44,109.48) 25.74,109.77 26.57,109.77 TL1.13
RJ45_TXD3P: length 23.6
  IN3 w0.114: JRJ452.7 14.48,121.05 21.35,121.05 23.64,118.75 23.64,116.38 26.61,113.41 26.61,110.38 26.43,110.2 25.44,110.2 v5(25.44,110.2)
  BOTTOM w0.114: v5(25.44,110.2) 25.53,110.2 25.54,110.19 26.14,110.19 26.26,110.31 26.26,110.57 26.73,111.04 27,111.04 TL1.14
RST#: length 3.8
  TOP w0.114: v4(22.73,85.26) 22.84,85.26 RVG131.2 24.39,86.2 25.37,87.17 UVG2.23
S3_1.35V: length 4.4
  BOTTOM w0.203: PU301.7 135.22,40.27 134.25,41.24 PC318.1
  BOTTOM w0.254: PR310.1 PR311.1 134.25,42.61 PC318.1
S5_1.35V: length 4.3
  BOTTOM w0.203: PC319.1 135.08,41.21 135.62,40.68 PU301.8
  BOTTOM w0.254: PC319.1 PR313.2 PR312.2
SA_CLK_DDR0: length 67.2
  IN3 w0.076: v3(79.13,85.75) 78.72,85.34 78.72,84.95 78.73,84.94 78.73,83.04 79.12,82.64 80.55,82.64 81.29,81.9 81.29,80.27 82.02,79.54 82.02,72.38 80.52,70.88 80.52,70.2 80.5,70.18 80.5,70.17
  IN3 w0.114: v3(91.89,35.09) 91.89,34.94 92.03,34.8 92.49,34.8 92.69,35 92.69,36.75 93.12,37.18 93.12,40.53 92.84,40.81 92.84,45.45 92.26,46.03 92.26,46.62 92.84,47.21 92.84,49.67 91.29,51.22 91.29,52.37 91.47,52.55 91.47,53.68 83.84,61.3 83.67,61.3 83.25,60.89 82.92,60.89 82.5,61.31 82.5,61.64 82.84,61.97 82.84,62.14 82.55,62.43 82.38,62.43 82.05,62.09 81.72,62.09 81.3,62.51 81.3,62.84 81.64,63.18 81.64,63.34 80.5,64.48 80.5,70.17
  BOTTOM w0.076: UC1.AT53 v3(79.13,85.75)
  BOTTOM w0.114: v3(91.89,35.09) 92.17,34.81 92.37,34.81 92.49,34.93 92.49,35.98 92.32,36.15 JDIMM1.101
SA_CLK_DDR1: length 67
  IN3 w0.076: 79.76,70.17 79.76,70.18 79.78,70.2 79.78,71.18 80.96,72.36 80.96,75.73 80.65,76.03 80.65,80.18 77.83,83 77.83,85.37 v3(78.22,85.75)
  IN3 w0.114: v3(91.92,31.23) 91.62,31.54 91.37,31.54 91.14,31.77 91.14,36.01 91.88,36.75 91.88,43.06 91.45,43.49 91.45,50.04 90.53,50.96 90.53,53.58 83.95,60.16 82.61,60.16 80.57,62.19 80.57,63.35 79.76,64.17 79.76,70.17
  BOTTOM w0.076: UC1.AT55 v3(78.22,85.75)
  BOTTOM w0.114: JDIMM1.102 92.62,28.95 92.62,29.97 92.79,30.14 92.79,31.16 92.43,31.52 92.21,31.52 v3(91.92,31.23)
SA_CLK_DDR#0: length 67.2
  IN3 w0.076: v3(79.13,85.12) 78.89,84.87 78.89,83.11 79.19,82.81 80.62,82.81 81.45,81.97 81.45,80.34 82.19,79.61 82.19,72.32 80.68,70.81 80.68,70.19 80.7,70.17
  IN3 w0.114: 80.7,70.17 80.7,64.56 81.84,63.42 81.84,63.09 81.5,62.76 81.5,62.59 81.8,62.3 81.96,62.3 82.3,62.64 82.63,62.64 83.05,62.22 83.05,61.89 82.71,61.55 82.71,61.39 83.01,61.09 83.17,61.09 83.58,61.51 83.93,61.51 91.67,53.76 91.67,52.47 91.5,52.29 91.5,51.31 93.05,49.76 93.05,47.12 92.46,46.54 92.46,46.12 93.05,45.53 93.05,40.89 93.33,40.61 93.33,37.1 92.89,36.67 92.89,34.91 92.58,34.6 92.03,34.6 91.89,34.45 v5(91.89,34.3)
  BOTTOM w0.076: UC1.AU53 v3(79.13,85.12)
  BOTTOM w0.114: v5(91.89,34.3) 92.17,34.58 92.47,34.58 92.72,34.83 92.72,35.98 92.92,36.18 JDIMM1.103
SA_CLK_DDR#1: length 67
  IN3 w0.076: 79.97,70.17 79.97,70.19 79.95,70.21 79.95,71.12 81.12,72.29 81.12,75.8 80.82,76.1 80.82,79.04 80.89,79.11 80.89,79.36 80.82,79.44 80.82,79.68 80.89,79.76 80.89,80 80.82,80.08 80.82,80.25 80.7,80.36 80.7,80.48 80.53,80.65 80.41,80.65 80.24,80.83 80.24,80.95 80.06,81.12 79.94,81.12 79.77,81.29 79.77,81.41 79.6,81.59 79.48,81.59 79.3,81.76 79.3,81.88 79.13,82.05 79.01,82.05 78.84,82.22 78.84,82.35 78.67,82.52 78.54,82.52 78.37,82.69 78.37,82.81 78.2,82.98 78.08,82.98 78,83.06 78,83.28 78.07,83.36 78.07,83.6 78,83.68 78,83.92 78.07,84 78.07,84.24 78,84.32 78,84.9 v3(78.22,85.12)
  IN3 w0.114: v5(91.92,31.99) 91.66,31.74 91.45,31.74 91.34,31.85 91.34,35.93 92.08,36.67 92.08,43.14 91.65,43.58 91.65,50.13 90.73,51.04 90.73,53.67 84.04,60.36 82.69,60.36 80.78,62.28 80.78,63.44 79.97,64.25 79.97,70.17
  BOTTOM w0.076: UC1.AU55 v3(78.22,85.12)
  BOTTOM w0.114: v5(91.92,31.99) 92.17,31.75 92.53,31.75 93.02,31.26 93.02,30.16 93.22,29.96 93.22,28.95 JDIMM1.104
SA_DIMM_VREFDQ: length 73.2
  TOP w0.114: v3(70.87,82.87) 69.34,81.35 67.4,81.35 65.16,79.1 65.16,75.48 v4(52.48,62.8) 52.48,55.41 49.92,52.85 49.92,52.36 50.3,51.98 50.48,51.98
  TOP w0.254: RD2.1 58.86,39.99 57.82,41.04 57.82,42.23 58.6,43.02 61.68,43.02 62.21,43.54 62.21,45 63.61,46.39 63.61,49.65 58.98,54.27 54.89,54.27 52.6,51.98 50.48,51.98
  TOP w0.305: CD2.1 RD2.1
  BOTTOM w0.076: UC1.AY68 v3(70.87,82.87)
SATA_PRX_C_DTX_N0: length 2.9
  BOTTOM w0.114: C26.2 177.02,127.67 177.02,126.94 176.5,126.42 JHDD.5
SATA_PRX_C_DTX_N1: length 6.6
  BOTTOM w0.114: JODD.5 228.32,46.22 227.81,46.22 v3(225.97,44.38) 224.79,43.19 224.14,43.19 C129.2
SATA_PRX_C_DTX_P0: length 2.9
  BOTTOM w0.114: C27.2 177.25,127.62 177.25,126.86 177.77,126.34 JHDD.6
SATA_PRX_C_DTX_P1: length 6.6
  BOTTOM w0.114: C130.2 224.08,43.42 224.69,43.42 v3(224.92,43.65) 227.72,46.45 228.24,46.45 JODD.6
SATA_PRX_DTX_N0: length 118.2
  IN3 w0.076: v3(98.34,101.83) 98.53,102.02 98.7,102.02 98.87,102.2 98.87,103.38 98.89,103.4 98.89,103.42
  IN3 w0.114: v3(182.3,112.03) 182.1,111.82 182.1,111.56 181.85,111.32 175.26,111.32 174.75,111.83 170.95,111.83 170.23,111.11 163.67,111.11 161.65,109.08 153.97,109.08 150.32,112.74 143.52,112.74 143.09,112.31 130.05,112.31 128.93,113.43 121.22,113.43 120.46,112.66 110.22,112.66 108.52,110.96 105.96,110.96 103.42,108.42 100.17,108.42 98.58,106.84 98.58,103.99 98.89,103.69 98.89,103.42
  BOTTOM w0.076: UC1.F20 98.58,101.59 v3(98.34,101.83)
  BOTTOM w0.114: C26.1 176.97,129.15 176.97,129.53 177.27,129.83 178.47,129.83 v3(178.82,129.48) 180.35,127.96 180.35,116.52 182.12,114.74 182.12,112.21 v3(182.3,112.03)
SATA_PRX_DTX_N1: length 200.2
  IN3 w0.076: v3(97.42,101.2) 97.22,101.4 97.07,101.4 96.88,101.59 96.88,102.68 97.41,103.21 97.41,103.24 97.43,103.25
  IN3 w0.114: 97.43,103.25 97.72,103.55 97.72,107.38 99.75,109.41 103.12,109.41 105.48,111.77 107.93,111.77 109.68,113.53 120.02,113.53 121.43,114.94 128.72,114.94 130.38,113.27 142.32,113.27 142.7,113.65 150.68,113.65 154.16,110.17 161.18,110.17 163.12,112.12 169.2,112.12 170.48,113.4 174.99,113.4 175.44,112.94 177.41,112.94 177.79,113.32 183,113.32 183.71,112.61 196.45,112.61 197.95,114.11 197.95,114.44 v3(197.72,114.67)
  BOTTOM w0.076: UC1.G21 97.68,100.94 v3(97.42,101.2)
  BOTTOM w0.114: C129.1 222.59,43.12 v3(221.75,43.12) 219.72,43.12 216.54,46.3 216.54,84.6 212.88,88.26 212.88,94.65 197.75,109.79 197.75,114.64 v3(197.72,114.67)
SATA_PRX_DTX_P0: length 118.1
  IN3 w0.076: v3(98.34,102.47) 98.34,102.29 98.44,102.19 98.63,102.19 98.71,102.27 98.71,103.38 98.7,103.4 98.7,103.42
  IN3 w0.114: v3(181.51,112.03) 181.72,112.03 181.89,111.85 181.89,111.65 181.77,111.52 175.34,111.52 174.83,112.03 170.86,112.03 170.15,111.31 163.59,111.31 161.56,109.29 154.06,109.29 150.4,112.94 143.44,112.94 143.01,112.51 130.13,112.51 129.01,113.63 121.14,113.63 120.38,112.87 110.14,112.87 108.44,111.16 105.87,111.16 103.33,108.62 100.08,108.62 98.38,106.92 98.38,103.91 98.7,103.6 98.7,103.42
  BOTTOM w0.076: UC1.E20 98.72,102.17 98.49,102.17 98.34,102.32 v3(98.34,102.47)
  BOTTOM w0.114: v3(181.51,112.03) 181.72,112.03 181.9,112.21 181.9,114.64 180.12,116.42 180.12,127.86 v3(179.64,128.34) 178.38,129.61 177.37,129.61 177.2,129.43 177.2,128.97 177.27,128.89 C27.1
SATA_PRX_DTX_P1: length 200.2
  IN3 w0.076: 97.57,103.11 97.55,103.1 97.53,103.1 97.04,102.61 97.04,101.66 97.14,101.56 97.3,101.56 97.42,101.68 v3(97.42,101.83)
  IN3 w0.114: v5(198.51,114.67) 198.28,114.67 198.15,114.54 198.15,114.03 196.53,112.41 183.62,112.41 182.91,113.12 177.88,113.12 177.5,112.74 175.36,112.74 174.9,113.2 170.57,113.2 169.28,111.91 163.21,111.91 161.27,109.97 154.07,109.97 150.59,113.45 142.79,113.45 142.41,113.07 130.3,113.07 128.64,114.73 121.52,114.73 120.11,113.32 109.77,113.32 108.02,111.57 105.57,111.57 103.21,109.21 99.84,109.21 97.92,107.29 97.92,103.47 97.57,103.11
  BOTTOM w0.076: UC1.F21 97.66,101.59 v3(97.42,101.83)
  BOTTOM w0.114: C130.1 222.48,43.35 219.82,43.35 216.77,46.39 216.77,84.7 213.11,88.36 213.11,94.75 197.97,109.89 197.97,114.26 198.1,114.39 198.23,114.39 v5(198.51,114.67)
SATA_PTX_C_DRX_N0: length 2.9
  BOTTOM w0.114: JHDD.3 173.96,126.24 173.46,126.74 173.46,127.65 C25.2
SATA_PTX_C_DRX_N1: length 5.9
  BOTTOM w0.114: C165.2 224.11,41.49 224.36,41.49 224.52,41.65 v3(224.75,41.65) 226.73,41.65 227.75,42.66 228.26,42.66 JODD.3
SATA_PTX_C_DRX_P0: length 2.9
  BOTTOM w0.114: C24.2 173.21,127.67 173.21,126.84 172.69,126.32 JHDD.2
SATA_PTX_C_DRX_P1: length 5.8
  BOTTOM w0.114: JODD.2 228.3,42.43 227.84,42.43 226.83,41.42 v3(226.04,41.42) 224.61,41.42 224.46,41.26 224.11,41.26 C164.2
SATA_PTX_DRX_N0: length 126.7
  IN3 w0.114: v3(184.54,115.08) 184.74,115.08 184.92,115.25 184.92,115.47 184.4,115.99 179.17,115.99 177.75,117.41 171.56,117.41 168.15,114.01 162.07,114.01 160.16,112.1 155.15,112.1 151.34,115.91 130.93,115.91 130,116.85 120.46,116.85 119.83,116.22 107.96,116.22 107.41,115.66 104.74,115.66 99.52,110.45 99.52,110 98.79,109.26 98.38,109.26 98.13,109.01 v3(98.13,108.93)
  BOTTOM w0.076: UC1.B21 97.6,104.54 97.88,104.82 97.88,106.53 97.72,106.69 97.72,109.13 97.82,109.23 97.97,109.23 98.13,109.08 v3(98.13,108.93)
  BOTTOM w0.114: C25.1 173.46,129.22 173.46,130.07 173.87,130.48 v3(174.58,130.48) 178.73,130.48 181.79,127.42 181.79,119.34 184.92,116.22 184.92,115.25 184.74,115.08 v3(184.54,115.08)
SATA_PTX_DRX_N1: length 202.5
  IN3 w0.114: v3(98.1,111.52) 98.3,111.32 98.65,111.32 99.24,111.91 99.24,113.21 102.59,116.55 107.12,116.55 108.46,117.9 140.9,117.9 141.92,116.88 152.03,116.88 155.86,113.04 159.67,113.04 161.54,114.91 167.6,114.91 171.14,118.45 183.95,118.45 186.75,115.66 194.6,115.66 194.95,115.31 194.95,115.03 v3(195.16,114.82)
  BOTTOM w0.076: UC1.D21 97.38,103.34 97.31,103.61 97.31,103.72 97.17,104.2 97.17,104.45 97.2,104.54 97.2,104.73 97.17,104.83 97.17,104.85 97.17,104.86 97.17,105.19 97.35,105.36 97.35,106.11 97.15,106.3 97.15,110.77 97.68,111.3 97.88,111.3 v3(98.1,111.52)
  BOTTOM w0.114: C165.1 222.66,41.62 v3(221.54,41.62) 219.84,41.62 216.06,45.4 216.06,84.34 212.35,88.05 212.35,94.39 194.98,111.77 194.98,114.64 v3(195.16,114.82)
SATA_PTX_DRX_P0: length 126.7
  IN3 w0.114: v3(185.33,115.08) 185.32,115.08 185.12,115.28 185.12,115.56 184.49,116.19 179.25,116.19 177.83,117.62 171.47,117.62 168.07,114.21 161.98,114.21 160.08,112.31 155.23,112.31 151.42,116.12 131.02,116.12 130.08,117.06 120.38,117.06 119.74,116.42 107.88,116.42 107.32,115.86 104.65,115.86 99.32,110.53 99.32,110.08 98.7,109.46 98.2,109.46 v3(98.08,109.59)
  BOTTOM w0.076: v3(98.08,109.59) 97.88,109.39 97.76,109.39 97.56,109.2 97.56,106.63 97.72,106.47 97.72,105.08 97.6,104.96 UC1.A21
  BOTTOM w0.114: v3(185.33,115.08) 185.15,115.26 185.15,116.31 182.02,119.44 182.02,127.52 178.83,130.71 v3(176.1,130.71) 173.78,130.71 173.23,130.16 173.23,129.22 C24.1
SATA_PTX_DRX_P1: length 202.5
  IN3 w0.114: v3(194.36,114.82) 194.57,114.82 194.75,115 194.75,115.22 194.51,115.46 186.66,115.46 183.87,118.25 171.23,118.25 167.68,114.71 161.62,114.71 159.75,112.84 155.78,112.84 151.94,116.68 141.83,116.68 140.82,117.69 108.55,117.69 107.2,116.35 105.65,116.35 105.52,116.22 105.19,116.22 105.07,116.35 104.74,116.35 104.61,116.22 104.28,116.22 104.15,116.35 103.82,116.35 103.7,116.22 103.37,116.22 103.24,116.35 102.67,116.35 99.45,113.12 99.45,111.83 98.74,111.11 98.3,111.11 v3(98.08,110.89)
  BOTTOM w0.076: UC1.C21 97.42,103.97 97.33,104.23 97.33,104.4 97.39,104.59 97.39,104.74 97.33,104.86 97.33,105.12 97.51,105.29 97.51,106.17 97.31,106.36 97.31,110.71 97.75,111.14 97.92,111.14 98.08,110.99 v3(98.08,110.89)
  BOTTOM w0.114: v3(194.36,114.82) 194.57,114.82 194.75,114.64 194.75,111.67 212.12,94.3 212.12,87.96 215.83,84.25 215.83,45.31 219.75,41.39 v3(219.94,41.39) 222.41,41.39 C164.1
SB_CLK_DDR0: length 54.7
  IN1 w0.076: 81.31,70.17 81.31,70.25 81.33,70.27 81.33,72.02 82.4,73.09 82.4,79.06 82.48,79.14 82.48,79.49 82.4,79.57 82.4,79.9 82.48,79.97 82.48,80.3 82.4,80.38 82.4,80.71 82.48,80.78 82.48,81.11 82.4,81.19 82.4,81.52 82.48,81.6 82.48,81.83 83.07,82.42 83.34,82.42 83.74,82.82 83.74,82.94 83.98,83.17 84.09,83.17 84.32,83.41 84.32,83.52 84.56,83.75 84.67,83.75 84.99,84.08 84.99,84.33 84.92,84.41 84.92,84.74 84.99,84.82 84.99,86.78 84.79,86.98 84.53,86.98 84.21,87.31 83.85,87.31 83.71,87.17 v3(83.71,87.02)
  IN1 w0.114: v5(92.12,48.05) 92.12,47.88 92.27,47.73 92.69,47.73 92.79,47.83 92.79,48.34 92.61,48.52 92.61,49.42 92.79,49.6 92.79,49.89 92.61,50.08 91.72,50.08 91.45,50.35 91.45,50.97 91.23,51.18 90.76,51.18 90.46,51.48 90.46,51.91 90.76,52.21 91.21,52.21 91.4,52.39 91.4,52.65 91.21,52.83 90.62,52.83 90.35,53.09 90.35,54.43 81.31,63.47 81.31,70.17
  BOTTOM w0.076: UC1.AP45 v3(83.71,87.02)
  BOTTOM w0.114: v5(92.12,48.05) 92.12,47.92 92.25,47.79 92.49,47.79 92.7,48 92.7,49.1 92.32,49.47 JDIMM2.101
SB_CLK_DDR1: length 53.8
  IN1 w0.076: v3(82.79,87.02) 82.9,87.14 83.04,87.14 83.17,87 83.17,84.85 83.13,84.81 83.09,84.77 83.09,84.44 83.13,84.39 83.17,84.35 83.17,84.02 83.13,83.98 83.09,83.94 83.09,83.61 83.13,83.57 83.17,83.52 83.17,83.28 81.97,82.08 81.97,73.4 80.61,72.03 80.61,70.2 80.61,70.19 80.59,70.17
  IN1 w0.114: 80.59,70.17 80.59,63.17 89.59,54.17 89.59,51.29 90.63,50.25 90.63,49.87 91.31,49.19 91.31,45.76 90.94,45.39 90.94,44.9 91.13,44.7 92.07,44.7 92.29,44.49 v3(92.29,44.35)
  BOTTOM w0.076: UC1.AP46 v3(82.79,87.02)
  BOTTOM w0.114: v3(92.29,44.35) 92.57,44.64 92.72,44.64 92.82,44.54 92.82,43.47 92.62,43.27 JDIMM2.102
SB_CLK_DDR#0: length 54.8
  IN1 w0.076: 81.51,70.17 81.51,70.19 81.5,70.21 81.5,71.95 82.57,73.02 82.57,79 82.64,79.07 82.64,81.76 83.14,82.26 83.41,82.26 85.16,84.01 85.16,86.85 84.86,87.15 84.6,87.15 84.27,87.48 83.89,87.48 v5(83.71,87.66)
  IN1 w0.114: v3(92.12,47.31) 92.33,47.52 92.78,47.52 93,47.74 93,48.43 92.82,48.6 92.82,49.33 93,49.51 93,49.98 92.69,50.28 91.8,50.28 91.65,50.43 91.65,51.05 91.32,51.38 90.84,51.38 90.66,51.56 90.66,51.82 90.84,52 91.3,52 91.6,52.31 91.6,52.73 91.3,53.03 90.7,53.03 90.56,53.18 90.56,54.52 81.51,63.56 81.51,70.17
  BOTTOM w0.076: UC1.AN45 v5(83.71,87.66)
  BOTTOM w0.114: v3(92.12,47.31) 92.37,47.56 92.58,47.56 92.93,47.91 92.93,49.19 92.92,49.2 JDIMM2.103
SB_CLK_DDR#1: length 53.9
  IN1 w0.076: v3(82.79,87.66) 83.34,87.11 83.34,83.21 82.14,82.01 82.14,73.33 80.77,71.96 80.77,70.27 80.79,70.25 80.79,70.17
  IN1 w0.114: v5(92.29,45.09) 92.1,44.91 91.21,44.91 91.14,44.98 91.14,45.3 91.51,45.67 91.51,49.28 90.84,49.95 90.84,50.33 89.8,51.37 89.8,54.25 80.79,63.26 80.79,70.17
  BOTTOM w0.076: UC1.AN46 v3(82.79,87.66)
  BOTTOM w0.114: v5(92.29,45.09) 92.54,44.84 92.8,44.84 93.02,44.62 93.02,43.47 93.22,43.27 JDIMM2.104
SB_DIMM_VREFDQ: length 54
  TOP w0.254: v3(50.35,51.35) 52.51,51.35 54.79,53.63 57.71,53.63 58.27,53.08 RD17.1 CD31.1
  BOTTOM w0.076: 66.39,79.57 66.39,80.09 67.32,81.02 67.99,81.02 68.42,81.45 69.94,81.45 70.54,82.04 70.94,82.04 71.11,82.21 71.11,82.22 71.11,82.22 71.2,82.44 71.33,82.7 71.47,82.84 UC1.BA67
  BOTTOM w0.114: v3(50.35,51.35) 50.25,51.35 49.84,51.75 49.84,52.85 50.25,53.25 v2(50.86,53.25) 52.38,53.25 55.43,56.3 55.45,56.3 55.45,66.57 66.39,77.51 66.39,79.57
SD_CD#: length 2
  TOP w0.114: RW14.1 54,31.79 UW1.30
SD_CD#_R: length 44.8
  TOP w0.114: RW14.2 55.94,31.64 RW13.2 56.85,30.72 v3(56.85,30.6)
  IN3 w0.114: v3(56.85,30.6) 56.11,30.6 53.54,33.17 51.25,33.17 50.73,33.69 18.88,33.69 17.95,32.77 v5(17.95,32.76)
  BOTTOM w0.114: v5(17.95,32.76) JREAD2.11
SD_CLK_MS_DATA0: length 44.7
  IN3 w0.114: v3(26.7,32.81) 27.16,32.35 30.39,32.35 30.5,32.23 30.5,31.65 30.61,31.54 31.01,31.54 31.12,31.65 31.12,32.23 31.24,32.35 31.63,32.35 31.74,32.23 31.74,30.23 31.86,30.11 32.25,30.11 32.37,30.23 32.37,32.23 32.48,32.35 32.87,32.35 32.99,32.23 32.99,30.23 33.1,30.11 33.5,30.11 33.61,30.23 33.61,32.23 33.73,32.35 34.09,32.35 43.29,23.15 v3(48.57,23.15)
  BOTTOM w0.114: v3(26.7,32.81) 26.7,33.11 RW16.1 27.78,33.2 JREAD2.5 ; RW22.1 CW11.1 49.54,25.69 v4(48.57,24.73) v3(48.57,23.15)
SD_CLK_MS_DATA0_R: length 2.4
  TOP w0.114: UW1.17 48.69,28.48 v3(47.94,27.73)
  BOTTOM w0.114: RW22.2 48.06,27.6 v3(47.94,27.73)
SD_CMD_MS_DATA2: length 44.4
  TOP w0.114: RW23.1 v5(50.48,24.75)
  IN3 w0.114: v3(35.27,32.55) 35.27,32.09 35.36,32 35.52,32 36.25,32.73 36.41,32.73 36.69,32.45 36.69,32.28 35.96,31.56 35.96,31.4 36.24,31.12 36.4,31.12 37.13,31.84 37.29,31.84 37.57,31.57 37.57,31.4 36.84,30.68 36.84,30.52 37.12,30.24 37.28,30.24 38.01,30.96 38.17,30.96 38.45,30.69 38.45,30.52 37.72,29.8 37.72,29.64 39.12,28.24 39.28,28.24 40.01,28.96 40.17,28.96 40.45,28.68 40.45,28.52 39.72,27.79 39.72,27.63 40,27.35 40.16,27.35 40.89,28.08 41.05,28.08 41.33,27.8 41.33,27.64 40.6,26.91 40.6,26.75 40.88,26.47 41.04,26.47 41.77,27.2 41.93,27.2 42.21,26.92 42.21,26.76 41.48,26.03 41.48,25.87 41.76,25.59 41.92,25.59 42.65,26.32 42.81,26.32 43.09,26.04 43.09,25.88 42.36,25.15 42.36,24.99 42.6,24.75 42.93,24.75 43.05,24.64 43.05,23.88 43.16,23.76 43.56,23.76 43.67,23.88 43.67,24.64 43.79,24.75 44.18,24.75 44.29,24.64 44.29,23.88 44.41,23.76 44.8,23.76 44.92,23.88 44.92,24.64 45.03,24.75 45.42,24.75 45.54,24.64 45.54,23.88 45.65,23.76 46.05,23.76 46.16,23.88 46.16,24.77 46.27,24.88 46.67,24.88 46.78,24.77 46.78,23.88 46.9,23.76 47.29,23.76 47.4,23.88 47.4,24.64 47.52,24.75 v5(50.48,24.75)
  BOTTOM w0.114: v3(35.27,32.55) JREAD2.2
