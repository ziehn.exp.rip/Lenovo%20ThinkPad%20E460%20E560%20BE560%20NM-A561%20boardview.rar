# Allegro board Lenovo ThinkPad E460 E560 BE560 NM-A561 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3VALW_LAN: length 100.4
  TOP w0.203: UL1.15 43.73,118.95 v3(43.67,119.02) ; UL1.29 47.11,112.83 RL4.2 ; v3(43.57,117.36) 43.58,117.35 UL1.19
  TOP w0.508: v3(40.85,112.33) 40.44,112.74 40.44,121.91 35.66,126.69 20.16,126.69 v3(18.34,124.88) ; RL4.2 46.08,112.38 v3(46.01,112.46) 45.78,112.46 45.27,111.95 45.27,111.24 45.75,110.76 46.64,110.76 47.45,109.95 48.77,109.95 49.33,110.51 RL5.1 RL6.1 ; RL19.2 59.48,123.34 58.43,124.4 56,124.4 55.39,125.01 QL2.1 51.72,122.16 v3(51.57,122.01)
  BOTTOM w0.508: v3(40.85,112.33) 40.85,106.13 38.52,103.8 35.51,103.8 33.83,102.12 32.11,102.12 30.43,103.8 28.07,103.8 26.72,105.15 21,105.15 20.02,106.13 20.02,108.19 18.73,109.49 RL16.1 ; CRF15.1 CRF16.1 v2(54.59,122.39) 53.83,122.39 v3(53.5,122.06) ; v3(18.34,124.88) RL15.1
+3VALW_LOGO: length 11.9
  TOP w0.114: JLCD.9 97.11,137.64 97.11,136.87 97.42,136.56 97.42,135.29 v2(97.72,134.99) 98,134.71 98,134.05 v3(98.13,133.92) 98.29,133.76 R25.2
  BOTTOM w0.114: v3(98.13,133.92) 96.78,133.92 CRF13.1 CRF14.1 94.11,131.26 D1.3
+3VALW_OUT: length 2.5
  BOTTOM w0.254: PU201.4 167.98,4.84 167.7,4.56 PR203.1
+3VALW_P: length 45.1
  IN1 w0.381: v3(168.61,4.89) 168.61,4.26 167.77,3.42 161.14,3.42 160.58,2.86 153.12,2.86 152.58,3.39 152.58,3.42 151.01,4.99 v3(151.01,6.52) ; v3(168.54,2.33) 168.54,2.45 168.1,2.88 161.6,2.88 161.04,2.33 151.75,2.33 150.91,3.16 150.88,3.16 150.02,4.03 v3(150.02,6.42)
  BOTTOM w0.254: PR207.2 168.54,3.21 v3(168.54,2.33) ; PR203.2 v3(168.61,4.89)
  vias: v4(150.7,7.3)
+3VALW_PCH: length 319.1
  TOP w0.254: 126.17,62.27 125.85,61.95 124.71,61.95 121.53,58.77 107.58,58.77 106.15,60.2 106.15,60.59 104.22,62.52 RC356.2
  TOP w0.381: v3(122.79,76.44) 122.18,75.83 RC95.2 ; v3(121.65,63.69) 124.75,63.69 127.25,61.19 v3(127.25,60.43) 126.99,60.17 124.07,60.17 121.98,58.08 106.38,58.08 97.26,67.2 RC330.1 ; v3(128.43,88.94) 128.02,89.35 128.02,89.93 126.88,91.07 126.88,91.96 126.37,92.47 125.74,92.47 125.1,93.11 v3(124.49,93.11) ; RC306.2 v3(116.34,97.98) RC92.2 116.34,97.12 116.92,96.53 116.92,96.08 116.54,95.7 RC326.1 117.02,95.57 v3(117.18,95.42)
  TOP w0.508: CC263.1 100.31,93.79 v3(100.6,94.08) 100.56,94.11 CC262.1 100.56,95.72 v3(100.6,95.75) ; v3(101.9,92.4) 102.06,92.57 CC264.1 ; RC333.1 RC308.2 116.71,77.26 117.15,76.81 117.15,75.63 v3(117,75.48) RC132.1 ; v3(151.69,37.61) 153.14,36.16 166.83,36.16 v3(169.96,39.28) ; v3(111.31,114.16) 111.31,114.09 111.88,113.51 v4(113.34,113.51) 113.34,113.25 114.66,111.93 114.66,111.24 115.4,110.5 115.4,106.92 114.71,106.24 v3(114.71,103.37) ; RA27.1 v3(196.93,28.13)
  IN1 w0.381: v3(124.36,85.97) 127.51,85.97 128.05,85.43 128.05,82.23 v3(128.07,82.21)
  IN2 w0.381: v3(101.99,88.93) 101.99,89.97 101.25,90.72 ; v3(124.49,93.11) 124.49,94.27 122.71,96.05 122.04,96.05 121.51,96.59 119.34,96.59 118.47,97.45 116.87,97.45 v3(116.34,97.98) ; 101.25,90.72 102.85,90.72 103.82,89.75 106.58,89.75 107.4,88.94 107.4,88.38 107.78,88 115.58,88 116.99,86.59 118.67,86.59 119.75,87.67 120.33,87.67 121.85,86.15 124.19,86.15 v3(124.36,85.97) ; 101.25,90.72 v3(101.25,90.73)
  IN2 w0.508: v3(127.25,60.43) 129.98,57.7 129.98,47.74 131.98,45.73 147.02,45.73 151.69,41.06 v3(151.69,37.61)
  IN3 w0.508: v1(125.09,68.24) 125.51,68.66 v3(125.51,71.97) ; v3(114.71,103.37) 115.98,103.37 118.29,101.06 121.11,101.06 121.47,101.41 122.28,101.41 122.36,101.34 125.76,101.34 127.95,99.15 v3(131.76,99.15)
  BOTTOM w0.254: UC1.T16 v3(100.6,95.75) ; UC1.Y15 v3(101.9,94.08) ; UC1.AK15 v3(101.99,88.93) ; UC1.Y16 v3(100.6,94.08) ; v3(101.25,90.73) 101.5,91.07 UC1.AG15 ; UC1.AD15 101.83,92.48 v3(101.9,92.4)
  BOTTOM w0.381: v3(117.18,95.42) 116.62,95.42 116.19,94.99 RC83.1 RC93.2 ; v3(121.65,63.69) 121.67,63.69 122.05,64.07 122.05,65.2 v1(125.09,68.24)
  BOTTOM w0.508: v3(122.79,76.44) 122.79,76.02 121.21,74.45 ; RC298.2 111.75,113.26 111.31,113.7 v3(111.31,114.16) ; v3(169.96,39.28) 174.89,34.36 185.88,34.36 189.36,30.88 194.75,30.88 196.93,28.69 v3(196.93,28.13) ; 121.21,74.45 121.21,72.94 v3(122.15,72) 122.37,72 124.07,73.7 124.07,75.13 126.09,77.15 126.09,78.7 126.48,79.09 126.48,80.62 v3(128.07,82.21) ; 121.21,74.45 120.18,75.48 v3(117,75.48) ; v3(128.43,88.94) 128.43,89.02 131.76,92.34 v3(131.76,99.15)
+3VALW_PRIM: length 27.6
  TOP w0.381: v1(114.66,94.12) 115.07,94.12 CC97.1 RC326.2
  IN2 w0.381: v3(98.63,94.91) 98.63,94.83 99.09,94.38 100.13,94.38 100.69,94.93 106.87,94.93 107.15,94.65 108.87,94.65 109.43,94.1 109.43,93.38 110.04,92.78 111.11,92.78 111.49,93.16 114.06,93.16 114.66,93.75 v1(114.66,94.12)
  IN3 w0.381: v3(98.63,94.91) 98.05,94.33 98.05,93.46 97.52,92.93 96.97,92.93 96.59,92.55 96.59,92.15 97.11,91.63 97.11,90.84 v3(97.06,90.79)
  BOTTOM w0.254: UC1.AJ21 97.66,90.35 97.21,90.79 v3(97.06,90.79) ; UC1.V19 v3(98.63,94.91)
+3VALW_RTCPRIM: length 11.6
  TOP w0.508: 108.58,84.49 109.02,84.05 110.99,84.05 112.01,83.03 113.21,83.03 115.36,80.89 RC333.2
  BOTTOM w0.254: UC1.AK17 v3(100.17,88.93)
  vias: v4(107.31,84.43)
+3VBS: length 4.4
  TOP w0.381: v3(169.47,6.39) 169.47,6.91 v4(168.65,7.74) PR202.1
+3VDMIC: length 6.6
  TOP w0.203: v2(98.74,134) 98.74,134.51 98.89,134.66 98.89,135.22 98.43,135.68 98.43,138.58 97.94,139.07
  TOP w0.254: R9475.2 98.74,133.14 v2(98.74,134)
+3VL: length 431.2
  TOP w0.203: RPE5.1 195.14,37.92 v3(195.41,37.66) 195.64,37.89 RPE5.2 ; UE1.112 193.31,41.89 192.87,41.44 192.87,40.6 192.28,40.02 CE9.1 192.33,39.82 193,39.82 193.38,40.2 193.38,41.09 194.11,41.82 UE1.114 ; 199.31,41.4 UE1.127 ; CE6.1 204,54.47 UE1.26 ; CE8.1 192.91,60.99 UE1.50 ; 184.23,45.84 184.59,45.84 184.82,46.07 UE1.92 ; UE1.121 196.91,41.36 v3(197.11,41.16)
  TOP w0.305: v3(114.66,75.68) 114.86,75.48 RC127.1
  TOP w0.381: v3(207.85,51.6) 207.68,51.42 RE4.1 ; 199.31,41.4 199.31,41.02 199.84,40.49 200.14,40.49 200.72,39.92 CE5.1 CE10.1 v3(202.29,39.74) ; v3(203.44,55.24) 203.44,55.12 204,54.56 CE6.1 ; CE8.1 192.99,61 v3(193.73,60.26) ; JU3LF.20 243.33,177.05 v3(243.24,176.95) ; 183.88,45.84 184.23,45.84
  TOP w0.508: LE1.1 179.91,54.29 180.52,54.9 v3(180.52,55.16) 181.83,55.16 RE3.2 ; v3(188.17,39.16) 188.27,39.16 188.78,39.66 RE31.2 ; v3(191.42,35.97) 191.42,35.98 191.22,36.19 RE33.2 ; 183.88,45.84 183.7,45.66 183.28,45.66 CE4.1 183.2,44.91 v3(183.19,44.9) ; RE39.2 182.17,50.41 v3(181.41,49.65) ; v3(191.62,39.87) CE9.1 ; v3(163.18,64.86) 163.61,64.43 173.03,64.43 174.03,63.43 RPE3.4 ; RA30.2 v3(201.48,14.47) ; v3(228.33,152.03) 227.7,152.66 PR18.2 ; v3(219.78,112.45) 218.14,110.81 218.14,65.39 v4(218.01,65.27) 218.01,64.43 216.67,63.08 216.67,61.41 v3(217.33,60.75)
  IN1 w0.305: v3(152.79,62.02) 152.79,62 152.27,61.48 150.7,61.48 148.15,64.04 140.81,64.04 136.73,68.12 132.21,68.12 131.45,68.87 129.06,68.87 126.98,70.96 122.43,70.96 120.88,72.51 120.88,73.2 120.05,74.03 119.59,74.03 119.34,74.28 116.06,74.28 v3(114.66,75.68)
  IN1 w0.508: v3(181.51,59.15) 180.5,58.13 180.5,55.18 v3(180.52,55.16) 180.52,54.5 181.41,53.61 v3(181.41,49.65) 180.02,48.25 180.02,44.54 v3(180.68,43.88)
  IN2 w0.508: v3(228.33,152.03) 227.64,152.72 227.64,156.66 229.42,158.43 230.38,158.43 236.53,164.58 236.53,172.56 240.93,176.95 v3(243.24,176.95)
  IN3 w0.254: v3(171.15,3.72) 171.53,4.1 171.53,6.56 183.23,18.26
  IN3 w0.508: v3(217.33,60.75) 217.05,60.75 214.08,57.77 208.64,57.77 208.26,57.39 208.26,52.01 v3(207.85,51.6) 206.69,52.77 206.69,54.98 206.15,55.51 203.72,55.51 v3(203.44,55.24) 203.44,54.92 203.76,54.6 203.76,48.43 201.66,46.33 201.66,40.38 v3(202.29,39.74) 202.29,37.17 201.86,36.74 200.85,36.74 190.96,26.85 190.96,26.47 185.44,20.95 184.16,20.95 183.87,20.66 183.87,19.38 183.23,18.74 183.23,18.26 183.95,17.54 191.55,17.54 194.62,14.47 v3(201.48,14.47) ; v3(181.51,59.15) 180.75,59.91 166.81,59.91 163.12,63.59 163.12,64.81 v3(163.18,64.86) 162.87,65.17 161.5,65.17 158.15,61.81 152.99,61.81 v3(152.79,62.02)
  BOTTOM w0.254: 171.91,3.6 172.35,3.6 172.95,2.99 PR217.1 PR216.1
  BOTTOM w0.381: v3(228.33,152.03) 228.33,146.9 226.8,145.38 221.39,145.38 218.14,142.13 218.14,141.35 212.21,135.42 212.21,134.72 ; PR10.1 210.52,133.82 211.42,134.72 212.21,134.72 ; 212.21,134.72 212.84,134.09 217.82,134.09 218.14,133.77 218.14,122.8 218.65,122.29 R71.1 219.92,112.59 v3(219.78,112.45)
  BOTTOM w0.508: v3(203.44,55.24) 202.9,55.24 199.07,59.07 196.35,59.07 195.15,60.26 v3(193.73,60.26) 182.63,60.26 v3(181.51,59.15)
+3VL_AVCC: length 4.8
  TOP w0.203: v2(184.26,53.76) 184.75,53.27 UE1.74
  TOP w0.381: v2(184.26,53.76) 184.23,53.79 CE3.1 CE2.1 181.52,53.79 LE1.2
+3VLX: length 1
  TOP w0.254: v3(161.35,7.69) v4(160.38,7.69)
  vias: v3(161.35,8.32)
+3VS: length 581.6
  TOP w0.114: 113.66,62.33 v3(113.25,61.93)
  TOP w0.203: UE1.11 202.47,48.47 v3(202.68,48.25) ; 46.58,31.86 46.62,31.86 46.69,31.79 UW1.11 ; RPE5.4 196.64,37.9 196.4,37.66 ; RPE5.3 196.14,37.92 196.4,37.66 ; 196.4,37.66 196.4,35.52 v3(197.19,34.74)
  TOP w0.254: R217.1 235.35,144.88 235.35,144.81 C115.1 ; v3(154.69,65.14) 151.29,68.54 149.85,68.54 147.69,70.7 139.91,70.7 v3(138.13,72.48) ; RPC22.5 113.66,62.33 ; RC433.1 126.18,69.64 128.01,69.64 129.13,70.76 RPC200.1 ; v3(125.46,77.59) 125.46,77.61 124.97,78.09 RC165.1
  TOP w0.305: RD19.1 121.82,48.26 v3(122.59,48.26) 122.78,48.26 123.17,47.87 123.17,46.7 122.82,46.34 CD57.1 CD58.1
  TOP w0.381: v3(214.1,71.95) 207.6,71.95 206.53,73.01 RG5.2 ; RC1.1 116.67,100.14 v3(117.13,100.14) 117.13,99.84 117.53,99.43 117.96,99.43 118.24,99.15 RC2.1 118.29,98.77 RC434.1 ; RW18.2 53.27,25.67 v3(53.65,25.29) ; JU3LF.19 v3(245.19,176.55)
  TOP w0.406: v3(108.85,66.38) 109.72,67.26 109.72,68.48 RC52.2
  TOP w0.508: RD25.2 v3(112.07,20.49) ; RE9.2 204.37,133.44 201.66,130.72 201.1,130.72 198.61,128.23 198.61,125.54 200.01,124.14 200.01,122.54 v3(197.95,120.49) ; 174.89,65.47 175.08,65.67 ; 175.08,65.67 170.54,65.67 170,65.13 165.75,65.13 164.34,66.54 164.34,77.93 161.37,80.9 161.37,85.1 v3(162.19,85.92) ; 175.08,65.67 177.94,65.67 178.8,64.81 v3(184.46,64.81) ; RW11.1 RW12.1 56.17,29.81 56.34,29.63 56.52,29.63 v3(56.67,29.48) ; R70.2 C52.1 215.91,94.13 215.64,94.4 v3(214.24,94.4) ; RC287.1 RC277.1 47.33,104.33 44.35,107.3 v3(44.35,109.82) ; v3(181.1,121.26) 181.1,120.25 180.21,119.36 174.75,119.36 173.49,120.61 R111.1 ; RT36.1 v3(24.69,95.09) ; v3(182.56,125.01) 182.07,124.53 R60.1 ; 46.58,31.86 45.84,31.86 CW6.1 ; v3(201.33,57.72) 201.94,58.33 204.26,58.33 204.79,57.8 RE8.2 204.79,56.98 205.24,56.53 205.95,56.53 206.79,55.69 RE41.2 206.84,55.46 RE51.2 ; RC413.2 33.78,107.29 35.95,109.46 v3(42.68,109.46) ; R9475.1 v3(100.15,131.73) ; RW20.1 55.94,32.55 RW13.1 55.96,32.88 v3(55.38,33.47) ; v3(122.4,34.92) 122.09,34.92 121.34,35.66 CD30.1 121.33,36.43 CD29.1 ; v3(215.83,22.52) 215.35,22.52 RA18.1 ; RC108.1 173.62,132.98 QV6.3 v3(172.69,130.43) ; RVG132.1 v3(27.36,95.11) ; RA28.1 v3(214.97,28.35) ; RVG133.1 v3(26.47,95.06) ; v3(161.37,95.04) 159.82,93.48 155.74,93.48 154.42,92.17 153.45,92.17 152.76,91.48 151.42,91.48
  IN1 w0.508: v3(162.19,85.92) 161.35,86.76 161.35,89.86 160.05,91.15 160.05,92.5 161.37,93.82 v3(161.37,95.04) ; v3(53.65,25.29) 54.41,26.05 63.61,26.05 65.87,23.79 v3(77.27,23.79) ; v3(141.03,41.16) 138.28,43.91 v3(138.28,43.93) 138.06,44.16 137.14,44.16 135.58,45.72 129.22,45.72 v3(129.22,45.71) ; v3(184,123.15) 182.11,121.26 v3(181.1,121.26)
  IN2 w0.254: v3(125.46,77.59) 125.46,76.8 127.51,74.74 v3(129.98,74.74) 130.44,74.74 131.12,74.06 136.89,74.06 138.13,72.81 v3(138.13,72.48)
  IN2 w0.508: v3(77.27,23.79) 80.88,20.18 111.77,20.18 v3(112.07,20.49) 112.71,20.49 115.12,22.9 116.13,22.9 121.52,28.28 121.52,34.41 122.03,34.92 v3(122.4,34.92) 123.07,34.92 123.88,35.73 123.88,39.54 129.22,44.87 v3(129.22,45.71) ; 216.87,50.64 216.52,50.28 211.87,50.28 211.23,49.65 208.41,49.65 207.78,50.28 204.31,50.28 201.71,52.89 201.71,57.34 v3(201.33,57.72) 200.03,59.02 196.71,59.02 194.82,60.91 194.82,62.2 192.12,64.91 189.8,64.91 189.49,65.22 188.04,65.22 187.64,64.81 v3(184.46,64.81) ; v3(245.67,158.74) 245.67,159.68 244.68,160.67 239.55,160.67 237.95,162.27 237.95,169.61 239.32,170.98 239.32,172.71 240.14,173.52 243.54,173.52 244.05,174.03 244.05,175.4 v3(245.19,176.55)
  IN3 w0.254: v3(184.46,64.81) 169.53,64.81 167.54,66.79 156.34,66.79 v3(154.69,65.14)
  IN3 w0.508: v3(109.68,180.74) 110.34,180.08 v3(119.18,180.08) ; v3(80.7,133.2) 80.7,133.14 v1(79.05,131.48) 78.42,130.85 v1(78.29,130.85) 77.93,130.85 77.43,130.34 v1(74.83,130.34) ; v3(206.3,39.26) 205.49,40.07 205.49,45.86 206.43,46.8 v3(206.94,46.8)
  BOTTOM w0.254: RC409.1 v1(223.02,62.16) ; PR704.2 v3(138.28,43.93) ; PR308.2 v3(141.03,41.16)
  BOTTOM w0.305: QC1.5 75.16,131 74.83,130.66 v1(74.83,130.34) 74.83,130.02 RC107.2 ; RT37.1 v3(13.52,87.03) ; JDIMM1.199 121.72,35.6 v3(122.4,34.92) ; JDIMM2.199 121.72,50.35 121.72,49.08 122.54,48.26 v3(122.59,48.26) ; v3(233.05,147.82) 233,147.82 R106.1
  BOTTOM w0.356: QT1.5 QT1.2 v3(16.88,89.56) ; v1(78.29,130.85) 78.14,131 QC1.2
  BOTTOM w0.381: 124.56,48.26 v3(122.59,48.26) ; RC67.1 119.87,94.02 v3(120.07,93.82) 120.33,93.82 RC70.1 ; QC2.5 116.66,96.63 v3(116.36,96.33) 116.07,96.63 QC2.2 ; UV15.5 124.33,95.18 124.33,95.61 v1(124.39,95.67) ; RC88.1 RC86.1 114.38,98.69 114.74,99.05 v3(114.74,99.15)
  BOTTOM w0.508: v3(214.97,28.35) 214.59,27.97 214.59,23.41 215.47,22.52 v3(215.83,22.52) ; CC22.1 79.38,131.82 v1(79.05,131.48) 79.3,131.23 RC106.2 ; 91.98,141.95 92.56,141.37 R17.1 ; v3(100.15,131.73) 99.68,132.2 99.68,144.11 96.96,146.83 ; 124.59,48.26 126.32,46.52 128.4,46.52 v3(129.22,45.71) ; 124.59,48.26 124.56,48.26 ; 124.59,48.26 125.41,49.08 125.41,50.46 113.94,61.93 v3(113.25,61.93) 113.1,61.77 112.11,61.77 108.54,65.34 108.54,66.08 v3(108.85,66.38) ; R9480.2 110.93,124.35 110.93,124.35 v3(110.45,123.86) ; v3(202.68,48.25) 205.49,48.25 v3(206.94,46.8) ; v3(80.7,133.2) 81.25,132.65 USROM1.8 ; v3(86.98,124.6) 86.98,120.42 86.23,119.67 RC29.1 ; PR406.2 v1(65.84,114.59)
  BOTTOM w1.016: 37.2,89.77 37.78,90.34 37.78,101.54 42.68,106.44 42.68,108.56
  vias: v1(36.34,89.64) v1(36.34,89) v3(19.61,73.22) v3(19.61,72.46) v3(23.93,78.21) v3(24.5,78.53) v3(24.47,77.84) v3(28.71,35.45) v3(29.24,35.96) v3(42.65,110.1) v3(43.33,110.13) v3(43.34,109.44) v3(44.2,32.5) v3(44.86,32.53) v3(81.79,134.86) v3(82.38,135.27) v3(82.89,135.75) v3(83.42,136.21) v3(120.2,124.09) v3(183.67,123.71) v3(183.8,124.35) v3(183.85,124.98) v3(184.31,123.71) v3(184.49,124.96) v3(184.51,124.32) v3(184.66,123.18) v3(184.94,123.84) v3(186.11,20.11) v3(186.11,19.47) v3(186.75,20.11) v3(186.75,19.47) v3(187.38,20.11) v3(187.38,19.47) v3(188.02,20.11) v3(188.02,19.47) v3(188.65,20.11) v3(188.65,19.47) v3(196.04,28.06) v3(196.04,27.4) v3(198.43,15.66) v3(199.07,15.66) v3(205.24,12.18) v3(205.9,12.18) v3(236.58,144.82) v3(236.58,144.18) v3(245,158.88) v3(245.67,158.08)
+3VS_CMOS: length 5.9
  TOP w0.254: 96.72,139.73 96.87,139.57 JLCD.6
  TOP w0.508: 96.72,139.73 95.84,140.6 95.84,140.86 v3(94.88,141.82)
  BOTTOM w0.508: R17.2 94.68,142.01 v3(94.88,141.82)
+3VS_DDIMUX: length 9.6
  TOP w0.229: CX14.1 27.36,58.08 26.87,58.58 UX1.41
  TOP w0.381: RX3.1 24.28,69.72 v3(23.81,70.19) ; v3(28.15,70.65) 28.78,70.02 RX9.1
  TOP w0.508: CX14.1 v3(26.68,57.27) ; RX16.1 v3(29.27,57.44) ; 19.23,57.06 19.95,56.35 RX19.1 ; RX14.1 v3(25.84,56.37) ; RX17.1 31.3,59.22 v3(31.55,59.48)
  vias: v3(18.24,70.22) v3(18.24,69.51) v3(18.55,57.67) v3(18.55,56.99) v3(29.27,67.63) v4(19.59,57.57)
+3VS_DP: length 8.3
  TOP w0.305: UVG2.9 31.2,90.97 31.83,91.61 31.83,92.37 31.04,93.16 CVG34.1
  TOP w0.381: CVG34.1 v3(31.76,93.51) ; UVG2.17 25.37,90.17 24.31,91.23 CVG37.1 23.68,90.54 v3(23.6,90.46)
  vias: v2(31.76,92.62) v3(30.51,83.76) v3(32.59,85.66) v3(33.25,85.64) v3(34.22,85.66) v3(35.16,85.66) v3(36.1,85.76)
+3VS_DVDD: length 4.9
  TOP w0.203: 204.77,19.25 204.77,19.29 205.28,19.8 205.84,19.8 205.85,19.79 UA1.18
  TOP w0.254: 204.77,19.25 204.77,19.08 203.82,18.12 CA14.1 204.45,18.05 204.68,18.28 v3(204.78,18.28)
  vias: v3(200.59,16.12) v3(201.43,16.12) v4(200.01,16.14)
+3VS_FP: length 4.1
  TOP w0.114: R70.1 214.99,91.63 v4(214.97,91.61) 214.94,91.58 214.43,91.58 213.36,92.65 JFPB.1
+3VS_LS:
  vias: v4(188.91,22.96)
+3VS_VDDIO: length 4.8
  TOP w0.203: v4(208.24,24.5) 208.24,24.2 208.58,23.86 UA1.7
  TOP w0.381: v3(208.5,25.21) 208.5,25.34 208.79,25.64 CA42.1 209.07,25.81 209.07,24.8 208.77,24.5 v4(208.24,24.5)
  vias: v3(196.17,24.65) v3(196.83,24.65)
+3VS_VDDO: length 13.1
  TOP w0.114: RA28.2 215.3,26.35 v3(215.3,25.95) 215.17,25.82 v2(214.76,25.82) 213.8,25.82 212.17,24.2 211.11,24.2 210.58,23.66 UA1.2 ; RA29.1 v3(218.62,22.32)
  BOTTOM w0.114: v3(218.62,22.32) RA29.1 215.3,24.96 v3(215.3,25.95)
+3VS_VGA: length 194.5
  TOP w0.254: UV14.1 164.29,155.46 164.14,155.6 CV205.1 ; v3(161.68,142.15) 161.97,142.44 161.99,142.44 RV98.1 162.62,142.59 163.11,142.59 RV99.1 ; PR604.2 208.06,146.29 208.57,145.79 209.28,145.79 210.11,146.62 210.11,148.12 211.07,149.07 212.59,149.07 213.54,150.03 216.97,150.03 218.27,151.33 218.27,152.28 218.69,152.69 v3(219.77,152.69)
  TOP w0.305: RV98.1 162.61,143.07 162.75,143.07 163.12,143.44 163.12,143.89 163,144.02 163,145.37 163.12,145.49
  TOP w0.381: CV205.1 164.32,156.3 164.9,156.88 v3(165.16,156.88) ; RV134.2 171.13,154.34 172.22,155.44 RV92.1 172.22,156.94 171.84,157.32 v3(170.57,157.32) ; v1(149.1,143.8) 149.74,144.44 CV62.1 ; RV136.1 RV132.1 161.37,146.22 RV135.1 161.47,146.93 161.77,146.93 v3(162.24,146.47) ; RV138.1 RV117.1 161.78,150.33 162.19,150.74 v3(162.19,151.78) 161.93,151.78 161.7,152.01 RV139.1 RV140.1
  TOP w0.508: v3(156.34,124.45) 156.34,123.68 153.09,120.44 151.75,120.44 151.29,119.98 151.29,117.43 RV14.1 152.24,116.47 RV11.1 ; v3(162.24,146.47) 163.96,146.47 164.5,147 RV131.1 ; 165.11,121.88 165.33,121.88 166.35,120.87 168.97,120.87 v3(169.98,119.85) ; v3(160.33,156) 161.65,156 RV91.1 ; PR604.2 207.37,145.89 207.37,142.84 v3(206.61,142.08)
  IN1 w0.508: v3(169.98,119.85) 170.01,119.83 170.01,113.76 165.72,109.47 v3(165.72,107.15)
  IN3 w0.381: v3(170.57,157.32) 170.41,157.32 168.84,155.74 166.68,155.74 165.54,156.88 v3(165.16,156.88) 163.33,156.88 162.44,156 v3(160.33,156)
  IN3 w0.508: v3(129.06,95.34) 131.25,95.34 131.98,94.6 133.69,94.6 136.05,96.97 149.61,96.97 150.4,97.75 150.4,100.06 152.36,102.02 159.52,102.02 163.61,106.11 164.67,106.11 v3(165.72,107.15)
  BOTTOM w0.254: PR612.1 219.51,152.95 v3(219.77,152.69)
  BOTTOM w0.381: v1(161.93,131.61) 161.93,131.43 161.93,131.43 RV93.1
  BOTTOM w0.508: v3(206.61,142.08) 206.61,141.59 204.96,139.94 204.96,136.82 201.66,133.52 179.28,133.52 178.01,132.25 173.03,132.25 171,130.21 171,127.67 169.4,126.07 166.35,126.07 v3(163.76,123.48) ; RV9.1 129.57,94.83 v3(129.06,95.34)
  vias: v3(163.94,122.67) v3(163.94,121.99)
+5V_PWRGD: length 1.6
  BOTTOM w0.254: PR211.1 187.66,8.55 187.39,8.28 PU202.2
+5V_VCC: length 2.7
  BOTTOM w0.203: PC218.2 184.87,9.37 184.87,8.55 185.05,8.37 185.73,8.37 186.04,8.06 PU202.5
+5V_VIN:
  vias: v4(183.95,5.91)
+5VALW: length 511.7
  TOP w0.203: AOU1.4 36.51,19.35 v3(37.01,19.85) ; v3(34.15,21.32) AOU1.7
  TOP w0.254: U11.4 184.91,24.55 184.76,24.4 v3(184.49,24.4)
  TOP w0.305: UV12.4 171.78,174.03 CV236.1
  TOP w0.381: RV208.1 168.15,179.21 169.88,177.48 v3(170.49,177.48)
  TOP w0.508: v3(145.73,49.57) 145.4,49.57 144.89,49.06 144.89,47.66 143.34,46.12 136.38,46.12 v3(135.87,46.62) ; v3(61.07,120.87) 61.07,120.74 60.36,120.03 60.36,117.87 60.03,117.54 RL22.1 ; R156.1 v3(205.92,142.05) 205.24,142.74 205.24,145.2 202.27,148.17 v3(202.27,152.8) ; v3(38.03,105.75) 38.94,105.75 44.69,100.01 44.69,97.26 41.95,94.52 41.95,91.85 41.4,91.29 41.4,77.32 v3(40.57,76.49) ; v3(212.27,37) 213.04,37 213.77,36.26 R28.1 ; CV236.1 v3(170.59,174.66) ; v3(34.09,24.04) 38.61,28.56 v3(38.61,29.48) ; v3(201.99,62.14) 201.89,62.04 RE2.2 ; v3(125.46,104.36) 125.46,103.42 126.35,102.53 126.35,100.98 127.77,99.56 130.18,99.56 132.09,97.65 139.99,97.65 141.97,95.67 141.97,93.61 143.52,92.06 143.52,89.86 143.82,89.56 144.11,89.56 144.58,90.03 144.84,90.03 146.17,91.37 146.17,91.95 147.86,93.64 148.95,93.64 150.15,94.83 156.34,94.83 163.96,102.45 163.96,103.82 165.36,105.22 166.91,105.22 167.95,106.26 v3(167.95,106.95) ; RV161.1 176.59,121.39 177.35,120.63 v3(177.92,120.63) ; v1(168.08,175.43) 164.71,175.43 163.89,176.25 RV209.1 ; v3(202.06,132.37) 200.82,132.37 198.53,130.09 RV151.1
  TOP w1.016: v3(162.36,74.08) 163.38,75.1 163.38,77.64 159.72,81.29 150.91,81.29 149.67,82.54 145.27,82.54 144.07,83.73 144.07,85.19 v3(143.88,85.38) 143.82,85.45 143.82,89.56 ; v3(145.73,50.46) v3(145.73,49.57) 147.83,49.57 152.15,45.25 160.84,45.25
  IN1 w0.508: 201.15,136.61 201.15,138.06 205.14,142.05 v3(205.92,142.05) ; 201.15,136.61 201.95,135.82 201.95,132.49 v3(202.06,132.37) ; 201.15,136.61 198.29,133.76 198.29,130.96 196.08,128.75 194.45,128.75 192.39,126.68 182.05,126.68 180.35,124.98 180.35,123.23 177.92,120.8 v3(177.92,120.63) 176.21,122.34 176.21,124.5 175.82,124.88 172,124.88 170.69,123.58 170.69,113.55 167.95,110.81 v3(167.95,106.95)
  IN2 w0.508: v3(162.36,74.08) 171,65.44 187.36,65.44 188.19,66.28 195.64,66.28 v3(195.79,66.44) ; v3(38.61,29.48) 38.71,29.57 38.71,34.21 33.79,39.13 33.79,69.64 35.46,71.31 39.96,71.31 41.87,73.22 41.87,75.33 40.7,76.49 v3(40.57,76.49)
  IN3 w0.508: v3(165.28,43.73) 155.89,43.73 150.17,38.01 143.31,38.01 142.7,38.62 v3(142.6,38.62) ; v3(170.59,174.66) 170.49,174.77 v3(170.49,177.48) 170.49,185.54 172.19,187.24 174.33,187.24 177.02,184.55 186.01,184.55 v3(190.48,180.08) ; v3(76.54,123.23) 76.54,124.6 75.52,125.62 v1(71.96,125.62) 70.26,123.92 65.36,123.92 63.68,122.24 61.86,122.24 61.07,121.45 v3(61.07,120.87) 60.28,121.66 56.61,121.66 54.83,119.88 51.16,119.88 50.35,119.06 50.35,118.03 46.46,114.14 44.71,114.14 44.08,113.5 44.08,113 41.43,110.36 41.43,108.99 38.2,105.75 v3(38.03,105.75)
  BOTTOM w0.203: PU401.9 71.56,125.29 71.89,125.62 v1(71.96,125.62)
  BOTTOM w0.508: PR306.1 v3(142.6,38.62) ; R234.1 v3(227.59,127.73) ; v3(76.54,123.23) 76.87,123.23 77.15,123.51 PR402.1 ; v3(201.99,62.14) 201.14,62.14 199.76,63.52 199.76,64.15 197.45,66.46 195.81,66.46 v3(195.79,66.44) ; v1(168.08,175.43) 169.83,175.43 v3(170.59,174.66) ; PR601.2 202.88,152.19 v3(202.27,152.8) 202.27,152.85 202.83,153.41 PR602.2 ; R9486.1 v3(135.87,46.62)
  vias: v3(33.05,23.38) v3(33.33,24.04) v3(33.46,22.77) v3(33.71,23.41) v3(34.17,22.75) v3(34.47,23.41) v3(34.91,22.75) v3(37.12,17.52) v3(37.75,17.21) v3(37.95,17.97) v3(38.41,17.24) v3(38.59,17.97) v3(39.25,17.97) v3(165.28,42.84) v3(165.28,42.08) v3(165.28,41.31) v3(165.28,40.43) v3(165.94,41.31) v3(165.92,40.43) v3(166,43.7) v3(166,42.81) v3(165.97,42.08) v3(166.63,41.31) v3(166.63,40.43) v3(166.68,42.79) v3(166.68,42.05) v3(181.79,27.6) v3(181.92,28.23) v3(182.17,28.87) v3(182.43,27.85) v3(182.68,28.49) v3(182.81,29.12) v3(183.06,27.98) v3(183.32,28.61) v3(183.32,27.34) v3(183.7,26.71) v3(183.83,27.98) v3(184.08,28.61) v3(184.08,27.34) v3(184.44,26.74) v3(184.46,27.98) v3(184.84,27.34) v3(190.48,179.44) v3(208.01,10.28) v3(208.77,9.69) v3(208.77,9.01) v3(208.77,8.37) v3(208.77,7.69) v3(208.77,7.02) v3(208.77,6.39) v3(209.35,9.35) v3(209.38,10.07) v3(209.43,8.68) v3(209.43,7.99) v3(209.43,7.33) v3(209.43,6.69) v3(209.99,10.45) v3(209.99,9.69) v3(210.06,8.32) v3(210.06,7.63) v3(210.06,6.97) v3(210.06,6.34) v3(245.9,178.14) v3(245.9,177.51) v3(245.9,176.75) v3(245.9,176.11) v3(245.9,175.48) v4(160.97,54.24) v4(161.07,64.33) v4(208.18,9.56)
+5VALW_CHGUSB: length 1
  TOP w0.508: D17.5 v3(19.92,21.48)
  vias: v3(31.43,10.17) v3(31.5,10.83) v3(32.11,10.2) v3(32.21,10.89) v3(32.82,10.2) v4(30.87,12.87)
+5VALW_OUT: length 1.7
  BOTTOM w0.254: PR213.1 185.93,8.8 186.49,8.25 PU202.4
+5VALW_P: length 23.7
  IN3 w0.508: v3(206.3,8.93) 205.44,8.93 202.09,12.28 186.49,12.28 v3(185.93,11.72)
  BOTTOM w0.254: v3(185.93,11.72) 185.91,11.7 PR215.2 185.91,10.05 PR213.2
  vias: v4(198.66,4.59)
+5VBS: length 7.9
  TOP w0.381: v3(184.89,7.61) 184.89,7.28 v4(185.68,6.49) 186.11,6.06 PR212.1
+5VFB: length 1.6
  BOTTOM w0.254: PU202.3 186.94,8.97 PC229.1
+5VLP: length 160.8
  TOP w0.508: R157.1 v4(209.18,141.39) 213.01,137.56 v3(213.01,137.35)
  IN1 w0.508: v3(194.32,26.71) 195.13,27.52 195.13,30.72 196.25,31.84 196.25,37.63 199.32,40.71 199.32,47.77 202.62,51.07 204.37,51.07 205.39,52.08 205.9,52.08 207.35,53.53 208.57,53.53 208.84,53.81 208.84,55.84 209.84,56.83 209.84,57.29 207.57,59.55 207.57,64.07 209.07,65.57 209.07,116.46 214.36,121.74 v3(214.36,132.12) 214.36,136.01 v3(213.01,137.35)
  BOTTOM w0.508: v3(194.32,26.71) 193.45,27.57 186.35,27.57 185.38,26.6 185.38,22.7 184.86,22.18 184.86,20.21 185.35,19.72 185.35,17.82 184.21,16.68 184.21,14.59 182.25,12.64 182.25,10.1 182.95,9.4 PC225.1
+5VLX:
  vias: v3(193.12,5.4) v3(193.76,5.4) v4(189.19,6.03)
+5VS: length 261.6
  TOP w0.254: v3(190.17,122.33) JTP.8
  TOP w0.381: JU3LF.18 243.66,176.05 v3(243.43,176.28)
  TOP w0.508: RE5.2 182.28,49.27 v3(181.54,48.53) ; v3(137.32,63.87) 137.67,63.51 137.67,61.61 126.98,50.92 101.88,50.92 97.71,55.08 92.57,55.08 91.07,53.58 72.45,53.58 72.07,53.96 R9485.1 ; R65.1 R63.1 30.23,97.14 v3(29.72,96.64) ; v3(29.6,104.53) 29.6,103.98 28.84,103.21 28.84,102.3 29.27,101.87 29.27,100.24 29.09,100.07 v3(29.09,98.67) 29.42,98.34 RL20.2 ; RV152.1 188.09,126.71 188.5,126.3 v4(192.23,126.3) 193.88,126.3 v3(194.58,127) ; R59.1 182.94,124.45 183.22,124.73 183.22,125.25 183.64,125.67 187.99,125.67 190.17,123.49 v3(190.17,122.33) ; v3(180.88,45.81) 181.54,46.47 RE6.2
  IN1 w0.508: v3(181.54,48.53) 181.54,46.47 v3(180.88,45.81) 180.88,44.77 185.32,40.32 185.32,38.32 187.76,35.88 187.76,34.21 186.11,32.56 v3(186.11,30.39)
  IN2 w0.508: v3(243.43,176.28) 243.39,176.32 241.26,176.32 237.19,172.25 237.19,164.34 230.94,158.09 230.94,151.76 226.87,147.69 225.18,147.69 215.3,137.81 215.3,135.65 207.83,128.18 198.43,128.18
  IN3 w0.508: v3(137.32,63.87) 137.32,61.48 138.61,60.19 142.48,60.19 143.45,59.22 154.56,59.22 156.08,57.7 169.45,57.7 170.29,58.54 173.79,58.54 179.89,52.44 179.89,50.18 v3(181.54,48.53)
  BOTTOM w0.508: v3(29.09,98.67) 29.09,97.27 v3(29.72,96.64)
  vias: v3(12.31,101.69) v3(12.3,101) v3(18.52,67.63) v3(18.95,68.1) v3(19.17,67.48) v3(58.76,126.28) v3(59.04,126.89) v3(59.42,126.25) v3(59.72,126.86) v3(95.61,143.45) v3(95.81,144.08) v3(96.45,144.06) v3(96.6,143.42) v3(185.22,29.5) v3(185.48,30.77) v3(185.48,30.14) v3(185.73,29) v3(185.86,29.63) v3(186.24,28.61) v3(186.37,29.25) v3(186.49,29.88) v3(186.75,30.65) v3(187,29.5) v3(187.13,30.14) v3(187.64,29.76) v3(187.76,30.39) v3(188.27,30.01) v3(188.4,30.65) v3(191.57,21.45) v3(191.57,20.82) v3(191.57,20.18) v3(191.57,19.55) v3(192.18,21.68) v3(192.18,21.05) v3(192.18,20.41) v3(192.18,19.78) v3(192.18,19.12) v3(194.6,127.67) v3(195.93,127.67) v3(195.93,127.02) v3(197.37,127.65) v3(197.41,127.02) v3(212.73,10.56) v3(212.78,11.24) v3(213.42,11.24) v3(213.39,10.53) v3(214.05,11.24) v3(214.08,10.53) v3(214.69,11.24) v3(219.03,49.93) v3(219.03,49.21) v3(219.06,50.58) v3(219.7,50.56) v3(219.72,49.93) v3(219.72,49.19) v3(222.31,106.16) v3(222.48,105.5) v3(222.84,106.67) v3(222.94,105.98) v3(223.45,106.47) v3(223.86,106.97)
+5VS_AVDD: length 7.7
  TOP w0.203: UA1.28 210.18,17.4
  TOP w0.254: 210.18,17.4 210.72,16.85
  TOP w0.381: CA15.1 212.65,14.59 v2(212.65,15.43) 212.22,15.86 211.72,15.86 210.72,16.85
  TOP w0.508: CA15.1 214.45,13.86 RA32.1
+5VS_CLASSD: length 9.9
  TOP w0.203: UA1.13 205.89,21.79 205.23,22.46 v2(205.23,22.86) 204.93,23.15 204.48,23.15 203.97,23.66 ; UA1.16 205.44,20.59 205.26,20.77 203.74,20.77 203.46,20.49 CA4.1
  TOP w0.254: v3(204.15,20.23) 203.51,20.23 CA4.1 ; v3(204.78,23.66) 203.97,23.66 CA5.1
  TOP w0.508: CA16.1 203.05,26.28 v3(203.41,26.63)
  vias: v3(195.64,23.03) v3(195.64,22.39) v3(195.64,21.76) v3(196.27,23.03) v3(196.27,22.39) v3(196.27,21.76) v3(197.03,23.03) v3(197.03,22.39)
+5VS_CMOS: length 2.3
  TOP w0.254: 87.53,130.24 JLCD.39 ; JLCD.40 88.04,129.17 87.18,130.04
  vias: v3(84.23,131.87) v3(97.54,137.48) v3(97.75,136.87) v3(97.9,136.16)
+5VS_HDMI: length 7.4
  TOP w0.254: v3(15.18,86.02) UT3.5
  TOP w0.356: UT4.5 18.43,91.97 18.68,91.73 CT31.2
  TOP w0.508: CT31.2 19.11,90.84 v3(19.36,91.1) ; DT2.5 10.77,90.84 v3(9.63,90.84) ; DT1.5 11.69,84.24 v3(11.31,83.86) ; RT14.1 v3(13.75,92.95)
  BOTTOM w0.508: v3(11.64,89.55) 11.79,89.4 RT13.1
  vias: v3(13.72,93.72) v3(14.08,94.32) v3(14.43,93.72) v3(16.54,69.09) v3(17.2,69.1) v3(17.23,68.47) v5(16.57,68.44)
+5VS_HDMI_F: length 11.6
  BOTTOM w0.508: Q22.3 13.67,97.7 16.21,97.7 D5.1 18.24,98.16 18.24,95.37 F2.1 18.52,95.09 v2(19.72,95.09)
+5VS_LS:
  vias: v4(187.45,26.84)
+5VS_ODD:
  vias: v4(225.28,46.27)
+AVEE: length 3.2
  TOP w0.114: CA18.1 205.81,16.74 v2(206,16.93) 206.64,17.57 207.18,17.57 207.37,17.76 UA1.21
+DV33_18: length 3.1
  TOP w0.203: UW1.18 49.09,28.15
  TOP w0.508: 49.09,28.15 48.62,27.68 v2(48.62,27.57) 48.62,27.37 49.1,26.89 CW3.1
+V1.00AP: length 34.3
  IN1 w0.381: v3(143.36,48.15) 144.15,47.36 146.23,47.36 146.77,47.89 146.77,61.61 146.26,62.12 140.16,62.12 136.23,66.05 v3(133.15,66.05)
  BOTTOM w0.203: PU701.22 143.01,48.5 v3(143.36,48.15)
  vias: v2(133.81,66.08)
+VCC_AMPHYPLL: length 32.6
  IN1 w0.381: v3(101.9,99.11) 102.18,99.39 106.13,99.39 107.11,100.37 107.89,100.37 109.54,102.02 109.54,102.41 110.04,102.91 110.39,102.91 111.1,102.2 114.16,102.2 114.73,102.78 116.5,102.78 117.81,101.46 121.29,101.46 121.47,101.64 122.37,101.64 v3(122.7,101.97)
  BOTTOM w0.254: UC1.L15 v3(101.9,99.11) UC1.K15
  BOTTOM w0.508: v3(122.7,101.97) 122.7,101.83 123.15,101.39 123.4,101.39 v2(124.99,99.8) 126.87,97.92 CC46.1 126.27,97.46 LC1.2
+VCC_CORE: length 115.1
  TOP w0.076: 88.28,91.26 88.28,91.33
  TOP w0.254: 85.32,103.52 85.24,103.61 CC200.1 ; 85.27,104.48 85.24,104.45 CC200.1 ; v3(132.8,108.47) 133.23,108.9 133.23,114.21 133.89,114.87 v3(133.89,115.36) ; CC200.1 85.63,104.03 85.68,103.98 ; v3(81.92,91.07) CC170.1 ; 90.21,100.33 CC179.1 ; CC179.1 89.86,100.67 ; CC179.1 90.21,101.02 ; CC202.1 81.57,90.01 v3(81.92,90.36) ; CC191.1 89.55,98.88 89.52,98.92 ; CC190.1 86.4,104.35 ; CC190.1 86.4,103.66 ; CC190.1 86.05,104 ; CC173.1 87,105.54 ; CC173.1 87.34,105.18 ; CC173.1 86.66,105.18 ; CC206.1 87.82,92.25 87.81,92.24 ; CC206.1 88.29,91.61 CC142.1 ; CC206.1 88.28,92.26 CC178.1 ; v3(81.92,90.36) 82.18,90.11 CC171.1 ; v3(81.92,90.36) 81.79,90.49 CC194.1 ; 90.58,93.22 CC196.1 91.12,92.88 v3(91.14,92.85) ; CC204.1 84.21,90.54 v3(84.31,90.44) ; 92.32,102.36 CC197.1 91.64,102.36 ; 90.44,105.63 CC208.1 90.1,105.22 90.15,105.17 ; CC224.1 90.6,90.9 CC172.1 90.95,91.61 ; CC201.1 116.9,111.16 v3(116.96,111.1) ; CC142.1 87.84,91.61 ; CC142.1 88.28,91.33 ; CC198.1 84.33,90.41 v3(84.31,90.44) ; CC174.1 88.31,100.62 ; CC174.1 87.95,100.97 ; CC174.1 87.95,100.28 ; 87.81,92.83 87.86,92.88 CC178.1 ; CC175.1 87.53,91.49 ; v3(84.31,90.44) 84.31,90.35 CC209.1 ; 91.45,100.7 91.47,100.67 CC193.1 91.87,101.12 v3(91.94,101.2) ; CC205.1 91.98,104.98 ; CC205.1 91.64,104.62 ; CC205.1 92.32,104.62 ; CC176.1 84.38,91 v3(84.31,91.07) 84.28,91.1 CC145.1 ; CC207.1 91.71,92.41 ; CC207.1 91.36,92.06 ; CC207.1 91.71,91.72 ; v3(91.01,88.43) 90.99,88.46 90.25,88.46 90.11,88.31 ; CC178.1 88.28,93.66 PC476.2 ; v3(87.05,105.7) 87.02,105.67 ; CC199.1 84.26,91.66 v3(84.31,91.71) 84.46,91.56 CC143.1 84.89,91.99 ; 87.18,90.55 CC195.1 87.81,90.9 v3(87.89,90.82) ; 91.37,100.22 91.47,100.12 CC203.1 91.87,99.65 v3(91.95,99.56) ; CC177.1 91.01,92.24 ; CC144.1 v3(116.26,111.1)
  TOP w0.305: PC467.2 88.88,98.07 CC192.1 88.88,98.92 v3(88.7,99.1) ; CC208.1 89.57,105.63 v3(89.49,105.55) ; CC197.1 91.98,102.01
  IN2 w0.254: v3(133.89,115.36) 133.89,115.74 131.9,117.73 130.23,117.73 129.89,117.39 125.72,117.39 125.38,117.73 119.28,117.73 118.03,118.99 113.14,118.99 112.26,119.86 109.87,119.86 107.69,117.68 100.32,117.68 100.09,117.45 96.86,117.45 95.59,116.18 81.67,116.18 79.79,114.3 78.44,114.3 78.05,113.91 74.02,113.91 73.67,114.26 v3(73.67,114.64)
  VCC w0.102: 99.02,98.69 99.57,98.69 ; 100.97,98.69 101.56,98.69
  BOTTOM w0.203: v3(87.05,105.7) 87.01,105.66 UC1.A39 ; v3(93.27,105.45) 92.39,105.45 91.97,105.03 UC1.A30 ; UC1.A34 v3(89.49,105.55) ; UC1.A44 v3(84.53,105.55)
  BOTTOM w0.254: PR452.1 73.69,114.67 v3(73.67,114.64) ; PL403.2 132.21,107.89 v3(132.8,108.47)
  BOTTOM w0.305: 86.44,101.2 v3(86.45,101.2)
  vias: v1(87.43,108.88) v1(87.61,112.63) v1(88.25,112.63) v1(88.88,112.63) v1(89.34,108.88) v1(89.52,112.63) v1(90.15,112.63) v1(90.79,112.63) v1(99.37,105.77) v3(81.11,98.34) v3(81.11,97.07) v3(81.11,95.8) v3(81.12,94.5) v3(81.12,93.23) v3(81.12,91.96) v3(84.89,97.6) v3(84.89,96.26) v3(84.89,95.04) v3(84.89,93.77) v3(84.89,92.52) v3(85.99,99.23) v3(86.29,97.55) v3(86.29,96.2) v3(86.29,94.99) v3(86.29,93.72) v3(86.29,92.47) v3(86.44,101.89) v3(86.45,99.79) v3(86.82,99.28) v3(87.18,112.18) v3(87.18,111.55) v3(87.18,110.85) v3(87.18,110.15) v3(87.24,106.4) v3(87.5,108.24) v3(87.5,107.61) v3(87.5,106.97) v3(87.81,112.05) v3(87.81,111.42) v3(87.81,110.78) v3(87.81,110.15) v3(87.81,109.51) v3(87.75,105.7) v3(87.85,99.16) v3(87.88,106.34) v3(88.07,108.88) v3(88.13,108.24) v3(88.13,107.61) v3(88.13,106.97) v3(88.14,90.18) v3(88.26,104.81) v3(88.29,101.2) v3(88.28,99.79) v3(88.45,112.05) v3(88.45,111.42) v3(88.45,110.78) v3(88.45,110.15) v3(88.45,109.51) v3(88.45,105.51) v3(88.51,106.15) v3(88.5,90.9) v3(88.7,108.88) v3(88.83,108.24) v3(88.83,107.61) v3(88.83,106.97) v3(88.8,90.34) v3(89.08,112.05) v3(89.08,111.42) v3(89.08,110.78) v3(89.08,110.15) v3(89.15,109.51) v3(89.08,97.55) v3(89.08,96.33) v3(89.08,95.01) v3(89.08,93.77) v3(89.11,90.92) v3(89.24,99.63) v3(89.19,88.31) v3(89.44,90.29) v3(89.78,112.05) v3(89.78,111.42) v3(89.78,110.78) v3(89.78,110.15) v3(89.85,109.51) v3(89.97,99.13) v3(90.1,101.84) v3(90.11,101.2) v3(90.11,99.79) v3(90.13,90.87) v3(90.13,90.18) v3(90.48,112.05) v3(90.48,111.42) v3(90.48,110.78) v3(90.48,110.15) v3(90.48,109.51) v3(91.18,112.05) v3(91.18,111.42) v3(91.18,110.78) v3(91.18,110.15) v3(91.18,109.51) v3(92.08,98.57) v3(92.08,97.5) v3(92.08,96.28) v3(92.08,94.91) v3(92.08,93.72) v3(101.96,109.97) v3(104.88,107.2) v3(105.92,108.22) v3(106.05,114.04) v3(106.66,106.01) v3(107.14,106.47) v3(107.6,113.98) v3(107.73,106.92) v3(108.26,107.46) v3(108.69,106.92) v3(109.12,110.02) v3(109.18,107.46) v3(111.44,105.48) v3(112.1,105.48) v3(122.99,112.31) v3(122.99,111.67) v3(123.63,112.31) v3(123.63,111.67) v3(124.26,112.31) v3(124.26,111.67) v3(124.26,108.18) v3(124.9,112.31) v3(124.9,111.67) v3(124.96,108.18) v3(124.96,107.55) v3(125.53,112.31) v3(125.53,111.67) v3(125.6,108.18) v3(125.6,107.55) v3(125.6,106.91) v3(125.6,106.21) v3(126.17,112.31) v3(126.17,111.67) v3(126.23,108.18) v3(126.23,107.55) v3(126.23,106.91) v3(126.23,106.28) v3(126.23,105.64) v3(126.8,112.31) v3(126.8,111.67) v3(126.8,111.04) v3(126.8,110.4) v3(126.8,109.77) v3(126.8,109.13) v3(126.8,108.5) v3(126.8,107.86) v3(126.8,107.23) v3(126.8,106.59) v3(126.8,105.96) v3(126.8,105.32) v3(127.44,112.31) v3(127.44,111.67) v3(127.44,111.04) v3(127.44,110.4) v3(127.44,109.77) v3(127.44,109.13) v3(127.44,108.5) v3(127.44,107.86) v3(127.44,107.23) v3(127.44,106.59) v3(127.44,105.96) v3(127.44,105.32) v3(128.01,108.82) v3(128.01,108.18) v3(128.01,107.55) v3(128.01,106.91) v3(128.01,106.28) v3(128.01,105.64) v3(128.01,104.94) v3(128.07,112.31) v3(128.07,111.67) v3(128.07,111.04) v3(128.07,110.4) v3(128.07,109.77) v3(128.58,105.96) v3(128.58,105.26) v3(128.71,112.31) v3(128.71,111.67) v3(128.71,111.04) v3(128.71,110.4) v3(128.71,109.77) v4(86.8,107.8)
+VCC_DSW3P3: length 14.7
  TOP w0.508: v1(106.17,79.92) 110.99,79.92 114.52,76.39 RC127.2 RC132.2
  IN3 w0.203: v3(99.93,89.89) 99.3,89.89 98.8,89.38 98.61,89.38
  BOTTOM w0.254: UC1.AD18 99.88,92.48 v3(99.95,92.4) UC1.AD17 ; UC1.AJ17 v3(99.93,89.89)
+VCC_FAN1:
  vias: v2(60.48,118.89)
+VCC_GT: length 215.3
  TOP w0.203: CC152.1 54.79,92.36 ; CC152.1 55.14,92.71 ; CC152.1 54.45,92.71 ; CC156.1 53.43,98.81 ; CC156.1 53.78,98.45 ; CC156.1 54.12,98.81 ; 54.24,96.1 54.22,96.09 CC154.1 ; CC154.1 53.36,96.09 53.32,96.13 ; CC154.1 53.78,96.45
  TOP w0.254: CC159.1 73.65,94.4 v3(73.32,94.74) ; CC159.1 73.84,94.76 ; CC159.1 74.19,94.4 ; CC149.1 73.58,96.92 ; CC150.1 77.85,98.57 ; CC150.1 78.17,98.91 ; CC150.1 CC160.1 ; CC160.1 77.76,97.96 ; CC160.1 78.17,97.61 ; CC153.1 72.61,94.88 72.6,94.88 ; CC155.1 73.02,92.76 ; CC155.1 73.7,92.76 ; CC155.1 73.36,93.12 ; v3(73.24,95.6) 72.96,95.88 CC157.1 ; CC148.1 71.96,97.84 ; CC148.1 72.64,97.84 ; CC148.1 72.3,98.04 v3(72.65,98.39) ; CC146.1 77.84,95.57 ; 77.65,91.02 CC147.1 ; 77.65,90.44 CC161.1 ; CC151.1 77.79,96.18 ; v3(61.24,110.33) 61.17,110.4 RC125.1 ; 72,94.85 CC158.1
  IN2 w0.102: 70.69,99.19 70.35,99.19
  IN2 w0.254: v3(46.44,72.2) 46.44,73.27 41.41,78.3 41.41,92.06 47.3,97.96 47.3,98.78 51.81,103.29 51.81,106.47 53.08,107.74 54.67,107.74 57.27,110.34 57.91,110.34 61.19,113.63 61.19,119.32 61.86,119.98 63.23,119.98 63.96,120.72 63.96,122.52 62.64,123.84 62.64,125.28 63.99,126.63 71.33,126.63 74.15,129.45 v3(74.15,130.32)
  BOTTOM w0.203: 75.03,98.67 UC1.M62 75.03,98.05 ; UC1.W63 74.63,95.16 ; UC1.W63 73.95,94.85 ; UC1.W63 74.26,94.82 ; UC1.J48 81.88,99.79 81.87,99.79 ; UC1.J48 82.34,100.02 ; UC1.J48 UC1.J50 ; UC1.J48 UC1.J46 ; UC1.J48 81.42,100.02 ; 73.91,93.03 UC1.AC64 73.3,93.03 ; 70.66,98.51 UC1.L69 70.05,98.51 ; UC1.N64 73.91,98.21 ; UC1.N64 73.3,98.21 ; UC1.N64 73.78,97.73 74.08,97.73 UC1.N63 ; UC1.U65 73.26,96.38 ; UC1.U65 72.65,96.38 ; UC1.U65 72.65,95.77 ; UC1.U65 73.26,95.77 ; 73.95,98.51 UC1.L63 ; UC1.L63 74.61,98.82 ; UC1.L63 74.26,98.47 ; 82.34,100.02 UC1.J46 ; 82.34,100.02 UC1.K48 ; UC1.R67 71.96,97.3 ; UC1.R67 71.35,96.68 ; UC1.R67 71.96,96.68 ; 72.65,96.68 UC1.R65 ; UC1.R65 72.65,97.3 ; UC1.R65 73.26,96.68 ; UC1.J55 78.68,100.02 ; UC1.J55 v3(78.22,99.74) ; UC1.J55 77.76,100.02 ; UC1.J55 UC1.J56 ; UC1.J55 UC1.J53 ; 78.68,100.02 UC1.K55 ; 78.68,100.02 UC1.J53 ; 68.75,94.55 UC1.AA71 ; UC1.AA71 69.36,94.55 ; UC1.AA71 68.75,93.94 ; UC1.AA71 69.36,93.94 ; UC1.U68 71.31,96.38 ; UC1.U68 71.31,95.77 ; UC1.U68 70.7,95.77 ; UC1.U68 70.7,96.38 ; 73.95,98.21 UC1.N63 ; UC1.N63 74.26,98.25 ; UC1.N63 74.68,97.91 ; 71.35,93.03 UC1.AC67 ; UC1.AC67 71.96,93.03 ; UC1.AC67 71.96,93.64 ; UC1.J56 77.76,100.02 ; UC1.J56 v3(77.31,99.74) ; UC1.J56 UC1.J58 ; UC1.J56 76.85,100.02 ; 77.76,100.02 UC1.K56 ; UC1.R71 69.36,96.68 ; UC1.R71 68.75,96.68 ; UC1.R71 69.36,97.3 ; UC1.R71 68.75,97.3 ; 72,93.03 UC1.AC66 ; UC1.AC66 72,93.64 ; UC1.AC66 72.61,93.64 ; UC1.AC66 72.61,93.03 ; UC1.AC68 71.31,93.03 ; UC1.AC68 70.7,93.03 ; UC1.AC68 70.7,93.64 ; 70.7,98.51 UC1.L68 71.31,98.51 ; 82.78,99.81 82.79,99.82 UC1.J46 ; UC1.AC70 70.01,93.64 ; UC1.AC70 69.4,93.03 ; UC1.AC70 69.4,93.64 ; UC1.AC70 70.01,93.03 ; 69.4,98.51 UC1.L70 70.01,98.51 ; 68.75,93.03 UC1.AC71 ; UC1.AC71 68.75,93.64 ; UC1.AC71 69.36,93.03 ; UC1.AC71 69.36,93.64 ; 75.63,99.71 UC1.K60 ; UC1.K60 76.24,99.71 ; UC1.K60 75.93,100.02 ; v3(76.38,99.68) 76.39,99.69 UC1.J58 ; 70.05,98.21 UC1.N69 ; UC1.N69 70.05,97.6 ; UC1.N69 70.66,98.21 ; UC1.N69 70.66,97.6 ; UC1.R66 72.61,96.68 ; UC1.R66 72.61,97.3 ; UC1.R66 72,96.68 ; UC1.R66 72,97.3 ; UC1.R68 71.31,96.68 ; UC1.R68 70.7,97.3 ; UC1.R68 70.7,96.68 ; UC1.T62 75.03,96.23 ; UC1.T62 75.03,96.84 ; UC1.T62 74.28,96.53 ; 70.7,95.47 UC1.W68 ; UC1.W68 70.7,94.85 ; UC1.W68 71.31,95.47 ; UC1.W68 71.31,94.85 ; UC1.K48 82.64,99.71 ; UC1.K48 82.03,99.71 ; 69.4,96.68 UC1.R70 ; UC1.R70 70.01,97.3 ; UC1.R70 70.01,96.68 ; UC1.R70 69.4,97.3 ; UC1.W65 73.26,95.47 ; UC1.W65 73.26,94.85 ; UC1.W65 72.65,94.85 ; UC1.W65 72.65,95.47 ; 70.05,94.85 UC1.W69 ; UC1.W69 70.66,94.85 ; UC1.W69 70.66,95.47 ; 80.51,100.02 UC1.K52 ; 80.51,100.02 UC1.J52 ; 80.51,100.02 UC1.J50 ; UC1.K52 80.81,99.71 ; UC1.K52 80.2,99.71 ; UC1.U71 69.36,95.77 ; UC1.U71 68.75,95.77 ; UC1.U71 68.75,96.38 ; UC1.U71 69.36,96.38 ; 75.03,99.58 UC1.L62 75.03,98.97 ; UC1.K56 78.07,99.71 ; UC1.K56 77.46,99.71 ; UC1.AA67 71.96,94.55 ; UC1.AA67 71.96,93.94 ; UC1.AA67 71.35,94.55 ; UC1.R63 74.66,96.99 ; UC1.R63 74.26,96.65 ; UC1.R63 73.95,96.68 ; 74.26,94.59 UC1.AA63 73.95,94.55 ; 71.35,94.85 UC1.W67 ; UC1.W67 71.96,94.85 ; UC1.W67 71.35,95.47 ; UC1.J50 81.42,100.02 ; UC1.J50 80.96,99.74 v3(80.96,99.74) ; UC1.J50 UC1.J52 ; UC1.AA70 70.01,94.55 ; UC1.AA70 69.4,93.94 ; UC1.AA70 70.01,93.94 ; UC1.AA70 69.4,94.55 ; UC1.A48 82.06,105.6 v3(82.11,105.65) ; 69.4,97.6 UC1.N70 ; UC1.N70 69.4,98.21 ; UC1.N70 70.01,98.21 ; UC1.N70 70.01,97.6 ; 70.05,96.68 UC1.R69 ; UC1.R69 70.66,97.3 ; UC1.R69 70.66,96.68 ; UC1.R69 70.05,97.3 ; UC1.J58 75.93,100.02 ; UC1.J58 UC1.J60 ; UC1.J58 76.85,100.02 ; UC1.W70 70.01,94.85 ; UC1.W70 69.4,94.85 ; UC1.W70 69.4,95.47 ; 72,97.6 UC1.N66 ; UC1.N66 72.61,97.6 ; UC1.N66 72.61,98.21 ; UC1.N66 72,98.21 ; UC1.A66 v3(72.14,105.65) ; 73.3,94.85 UC1.W64 ; UC1.W64 73.3,95.47 ; UC1.W64 73.91,94.85 ; 72.61,98.51 UC1.L66 72,98.51 ; 75.93,100.02 UC1.J60 ; 73.91,96.68 UC1.R64 73.3,96.68 ; 68.75,98.51 UC1.L71 69.36,98.51 ; UC1.N71 69.36,98.21 ; UC1.N71 69.36,97.6 ; UC1.N71 68.75,97.6 ; UC1.N71 68.75,98.21 ; UC1.AC69 70.66,93.03 ; UC1.AC69 70.66,93.64 ; UC1.AC69 70.05,93.64 ; UC1.AC69 70.05,93.03 ; 71.35,98.51 UC1.L67 71.96,98.51 ; 72,93.94 UC1.AA66 ; UC1.AA66 72,94.55 ; UC1.AA66 72.61,93.94 ; UC1.AA66 72.61,94.55 ; 81.11,99.71 UC1.K50 ; UC1.K50 81.73,99.71 ; UC1.K50 81.42,100.02 ; 84.59,100.04 UC1.J43 UC1.J45 83.72,100.07 ; UC1.K53 79.9,99.71 ; UC1.K53 79.29,99.71 ; UC1.K53 79.59,100.02 ; 78.37,99.71 UC1.K55 ; UC1.K55 78.98,99.71 ; 68.75,95.47 UC1.W71 ; UC1.W71 69.36,94.85 ; UC1.W71 68.75,94.85 ; UC1.W71 69.36,95.47 ; UC1.K58 77.16,99.71 ; UC1.K58 76.54,99.71 ; UC1.K58 76.85,100.02 ; UC1.N67 71.96,98.21 ; UC1.N67 71.35,98.21 ; UC1.N67 71.96,97.6 ; UC1.J53 79.13,99.77 v3(79.11,99.74) ; UC1.J53 UC1.J52 ; UC1.J53 79.59,100.02 ; 72.65,93.64 UC1.AC65 ; UC1.AC65 72.65,93.03 ; UC1.AC65 73.26,93.03 ; UC1.A58 v3(77.1,105.65) ; 73.3,98.51 UC1.L64 73.91,98.51 ; UC1.Y62 75.03,95.01 ; UC1.Y62 74.33,94.71 ; UC1.Y62 74.73,95.05 ; UC1.W66 72.61,95.47 ; UC1.W66 72.61,94.85 ; UC1.W66 72,94.85 ; 79.59,100.02 UC1.J52 ; UC1.J60 75.48,99.72 v3(75.48,99.72) ; 70.05,94.55 UC1.AA69 ; UC1.AA69 70.66,93.94 ; UC1.AA69 70.66,94.55 ; UC1.AA69 70.05,93.94 ; UC1.J52 80.04,100.14 80.04,99.72 v3(80.02,99.7) ; 73.26,98.51 UC1.L65 72.65,98.51 ; 73.91,94.55 UC1.AA64 73.3,94.55 ; UC1.A53 v3(79.58,105.65) ; UC1.A62 v3(74.62,105.65)
  BOTTOM w0.254: PL406.2 46.13,72.51 v3(46.44,72.2) ; PR456.1 72.78,130.29 73.29,130.8 73.77,130.8 74.15,130.42 v3(74.15,130.32)
  vias: v3(44.25,83.1) v3(44.25,82.34) v3(44.38,78.53) v3(44.76,78.02) v3(44.89,83.48) v3(44.89,82.72) v3(45.27,78.53) v3(45.52,84.85) v3(45.52,83.83) v3(45.52,83.1) v3(45.52,82.34) v3(45.65,78.02) v3(46.18,84.19) v3(46.16,83.48) v3(46.16,82.72) v3(46.16,78.53) v3(46.54,78.02) v3(46.92,84.7) v3(46.92,83.81) v3(46.92,83.1) v3(46.92,82.34) v3(46.92,81.57) v3(46.92,80.81) v3(46.92,80.05) v3(46.92,79.29) v3(46.92,78.53) v3(47.55,83.48) v3(47.55,82.72) v3(47.55,81.95) v3(47.55,81.19) v3(47.55,80.43) v3(47.55,79.67) v3(47.55,78.91) v3(47.55,78.02) v3(48.06,78.53) v3(48.19,83.86) v3(48.19,83.1) v3(48.19,82.34) v3(48.19,81.57) v3(48.19,80.81) v3(48.19,80.05) v3(48.19,79.29) v3(48.7,78.14) v3(48.82,83.48) v3(48.82,82.72) v3(48.82,81.95) v3(48.82,81.19) v3(48.82,80.43) v3(48.82,79.67) v3(48.82,78.91) v3(49.46,83.12) v3(49.46,82.36) v3(49.46,81.57) v3(49.46,80.68) v3(49.46,79.95) v3(49.46,78.93) v3(49.51,78.17) v3(53.04,91.81) v3(53.04,91.1) v3(53.07,93.89) v3(53.07,93.21) v3(53.07,92.5) v3(53.6,97.7) v3(53.78,93.89) v3(53.8,93.21) v3(53.8,92.5) v3(53.78,91.81) v3(53.78,91.1) v3(54.29,97.7) v3(54.95,97.7) v3(55.58,97.7) v3(56.24,97.7) v3(56.9,97.68) v3(57.61,97.68) v3(58.27,97.68) v3(58.93,97.65) v3(59.62,97.65) v3(60.28,97.65) v3(60.92,97.65) v3(61.55,97.65) v3(62.19,97.65) v3(62.82,97.65) v3(63.48,97.63) v3(64.12,97.63) v3(66.23,96.24) v3(66.21,94.99) v3(67.09,96.82) v3(67.09,95.7) v3(67.09,94.59) v3(67.93,97.46) v3(67.91,96.24) v3(67.93,95.14) v3(67.93,94.1) v3(69.32,95.64) v3(69.38,98.42) v3(69.35,97.46) v3(69.37,96.56) v3(69.41,94.74) v3(69.41,93.8) v3(70.02,98.4) v3(69.96,97.43) v3(70.12,94.71) v3(70.63,93.76) v3(70.65,97.43) v3(70.68,96.54) v3(71.33,98.36) v3(71.3,95.62) v3(71.3,94.71) v3(71.95,96.54) v3(73.24,96.54) v3(75.88,99.25) v3(76.87,99.28) v3(76.87,98.21) v3(76.87,97.02) v3(76.87,95.8) v3(76.87,94.55) v3(76.87,93.28) v3(77.76,99.21) v3(78.68,99.23)
+VCC_HDA: length 22.2
  TOP w0.114: v4(97.82,70.14) 97.82,70.8 RC330.2
  TOP w0.127: v3(98.63,89.89) 98.6,89.89 97.85,89.13 97.85,84.61 CC274.1
  TOP w0.254: CC99.1 RC299.2 ; CC99.1 RC330.2 ; CC99.1 98.18,79.08 97.85,79.41 97.85,82.59 98.35,83.1 CC274.1
  BOTTOM w0.254: UC1.AJ19 v3(98.63,89.89)
+VCC_IO: length 115.7
  TOP w0.076: 87.01,87.89 87.01,88.01
  TOP w0.254: CC107.1 86.29,88.47 v3(86.45,88.31) ; CC107.1 86.29,89.47 CC109.1 ; CC107.1 85.88,88.94 ; 85.68,89.5 85.86,89.68 CC109.1 ; RC344.1 81.03,105.91 v3(80.4,106.54) ; CC109.1 CC108.1 ; 86.85,88.05 87.01,87.89 CC106.1 87.01,87.4 86.9,87.29 ; RC297.2 v3(104.83,68.49)
  TOP w0.508: RC104.1 67.82,109.13 v3(67.98,108.98) ; v1(66.67,113.07) 65.88,112.28 R9490.1
  IN1 w0.508: v3(80.4,106.54) 80.2,106.35 78.43,106.35 75.46,109.32 73.53,109.32 73.11,108.9 68.05,108.9 v3(67.98,108.98)
  IN2 w0.203: v3(80.4,106.54) 79.7,106.54 79.11,105.96 79.11,103.23 79.57,102.78 79.57,101.02 79.56,101.01 79.56,99.48 80.13,98.91 80.13,89.57 80.7,89 84.84,89 v3(85.54,88.31)
  IN2 w0.508: v1(66.67,113.07) 66.67,111.67 67.98,110.36 v3(67.98,108.98)
  IN3 w0.203: v3(80.4,106.54) 80.8,106.54 81.06,106.29 81.06,105.17 82.56,103.67 82.56,103.06 82.35,102.86 82.35,101.05 82.36,101.05 82.36,101.03 83.01,100.37
  IN3 w0.254: 83.01,100.37 83.37,100.01 84.77,100.01 85.02,99.76 85.02,98.85 84.41,98.24 82.07,98.24 81.72,97.88 79.05,97.88 78.52,97.35 78.52,89.68 79.36,88.84 85.92,88.84 v3(86.45,88.31)
  BOTTOM w0.203: v3(92.85,90.06) UC1.AK30 ; v3(92.85,90.06) UC1.AL30 ; v3(92.85,90.06) UC1.AK28 ; UC1.AL30 v3(92.85,88.31) ; UC1.AL30 92.39,88.72 UC1.AM30 ; v3(85.54,88.31) 85.93,88.7 UC1.AM42 86.06,88.7 v3(86.45,88.31) UC1.AL42
  BOTTOM w0.254: UC1.AM30 v3(91.94,88.31) ; v3(92.85,88.31) UC1.AM28
  BOTTOM w0.381: v3(104.83,68.49) 100.89,72.43 86.92,72.43 v3(85.78,73.57)
  BOTTOM w0.508: v3(67.98,108.98) 67.98,110.02 67.75,110.25 RC105.1
  vias: v4(84.77,82.79)
+VCC_IO_AP:
  vias: v4(67.47,63.34)
+VCC_IO_AP_GATE: length 67.1
  TOP w0.305: v3(129.47,46.9) 129.6,47.03 129.6,49.39 128.61,50.38 101.66,50.38 97.49,54.55 93.1,54.55 v4(92.92,54.37) 91.6,53.05 R9485.2 R9487.1
  BOTTOM w0.254: Q24.3 130.52,45.85 v3(129.47,46.9)
+VCC_MPHYGT: length 6
  BOTTOM w0.254: UC1.P15 101.25,97.32 v3(101.25,97.43) ; UC1.T20 v3(98.63,95.75) UC1.T19 v3(99.28,95.75) ; UC1.N15 101.9,97.51 v3(101.9,97.43) ; v3(101.23,98.27) 101.23,98.18 UC1.N16 ; UC1.N17 100.6,97.51 v3(100.6,97.43) 100.6,97.32 UC1.P16 ; UC1.AF21 v3(97.98,92.4) UC1.AF20 ; UC1.N18 99.93,97.53 v3(99.93,97.43)
  vias: v3(114.94,101.28) v3(115.45,101.72) v3(115.58,101.11) v3(116.13,101.74) v3(116.19,101.13) v3(123.37,98.66) v3(123.69,98.08) v3(124.07,98.66) v3(124.45,98.08) v3(124.77,98.66) v3(126.9,76.11) v3(127.51,80.68) v3(128.05,76.19) v3(128.05,75.55) v3(128.71,76.09) v3(128.68,75.43) v4(102.16,102.48)
+VCC_SA: length 184.5
  TOP w0.076: 95.5,97.61 95.5,97.69
  TOP w0.254: 95.78,92.18 CC251.1 ; CC251.1 95.42,92.52 ; CC251.1 95.78,92.86 ; CC249.1 95.54,90.46 v3(95.41,90.59) ; CC253.1 95.08,96.23 ; RC375.1 102.98,116.6 102.98,119.08 v1(103.13,119.23) ; CC250.1 94.53,92.17 ; CC250.1 94.18,92.46 v3(94.44,92.72) ; CC250.1 94.18,91.75 v3(94.44,91.48) ; PR460.1 65.41,117.39 v3(65.56,117.24) ; 95.41,97.7 95.5,97.61 CC255.1 94.98,97.35 v3(94.88,97.25) ; CC245.1 95.5,95.26 CC252.1 95,95.67 v3(94.98,95.65) ; CC254.1 95.08,96.79
  IN2 w0.254: v3(65.56,117.24) 65.12,117.24 64.57,116.69 64.57,115.67 64.85,115.4 65.25,115.4 65.61,115.76 76.39,115.76 76.97,116.34 79.79,116.34 81.03,117.58 84.8,117.58 86,118.78 87.31,118.78 88.26,117.83 95.21,117.83 96.55,119.17 103.07,119.17 v1(103.13,119.23) 103.86,119.23 104.8,120.17 107.93,120.17 109.02,121.26 117.44,121.26 118.05,120.65 131.24,120.65 135.43,116.46 150.94,116.46 153.47,113.93 153.47,110.21 156.81,106.88 156.81,104.08 156.46,103.74 156.46,97.39 154.36,95.29 v1(154.36,93.38)
  VCC w0.102: 100.26,97.86 101.58,97.86 ; 99.52,97.86 98.33,97.86
  IN3 w0.254: v1(134.98,80.94) 134.8,81.12 134.8,83.67 138.68,87.54 140.46,87.54 142.11,85.89 148.52,85.89 150.83,88.2 152.84,88.2 155.25,90.62 155.25,92.2 154.43,93.02 154.43,93.32 v1(154.36,93.38)
  BOTTOM w0.203: UC1.J27 UC1.G27 ; UC1.J27 UC1.G28 v3(93.77,101.2) UC1.G27 ; UC1.J27 93.76,100.07 ; UC1.G27 v3(94.68,101.2) UC1.G25 v3(95.59,101.2) ; v3(95.59,101.2) 95.59,100.48 ; v3(95.59,101.2) UC1.G23 UC1.J22 UC1.K23 ; UC1.J23 95.59,100.12 95.59,99.56 v3(95.61,99.53) ; UC1.J23 UC1.K23 ; UC1.J23 UC1.K25 ; 93.92,99.71 UC1.K27 94.22,99.67 ; 93.61,99.71 UC1.K28 93.31,99.67 ; 94.83,89.95 UC1.AK25 95.14,89.98 ; UC1.K23 95.75,99.71 ; UC1.K23 96.05,99.67 ; UC1.K25 95.44,99.71 ; UC1.K25 95.14,99.67 ; UC1.AK23 96.04,90.01 ; UC1.K30 92.41,99.48
  BOTTOM w0.254: 95.59,100.48 UC1.J23 ; 95.59,100.48 UC1.G23 ; 95.59,100.48 UC1.G25 ; v1(134.98,80.94) 134.6,81.32 PL408.2
  vias: v3(94.11,90.95) v3(94.24,97.25) v3(94.29,95.65) v3(94.27,94.96) v3(94.29,94.35) v3(94.57,96.69) v3(94.67,99.05) v3(94.77,90.87) v3(94.85,90.13) v3(95.08,92.72) v3(95.08,92.11) v3(95.08,91.51) v3(95.33,98.95) v3(129.22,86.27) v3(129.22,85.61) v3(129.75,84.57) v3(129.8,86.58) v3(129.83,85.89) v3(129.83,85.21) v3(130.46,86.22) v3(130.46,85.56) v3(130.46,84.88) v3(131.07,86.6) v3(131.07,85.94) v3(131.07,85.26) v3(131.07,84.55) v3(131.37,83.99) v3(131.73,86.63) v3(131.73,85.97) v3(131.73,85.28) v3(131.71,84.6) v3(132.24,84.16) v3(132.31,86.35) v3(132.29,85.64) v3(132.34,84.88) v4(133.09,84.24)
+VCC_SFR: length 13.9
  TOP w0.254: RC197.2 96.2,105.65 CC70.1 v4(93.96,104.71) 93.3,104.71 v3(93.22,104.64)
  IN1 w0.203: v3(97.33,99.11) 97.25,99.02 96.37,99.02 96.15,99.25 96.15,99.86 95.84,100.17 94.96,100.17 94.24,100.89 94.24,102.66 93.22,103.67 v3(93.22,104.64)
  BOTTOM w0.254: v3(97.33,99.11) UC1.K21 97.72,99.59 98.24,99.59 UC1.K20
+VCC_SFROC: length 1.7
  TOP w0.254: RC293.2 95.81,85 96.07,85.26
  BOTTOM w0.203: UC1.AL23 v3(96.51,89.93)
  vias: v2(96.01,87.86)
