# Allegro board Lenovo ThinkPad E460 E560 BE560 NM-A561 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCC_ST: length 309.3
  TOP w0.203: U148.A2 125.33,65.11 C8544.1
  TOP w0.254: v1(74.29,117.13) 73.97,116.82 RC3.2 ; RC31.2 RC34.2 77.01,116.63 77.58,117.2 78.67,117.2 v1(79.05,117.58)
  TOP w0.381: v3(69.22,110.89) RC387.1 ; RC391.1 RC388.1 71.84,110.17 v3(71.13,110.89) 71.13,111.07 70.57,111.62 RC20.1
  TOP w0.508: v3(99.03,106.28) 97.85,106.28 RC197.1 97.67,106.61 CC69.1 97.72,107.61 99.5,109.39 99.5,112.56 101.48,114.54 102.04,114.54 103.66,116.17 103.66,118.3 104.4,119.04 104.4,119.47 103.12,120.75 v1(103.12,121.07) 104.7,122.66 107.54,122.66 108.01,123.13 v4(108.96,123.13) 110.98,123.13 111.72,123.86 117.95,123.86 120.81,126.72 123.51,126.72 125.79,124.45 125.79,122.59 127.21,121.17 140.49,121.17 140.65,121.32 142.96,121.32 v3(143.34,120.94) ; PR404.1 68.54,116.73 v1(68.46,116.8) ; PR404.1 69.14,116.88 69.14,117.77 PC403.1 ; PR404.1 PR403.1 ; v3(80.52,108.47) 80.04,108.47 79.36,109.16 79.36,109.53 78.32,110.56 78.32,111.07 80.68,113.43 80.68,115.51 80.22,115.97 80.22,116.58 80.57,116.94 80.74,116.94 81.06,117.26 81.06,117.79 80.26,118.59 79.81,118.59 78.67,119.74 v1(78.16,119.74) ; C8544.1 123.89,65.11 123.63,65.38 v3(123.63,65.7) ; v3(170.33,57.02) 170.52,57.22 170.52,59.09 v3(166.96,62.65)
  IN1 w0.508: v3(80.52,108.47) 80.75,108.47 81.26,108.98 81.26,109.46 80.78,109.95 78.72,109.95 77.76,110.91 75.35,110.91 74.91,110.47 71.55,110.47 v3(71.13,110.89) 71.13,110.53 70.62,110.02 69.68,110.02 69.25,110.45 69.25,110.86 v3(69.22,110.89)
  IN2 w0.508: v1(78.16,119.74) 77.15,119.74 76.17,118.76 70.8,118.76 68.84,116.8 v1(68.46,116.8) ; v3(143.34,120.94) 144.51,122.11 153.55,122.11 157.42,118.25 157.42,110.09 159.85,107.65 159.85,93.77 155.76,89.68 155.76,88.89 159.57,85.08 159.57,74.03 166.6,66.99 166.6,64.43 166.96,64.07 v3(166.96,62.65) ; v3(98.28,120.44) 98.91,121.07 v1(103.12,121.07)
  IN3 w0.254: v1(68.46,116.8) 69.79,116.8 70.41,116.18 72.95,116.18 73.91,117.13 v1(74.29,117.13) 74.29,116.56 74.54,116.31 76.32,116.31 77.59,117.58 v1(79.05,117.58)
  IN3 w0.508: v3(123.63,65.7) 124,65.33 126.16,65.33 128.01,63.48 134.33,63.48 138.26,59.55 142.22,59.55 147.17,54.6 154.82,54.6 155.53,53.89 157.79,53.89 160.61,56.71 170.01,56.71 v3(170.33,57.02)
  BOTTOM w0.203: v3(99.03,106.28) 98.93,106.17 98.93,105.45 99.4,104.97 UC1.A18
  BOTTOM w0.381: RC53.1 71.23,110.78 v3(71.13,110.89)
  BOTTOM w0.508: v1(78.16,119.74) 78.68,119.74 79.72,118.7 80.03,118.7 80.51,118.21 83.88,118.21 85.53,119.86 85.53,120.05 86.29,120.82 86.29,124.83 86.7,125.24 89.8,125.24 92.18,122.85 94.9,122.85 95.64,122.11 96.83,122.11 98.28,120.66 v3(98.28,120.44)
+VCC_STG: length 253.9
  TOP w0.254: CC68.1 97.8,104.6 98.28,104.12 98.28,103.11 97.88,102.71 97.88,101.48 98.16,101.2 v3(98.34,101.2) ; RC426.2 72.02,115.42 RC294.1 ; U149.4 128.41,65.33 v3(128.17,65.09)
  TOP w0.305: v3(104.4,120.99) 104.96,120.44 104.96,118.66 104.7,118.4 104.7,116.45 102.22,113.96 101.96,113.96 100.39,112.38 100.39,109.06 101.03,108.41 101.05,107.42 101.03,106.66 v4(100.11,105.73) 99.12,104.74 CC68.1 97.8,105.25 97.39,105.65 v3(96.92,105.65)
  TOP w0.381: RC294.1 71.95,114.99 71.43,114.47 v1(71.23,114.47) ; RC401.1 83.5,127.1 85.65,124.94 v1(85.65,124.69)
  TOP w0.508: R9490.2 67.39,112.24 v3(67.39,113.17)
  IN2 w0.381: 86.36,122.98 85.65,123.68 v1(85.65,124.69) ; 86.36,122.98 83.12,119.74 79.81,119.74 v1(78.8,118.72) ; 86.36,122.98 90.8,122.98 91.05,122.72 94.99,122.72 95.81,121.9 103.5,121.9 v3(104.4,120.99)
  IN2 w0.508: v3(104.4,120.99) 106.38,120.99 108.29,122.91 110.87,122.91 111.39,123.42 115.69,123.42 116.45,122.66 118.23,122.66 119.54,121.35 132.37,121.35 135.9,117.82 151.18,117.82 154.77,114.23 154.77,110.11 158.06,106.82 158.06,96.13 154.43,92.5 153.73,92.5 152.66,91.43 152.66,90.33 155.33,87.67 155.33,74.79 160.66,69.46 v3(160.66,65.85) ; v3(67.39,113.17) 67.39,112.85 67.92,112.33 68.79,112.33 69.14,112.69 69.14,113.45 69.53,113.83 70.92,113.83 71.23,114.14 v1(71.23,114.47)
  IN3 w0.508: v1(71.23,114.47) 72.05,115.29 76.32,115.29 77.15,116.12 79.5,116.12 80.51,117.13 80.51,118.21 80,118.72 v1(78.8,118.72) ; v3(166.17,58.33) 156.34,58.33 154.72,59.96 144.15,59.96 143.29,60.82 138.88,60.82 138.17,61.53 138.17,64.23 137.81,64.59 132.38,64.59 131.96,64.17 129.09,64.17 v3(128.17,65.09)
  BOTTOM w0.203: UC1.A22 v3(96.92,105.65)
  BOTTOM w0.254: UC1.G20 v3(98.34,101.2)
  BOTTOM w0.508: v3(166.17,58.33) 166.17,58.79 162.03,62.93 161.68,62.93 160.66,63.95 v3(160.66,65.85) ; v3(67.39,113.17) 67.39,113.12 RC123.1
AV12: length 7
  TOP w0.203: 46.95,32.48 47.23,32.2 UW1.10
  TOP w0.508: 46.95,32.48 v2(46.46,32.96) 46.21,33.21 43.85,33.21 43.39,32.76 CW4.1 RW3.1
DV12: length 8
  TOP w0.203: CW2.1 45.88,29.94 46.72,29.94 47.38,30.6 UW1.14
  TOP w0.508: CW2.1 44.96,29.96 v4(44.58,30.34) 44.15,30.77 42.93,30.77 42.56,30.41 CW1.1 41.84,31.15 RW3.2
GND: length 1802.2
  TOP w0.076: 81.73,83.26 CC231.2 ; CC231.2 82.42,83.26 ; CC231.2 82.07,83.62
  TOP w0.114: CA3.2 198.37,20.33 198.34,20.36 ; CC156.2 54.12,99.39 ; CC156.2 53.43,99.39 ; CC156.2 53.78,99.75
  TOP w0.178: v3(48.49,122.47) 48.49,121.93 47.91,121.35 UL1.6
  TOP w0.203: v3(93.22,133.14) 93.06,133.3 92.96,133.3 JLCD.24 ; 91.24,131.06 91.24,131.62 JLCD.30 ; 91.24,131.06 90.59,131.71 ; 91.24,131.06 v3(91.24,131.05) ; v3(90.38,130.24) 89.76,130.86 JLCD.34 ; JLCD.27 92.1,132.47 92.1,132.36 v3(92.31,132.15) ; v3(202.88,44.69) 202.86,44.69 ; 202.86,44.69 202.29,45.27 UE1.3 ; 202.86,44.69 202.64,44.47 UE1.1 ; v3(96.45,136.08) 96.4,136.08 95.68,136.8 JLCD.13 ; UE1.91 v3(186.98,46.47) ; CC152.2 54.45,93.3 ; CC152.2 54.79,93.65 ; CC152.2 55.14,93.3 ; v3(95.51,135.14) 95.51,135.27 94.83,135.95 JLCD.16 ; v3(94.8,134.23) 94.8,134.28 93.98,135.09 JLCD.19 ; JLCD.37 88.89,130.03 88.12,130.8 v3(87.76,130.8) ; v3(238.66,147.13) 238.3,147.5 JTOUCH.3 ; v3(239.3,148.83) 238.59,148.83 238.46,148.7 JTOUCH.6 ; v3(197.31,44.21) UE1.122 ; v3(193,57.16) 193.31,57.48 UE1.49 ; U148.B2 124.84,65.52 C8544.2 ; UE1.27 v3(200.08,54.87) ; UE1.113 v3(193.71,44.39)
  TOP w0.229: v3(29.14,59.9) 28.8,59.9 28.55,60.15 UX1.43 ; v3(23.98,58.42) 24.17,58.42 24.47,58.71 UX1.35 ; UX1.26 20.35,60.95 v3(20.33,60.92)
  TOP w0.254: v3(161.52,126.48) 162.06,125.95 RV118.2 CV209.2 ; v3(96.65,97.35) CC255.2 ; CC255.2 CC254.2 ; CC255.2 96.08,98.13 CC239.2 ; CE10.2 v3(201.61,38.14) ; CC179.2 90.8,100.97 v3(91.02,101.2) ; CC173.2 87,104.01 CC190.2 86.99,103.51 v3(87.01,103.48) ; CC52.2 98.51,96.69 98.63,96.81 v3(98.63,97.45) ; JTP.7 189.17,120.56 189.42,120.31 v3(190.18,120.31) ; 81.16,89.19 81.17,89.21 CC202.2 81.57,88.85 ; CV134.2 140.17,175.86 v1(139.8,175.49) ; v3(208.44,69.15) 208.39,69.15 208.17,68.94 UGSEN1.5 ; CC193.2 92.84,100.67 93,100.52 ; v3(92.85,99.68) 92.45,100.09 CC203.2 ; RC407.1 107.04,89.27 107.37,88.94 107.96,88.94 v3(108.22,88.68) ; QV18.1 186,128.78 185.98,128.79 v3(185.96,128.77) ; v3(91.85,84.1) 91.12,83.36 CC227.2 ; v3(96.84,84.1) 96.84,83.55 RC189.2 ; v3(101.08,100.56) 100.92,100.4 CC49.2 ; 82.58,89.22 82.57,89.21 CC171.2 82.18,88.79 ; CC109.2 CC108.2 86.87,90.26 87.61,89.52 CC256.2 ; CC109.2 85.96,90.26 85.76,90.06 ; CC109.2 86.04,90.31 v3(86.04,90.9) ; CC252.2 96.5,95.67 ; CC68.2 96.88,103.52 v3(96.92,103.48) 96.99,103.54 CC244.2 97.42,103.36 v3(97.42,102.47) ; JU3LF.7 v3(245.14,170.55) ; RPE4.1 210.71,61.8 v3(210.5,62.02) ; UGSEN1.13 203.61,66.94 v3(203.38,66.71) ; v3(178.75,120.63) 178.62,120.75 RV166.2 ; CC209.2 82.91,89.98 v3(82.79,89.87) ; CC251.2 96.36,92.86 ; CC251.2 96.36,92.18 ; CC251.2 96.72,92.52 ; v3(95.59,81.7) 95.9,81.38 CC233.2 ; v3(106.49,89.05) 106.49,89.94 RC406.1 ; CC161.2 79.05,90.44 ; v3(175.37,123.66) 175.37,124.86 176.12,125.61 QV19.1 ; v3(109.02,21.25) 109.18,21.1 RD24.2 ; CC198.2 85.45,90.01 ; v3(184.92,128.94) 184.54,128.94 CV187.2 ; v3(236.48,150.1) 236.68,150.3 JTOUCH.10 ; v3(203.06,68.54) 203.13,68.54 203.23,68.44 UGSEN1.10 ; v3(199.37,37.45) 199.24,37.45 198.81,37.89 CE1.2 ; v3(97.26,74.54) 96.7,73.98 96.7,72.61 CC99.2 ; v3(179.51,123.36) 179.51,123.69 180.13,124.31 QV19.4 ; v3(94.45,103.48) 94.23,103.27 CC237.2 ; CC174.2 87.37,101.18 v3(87.35,101.19) ; UGSEN1.12 203.37,67.44 v3(203.33,67.4) ; PR208.2 166.86,2.66 v3(166.45,2.25) 165.97,2.73 PC213.1 ; v3(86.04,90.9) 85.93,91 CC176.2 ; v3(86.04,90.9) CC195.2 ; v3(206.66,65.11) 206.28,65.49 UGSEN1.16 ; 93.58,92.57 93.59,92.56 CC250.2 ; v3(174.94,116.93) 174.89,116.98 JKB.30 ; 80.24,90.49 CC194.2 ; v3(245.14,167.55) JU3LF.1 ; CC201.2 CC144.2 115.54,112.22 115.54,112.22 v3(115.37,112.05) ; CC226.2 92.94,81.86 v3(93.31,81.49) ; CC235.2 94.36,83.58 v3(94.36,84.1) ; RC381.2 112.58,110.66 v3(112.9,110.97) ; 96.42,96.23 CC253.2 ; CC257.2 97.42,88.73 v3(97.42,88.29) ; CC250.2 93.59,91.82 ; CC250.2 92.92,92.17 v3(92.87,92.22) 92.72,92.06 CC207.2 92.3,92.62 ; 82.71,90.44 82.81,90.54 CC204.2 ; UGSEN1.15 205.78,65.05 v3(205.85,64.99) ; CG4.2 196.35,71.21 197.08,71.95 v3(198.13,71.95) ; UC3.3 50.94,109.02 RC26.2 ; CC94.2 84.61,83.91 v3(84.42,84.1) ; v3(86.9,84.1) 86.95,84.05 CC228.2 ; v3(116.82,94.05) 117.16,94.39 117.16,94.67 117.71,95.21 117.71,96.74 RC307.2 ; CC229.2 89.77,83.71 v3(89.38,84.1) 89.21,84.27 CC234.2 ; UV14.4 v3(165.14,153.44) ; CC200.2 84.65,103.48 v3(84.66,103.47) ; U149.6 129.94,64.84 130.44,64.35 C747.1 130.61,64.17 v3(131.25,64.81) ; IT5.1 200.72,36.87 v3(200.72,38.14) CE5.2 ; CC274.2 98.35,85.74 v3(98.34,85.75) ; RC4.2 73.84,111.55 73.65,111.74 v3(73.65,112) 73.29,112 73.08,111.8 RC152.2 ; v3(190.38,130.95) 190.1,130.95 189.53,130.38 QV18.4 ; CC208.2 v3(89.57,106.21) ; RV127.2 162.29,157.32 v3(162.08,157.52) ; v3(99.3,94.93) 99.3,94.65 99.52,94.43 CC95.2 ; CC197.2 91.98,103.47 v3(91.97,103.48) 91.98,103.49 CC205.2 ; v3(87.36,87.02) 87.36,87.28 87.6,87.52 CC106.2 ; JU3LF.4 244.91,169.05 v3(245.2,169.34) ; v3(46.62,124.25) 46.62,123.43 v3(46.59,123.41) ; v3(52.23,99.89) 52,100.12 52,101 RC56.1 ; v3(209.23,62.02) 209.21,62 RPE4.4 209.21,60.8 208.78,60.36 208.78,58.97 209.09,58.66 CE14.2 ; JCP.1 34.54,95.2 35.12,95.2 35.61,95.2 v3(36.28,94.53) ; v3(98.08,110.23) 97.8,110.23 96.75,109.18 CC69.2 ; RC382.2 104.88,69.38 RC403.1 ; AOU1.14 v3(34.15,16.22) ; CC199.2 82.66,91.66 ; CC50.2 101.23,95.78 v3(101.25,95.75) 101.48,95.52 CC262.2 ; Q6.1 206.94,136.69 v3(206.86,136.62) ; CC263.2 101.23,94.06 v3(101.25,94.08) ; CC143.2 86.01,91.56 v3(86.04,91.53) 86.08,91.49 CC175.2 ; CC249.2 96.54,91.29 v3(96.55,91.3) ; CC170.2 80.22,91.07 ; CC147.2 79,91.02 ; RC184.2 v3(58.43,112.94) ; CC145.2 82.72,91.1 v3(82.56,90.93) ; CC70.2 94.98,105.63 v3(94.55,105.2) ; CV205.2 v3(164.14,157.9) ; U11.11 v3(186.49,24.55) ; 43.41,125.01 v3(43.41,123.46)
  TOP w0.305: RD3.2 59.87,36.36 60.52,35.71 v3(60.52,35.68) 60.75,35.91 CD3.2 ; RC151.1 RC55.1 111.89,72.1 v3(111.18,72.81) ; v3(169.55,170.3) 169.98,170.73 CV239.2 ; v3(116.46,165.3) 115.98,164.82 CV125.2 ; UV12.5 171.44,172 v3(171.33,171.9) ; CC150.2 79.46,98.57 v3(79.69,98.34) 79.28,97.93 79.25,97.96 79.25,97.96 CC160.2 ; CD39.2 87.61,45.25 88.14,45.79 88.14,46.5 87.84,46.8 v3(87.61,46.8) ; v3(131.2,68.34) 131.2,68.59 130.89,68.9 C8541.2 ; Q6.4 208.24,140.07 v3(208.36,140.2) ; v3(53.65,94.83) 53.78,94.96 CC154.2 ; CD46.2 82.72,43.77 83.34,44.39 v3(83.7,44.39) ; v3(111.49,70.47) 112.48,70.47 112.83,70.83 R9449.2 ; CD11.2 86.58,37.82 CD15.2 89.74,39.21 v3(89.64,39.31) ; CV23.2 115.6,141.95 114.89,141.95 114.55,141.62 114.55,141.54 v1(114.41,141.39) ; CD13.2 93.65,35.97 v3(93.4,35.73) ; v1(113.51,137.16) 112.84,136.49 CV85.2 ; v3(122.59,46.96) 122.33,46.7 RC317.1 ; v3(29.65,87.39) 30.08,86.97 UVG2.32 ; v3(100.31,40.68) 100.39,40.76 CD49.2 ; v3(120.94,45) 121.07,44.87 CD58.2 CD57.2 ; CC146.2 79.46,95.57 v3(79.69,95.8) 79.3,96.18 CC151.2 ; v3(243.41,179.05) JU3LF.24 ; v3(243.06,177.59) 243.1,177.55 JU3LF.21 ; CV237.2 175.22,174.87 v3(175.22,174.46) ; v3(169.83,173.55) 170.26,173.12 CV236.2 ; 87.01,93.77 86.99,93.74 PC480.1 PC474.1 ; RV188.2 v3(175.44,179.52) ; C70.2 191.4,27.34 v3(191.95,26.79)
  TOP w0.356: v3(18.22,88.56) 18.2,88.54 UT3.3 ; v3(21.32,93.23) 21.28,93.27 UT4.3
  TOP w0.381: RV202.2 134.3,185.19 v1(134.2,185.09) ; v1(171,132.63) 171,131.04 170.29,130.33 QV4.3 ; UT3.1 v3(18.09,87.24) ; v3(83.57,29.22) 83.7,29.09 CD10.2 ; UT4.1 v3(21.17,91.97) ; PC473.1 87.43,96.05 v3(87.69,96.31) ; v3(29.06,81.27) 29.39,81.6 CVG44.2 ; CV169.2 158.45,185.56 v1(158.16,185.26) ; v3(22.97,91.96) 22.76,91.76 CVG37.2 ; v3(19.41,42.84) D8.3 v3(16.92,42.84) ; CV177.2 162.42,182.79 v1(162.56,182.94) ; v1(129.8,173.69) 129.67,173.56 CV139.2 ; v3(23.22,55.39) 23.22,55.56 RX13.2 ; RX4.2 24.06,71.44 v3(23.81,71.19) ; CC206.2 88.91,92.22 v3(89.44,92.22) 89.99,92.22 CC177.2 ; CX13.2 v3(18.22,68.8) ; v3(31.04,22.44) 30.92,22.57 C119.2 ; CC157.2 72.3,95.3 v3(71.98,95.62) ; CV127.2 111.06,157.24 v1(111.11,157.18) ; RV133.2 161.32,153.07 v3(161.22,153.18) ; v1(139.81,139.21) 139.63,139.38 CV38.2 ; v1(114.51,156.78) 114.64,156.65 CV114.2 ; CV36.2 141.38,140.12 140.97,139.71 v1(140.97,138.76) ; CV53.2 v1(148.09,151.5) 147.61,151.98 CV63.2 ; CT28.2 v3(13.52,83.28) ; CV225.2 v3(161.47,158.03) ; v3(60.03,76.65) 59.49,76.65 RC295.2 ; CV113.2 102.36,166.78 v1(103.11,166.78) ; CL8.2 43.41,122.98 v3(43.41,123.46) ; CV28.2 136.25,151.58 135.89,151.94 v1(135.41,151.94) ; CV84.2 103.09,145.14 v1(103.11,145.16) ; CD41.2 93.5,51.14 v3(92.92,51.73) 92.06,50.87 CD38.2 CD40.2 ; RV137.2 151.52,145 152.44,145.92 v3(152.51,145.92) ; CV142.2 127.51,173.08 v1(128.13,173.69) ; CV97.2 113.46,139.61 v1(113.51,139.56) ; CV37.2 CV33.2 135.53,142 v1(135.29,142.24) ; v1(102.98,163.39) 102.91,163.46 CV123.2 ; v1(148.22,156.55) 148.19,156.53 CV22.2 ; v1(126.2,185.09) 126.37,184.92 CV152.2 ; PC475.1 v3(90.48,95.04) ; v3(206.41,48.38) 206.41,48.38 206.15,48.63 CE7.1 ; CV137.2 137.9,177.43 138.22,177.11 v1(138.23,177.11) ; CC159.2 73.31,93.82 v3(73.28,93.79) 72.65,93.79 CC153.2 ; v1(150.6,156.28) 150.12,155.79 CV78.2 149.49,154.68 CV30.2 ; CV107.2 112.34,167.15 v1(112.71,166.78) ; CV124.2 115.13,154.49 v1(114.51,155.11) ; RVG131.1 22.36,86.2 v3(21.95,86.6) ; v1(161.8,185.09) 161.78,185.11 CV168.2 ; v3(30.28,82.18) 30.28,82.31 CVG35.2 29.67,82.92 28.84,82.92 CVG39.2 ; CV150.2 134.85,181.54 v1(135.4,180.99) ; v3(100.13,119.7) 100.13,119.14 99.8,118.81 RC374.2 ; v3(96.17,47.56) 95.87,47.56 94.8,48.63 CD48.2 CD42.2 ; v1(111.11,155.58) 110.77,155.23 CV120.2 ; v3(54.27,108.96) 53.38,108.07 RC26.2 ; v1(151.85,154.45) 151.39,154.45 CV214.2 RV160.1 ; CV47.2 151.28,150.93 151.69,151.35 RV7.1 152.05,151.58 152.46,151.98 v1(152.66,151.98) ; CV121.2 103.11,158.79 v1(103.11,158.78) ; CV240.2 173.69,177.48 v3(173.92,177.71) ; RC383.2 105.77,71.16 v3(104.83,71.16) 104.83,71.93 RC27.1 ; CV207.2 167.44,155.95 v3(167.44,156.63) ; CV138.2 130.26,177.15 v1(130.2,177.09) ; C44.2 v3(30.23,100.42) ; v3(15.47,65.39) 15.45,65.37 D14.3 v3(13.01,65.37) ; PC486.1 83.22,97.32 v3(83.47,97.58) 83.47,97.82 PC466.1 ; YVG1.2 26.38,80.15 v3(27.17,80.94) ; v3(83.45,95.04) 82.87,95.04 PC471.1 ; v3(208.44,67.82) 209.31,67.82 CG6.2 ; RX12.2 29.57,69.65 29.57,70.19 v3(29.37,70.4) ; v3(35.44,90.72) 35.21,90.49 35.03,90.49 CVG41.2 ; v3(22.73,81.89) 22.73,82.65 23.04,82.97 v3(23.17,82.97) 23.5,83.3 CVG32.2 ; v3(22.73,81.89) 22.77,81.85 YVG1.4 ; v3(22.73,81.89) 22.73,80.11 22.38,79.77 v3(22.38,79.47) 22.69,79.16 26.88,79.16 27.17,79.45 v3(27.17,80.94) ; CC218.2 83.27,102.94 v3(82.79,102.47) ; CV213.2 162.62,130.98 162.87,130.72 v3(162.87,130.34) ; v1(105.51,165.18) 105.45,165.12 CV115.2 ; RG8.1 205.29,73.57 v3(205.77,74.06) ; CC142.2 88.89,91.58 v3(89.44,91.58) 89.46,91.61 CC172.2 ; CV35.2 162.41,140.83 v3(162.49,140.76) ; CV154.2 136.3,175.1 135.91,175.49 v1(135.8,175.49) ; RT22.2 16.44,83.07 v3(16.29,83.22) ; CC192.2 87.74,98.46 v3(87.71,98.44) 87.69,98.41 PC465.1 ; v3(43.46,125.05) 43.41,125.01 ; v3(83.45,93.77) 82.8,93.77 PC470.1 ; CC191.2 90.14,98.15 89.78,97.79 PC467.1 v3(90.48,97.58) ; CT27.2 v3(13.52,80.99) ; CV122.2 115.02,165.28 v3(114.51,164.78) ; CV221.2 v3(160.58,158.03) ; v3(204.73,53.76) 204.92,53.95 CE6.2 ; v3(121.85,74.18) 121.72,74.06 RC100.2 120.5,74.06 v3(119.84,73.4) 119.77,73.32 119.77,72.73 120.17,72.33 RC97.1 ; CV178.2 159.8,181.45 v1(160.22,181.87) ; CC107.2 87.15,89.22 CC256.2 ; PC476.1 v3(90.48,93.77) ; CVG33.2 27.18,82.84 v3(27.18,82.49) 27.18,80.95 v3(27.17,80.94) ; CV116.2 106.76,164.78 v1(106.33,165.2) ; CV126.2 107,162.17 v1(107.22,162.38) ; CVG40.2 28.78,84.81 v3(28.73,84.85) ; RT21.2 16.44,80.79 v3(16.29,80.94) ; CV100.2 104.65,136.42 v1(103.91,137.16) ; CC1.2 117.48,72.37 v3(117.18,72.07) 117.18,72.12 117.14,72.16 117.1,72.16 116.91,72.35 116.91,72.39 116.62,72.68 CC5.2 ; RV103.2 163.43,130.34 v3(162.87,130.34) ; v1(105.7,166.94) 104.81,166.94 CV112.2 ; v1(143.06,154.55) 142.44,153.93 CV48.2 ; v3(147.1,154.65) 146.56,154.12 CV27.2 ; RC300.2 120.24,74.92 v3(119.89,74.58) ; v3(31.75,66.26) 31.73,66.26 31.28,66.71 CX11.2 ; v1(110.24,161.15) 110.14,161.05 RV200.2 ; v1(157.8,175.49) 158.03,175.49 158.43,175.1 CV170.2 ; CV140.2 136.45,185.56 v1(136.16,185.26) ; RV113.2 162.62,130.09 v3(162.87,130.34) ; v3(172.52,153.46) CV206.2 ; v3(13.52,78.68) CT25.2 ; LE2.2 179.31,52.57 v3(179.06,52.32) ; CV88.2 114.96,143.6 v3(114.51,143.16) ; v1(107.24,157.05) 107.24,157.54 106.81,157.97 CV111.2 107.09,158.48 v1(107.57,158.48) ; RC355.1 104.75,89.92 v3(104.04,89.21) ; v1(158.6,183.49) 158.82,183.71 CV179.2 ; CC148.2 71.53,97.25 v3(71.33,97.45) ; CV165.2 159.9,177.39 v1(160.2,177.09) ; C8544.2 v1(124.33,66.65) ; v3(22.92,53.58) 23.58,54.24 R108.2 ; CA5.2 202.77,23.53 v3(202.06,23.53) ; v3(15.55,85.46) CT24.2 ; v1(107.25,136.66) 107.7,137.12 CV83.2 ; CC96.2 102.14,90.64 v3(102.72,90.06) ; CV131.2 113.11,163.4 112.71,163.01 v1(112.71,162.78) ; v3(12.96,61.46) D13.3 v3(15.42,61.46) ; v1(126.99,62.27) 125.96,63.3 C8543.2 ; v1(153.8,185.09) 153.81,185.1 CV180.2 ; v1(152.33,141.16) 152,141.16 RV111.2 ; CC196.2 v3(89.41,92.88) CC178.2 ; v1(151.01,143.7) 150.91,143.7 150.4,143.19 CV72.2 ; v1(102.98,141.77) 102.98,141.59 103.36,141.21 RV195.2 ; v3(46.59,123.41) 46.59,122.95 CL7.2 ; 87.01,93.77 v3(87.69,93.77) ; CV87.2 105.65,143.42 v1(105.51,143.56) ; CT26.2 v3(15.55,83.2) ; CV208.2 v3(170.87,155.49) ; CE13.1 v3(205.73,52.82) ; v3(105.31,94.39) 105.25,94.34 CC273.2 ; PC804.1 184.54,183.68 v3(184.77,183.91) ; CA40.2 216.16,24.04 216.67,24.55 v3(216.92,24.55) ; RC382.2 105.59,68.37 v3(104.83,67.6) RC301.2 ; v1(134.2,174.69) 134.38,174.51 CV141.2 ; v3(97.33,98.27) 97.31,98.25 PRT7.2 ; v3(21.44,15.61) D16.3 v3(18.96,15.61) ; CD45.2 81.48,49.42 v3(80.92,48.86) ; CV167.2 156.85,181.54 v1(157.4,180.99) ; v3(73.28,97.45) 73.34,97.5 CC149.2 ; v3(87.69,95.04) 87.51,94.86 PC483.1 ; v3(71.33,93.79) 71.38,93.84 CC158.2 ; v1(136.33,155.68) 136.33,154.83 136.84,154.32 CV218.2 CV219.2 138.64,154.32 CV220.2 139.75,154.62 v1(140.2,154.62) 140.29,154.71 140.29,155.23 CV29.2 ; v1(134.17,177.97) 134.14,177.99 RV203.2 ; RT23.2 16.44,85.28 v3(16.26,85.46) ; RV197.2 110.56,140.35 v1(110.17,139.96) ; CV96.2 102.87,143.52 v1(102.81,143.46) ; CVG38.2 v3(33.03,84.09) ; v1(111.11,143.56) 111.03,143.47 CV80.2 ; CE15.1 v3(207.51,49.52) ; RX10.2 v3(31.71,64.93) ; v3(87.69,97.58) 87.36,97.25 PC487.1 ; v3(181.41,57.19) 181.62,57.39 CE16.2 RE7.2 ; CVG36.2 34.78,84.09 v3(35.31,83.56) ; CD44.2 83.19,51.09 v3(83.04,51.25) ; CV51.2 151.17,147.52 151.77,148.12 v1(151.77,148.35) ; CV161.2 162.21,175.73 161.97,175.49 v1(161.8,175.49) ; CV232.2 v3(174.53,181.57) ; RV205.2 156.04,177.84 v1(156.17,177.97) ; v1(111.11,165.18) 110.82,164.88 CV117.2 ; RL8.2 v3(42.73,124.37) ; PC484.1 82.95,96.31 v3(83.47,96.31) ; CV241.2 166.85,179.17 v3(167.39,179.72) 166.62,180.49 QV23.1 ; CV132.2 103.29,153.35 v1(103.11,153.18) ; CD21.2 v3(87.56,27.47) ; R67.1 v3(30.21,99.45) ; CV222.2 v3(164.65,159.55) ; PC472.1 v3(90.48,96.31) ; C45.2 v3(30.23,101.31)
  TOP w0.508: CA25.1 v3(202.06,23.53) ; CC9.2 CC102.2 v3(45.04,109.82) ; U15.2 v3(24.26,23.81) 23.53,23.08 C8545.2 ; RC288.2 v3(119.67,99.99) RC204.2 ; v3(234.93,142.79) 234.93,143.47 ; 234.93,143.47 C116.2 ; 234.93,143.47 234.93,144.31 C115.2 ; CD17.2 v3(99.75,23.84) ; CD29.2 120.2,38.09 v3(120.64,38.53) 120.82,38.53 121.34,38.01 CD30.2 ; 198.34,20.36 v3(198.34,19.38) ; PC1.1 v3(62.59,8.07) ; D17.2 v3(19.92,17.24) ; CA7.2 212.99,28.23 v3(212.91,28.31) ; CV228.2 v3(173.41,122.93) ; CC61.2 v3(125.94,90.72) ; JFPB.5 v3(214.05,88.65) ; CA2.2 v3(198.37,22.66) ; CA19.1 v3(209.38,12.64) ; C749.1 126.97,68.9 v3(126.24,68.18) R9493.1 ; 64.6,6.77 64.57,6.79 PQ2.3 ; v3(244.48,184.55) 243.92,183.99 C172.2 ; RC389.2 120.58,89.69 v3(120.58,89.02) 121.04,88.56 CC60.2 ; PC209.1 166.17,9.97 v3(166.27,10.07) ; RC144.1 66.02,110.89 v3(66.05,110.91) ; DT1.2 9.43,84.24 v3(9.05,83.86) ; v3(12.25,90.74) 12.33,90.82 DT2.2 ; CC97.2 116.54,94.32 v3(116.82,94.05) ; CC139.2 83.48,100.97 v3(83.71,101.2) ; QV17.3 v3(190.95,127.42) ; CD47.2 97.91,40.64 v3(98.27,40.29) ; v3(187.38,124.02) 187.05,124.35 C205.2 ; CRF1.2 CRF2.2 v3(94.82,27.57) ; CW7.2 v3(55.91,28.92) ; R9476.2 v3(35.57,13.81) ; U7.2 188.02,16.55 187.81,16.75 v3(185.73,16.75) ; CC4.2 116.13,87.29 114.43,87.29 v3(114.15,87.01) ; v3(37.5,12.05) C8531.2 v3(36.2,13.89) ; v3(214.1,93.18) 214.56,93.64 C52.2 ; C204.2 v3(186.57,122.65) ; QL3.3 56.84,122.23 v3(57.56,122.95) ; RC315.1 123.63,34.2 122.82,33.39 v3(122.4,33.39) ; v3(215.96,32.07) 215.7,32.32 215.7,32.32 Q5.3 ; v3(58.05,49.14) 58.65,49.14 59.15,49.64 RD16.2 59.16,49.95 CD32.2 CD33.2 ; PC226.1 190.05,3.09 v3(189.97,3.16) ; UC4M1.4 v3(223.42,25.87) ; CD18.2 v3(100.64,23.81) ; CA1.2 195.13,25.44 194.37,25.44 v3(194.34,25.41) ; v3(201.61,71.41) CG3.2 ; PC468.1 v3(83.5,92.55) ; RC302.2 99.75,68.75 v3(100.77,68.75) ; PD7.1 v3(201.14,182.03) ; CC129.2 74.24,90.13 v3(73.91,90.13) ; v3(58.83,121.02) 58.76,120.94 CL17.2 ; CA43.2 v3(215.88,28.35) ; v3(29.14,58.71) 29.52,58.33 RX15.2 ; CE12.2 v3(192.1,35.96) ; PR201.2 170.49,10.89 v3(170.77,11.17) ; v3(213.26,11.98) 213.39,12.1 CA15.2 ; CA27.1 v3(201.86,19.98) 202.24,19.98 CA4.2 ; RC9.2 RC10.2 99.74,81.31 v3(99.31,81.74) 98.88,81.31 RC8.2 ; CG5.2 200.89,63.51 v3(200.41,64) ; RD11.2 v3(102.42,23.87) ; RE32.2 187.69,39.92 187.15,40.45 v3(187,40.45) ; v3(207.19,96.43) 208.44,96.43 JFPB.7 208.84,94.91 v3(207.19,94.91) ; v3(245.8,182.65) 246.3,182.15 JU3LF.28 ; CRF4.2 104.04,23.36 v3(104.55,23.87) ; CD43.2 92,40.91 92.5,40.4 v3(92.54,40.4) ; v3(26.52,56.35) CX14.2 ; v3(62.06,35.81) 61.64,36.23 CD1.2 ; v3(96.86,132.12) 97.33,131.65 97.48,131.65 ; RA13.2 v3(204.1,27.29) ; v3(97.69,27.45) 97.46,27.68 CD9.2 ; PC493.1 74.75,88.49 v3(74.56,88.31) ; CE11.2 209.1,51.42 v3(209.43,51.09) 209.43,50.38 IT4.1 ; CA18.2 204.3,16.07 v3(204.25,16.02) ; PC499.1 v3(75.48,93.29) ; RX18.2 v3(31.55,60.11) ; v3(100.12,35.75) 99.93,35.94 CD19.2 ; CW6.2 45.7,30.8 v3(45.12,30.8) ; CA13.2 v3(208.49,13.04) ; v3(54.18,51.09) 55.76,52.67 RD18.2 ; v3(226.88,157.22) 226.83,157.16 PR105.1 ; CRF3.2 v3(103.18,23.92) ; RC316.1 120.81,33.36 v3(120.3,33.87) ; v3(59.72,115.41) 59.67,115.46 59.06,115.46 58.68,115.84 RL23.2 ; CE9.2 v3(192.28,38.32) ; v3(151.95,119.55) 151.95,117.9 152.48,117.36 CV19.2 ; CD59.2 67.14,27.4 v3(67.06,27.47) ; v3(202.18,25.63) 201.99,25.82 CA26.1 ; RD12.2 105.09,24.22 v3(105.31,23.99) ; JFPB.4 v3(214.05,89.65) ; RC166.1 123.35,78.25 v3(123.35,80.41) ; CL9.2 CL13.2 35.83,111.41 v3(35.21,112.03) ; CVG42.2 35.32,83.54 v3(35.31,83.56) ; CA6.1 v3(214.08,28.35) ; C74.2 v3(190.94,23.18) ; R484.2 v3(34.68,13.83) ; D7.2 v3(17.66,45.94) ; RD4.2 57.08,40.55 v3(57.21,40.68) ; CW1.2 42.42,29.59 v3(42.42,29.71) ; JAUF.14 222.64,13.25 v3(222.26,13.63) ; C8532.2 v3(40.01,18) ; v3(17.56,57.55) 17.38,57.72 CX12.2 RX2.1 ; v3(70.52,90) 71.1,90.58 CC133.2 71.2,91.75 PC492.1 72.93,91.75 CC155.2 73.77,92.18 v3(73.99,91.96) 74.77,91.96 CC130.2 ; CC264.2 102.98,92.47 v3(102.77,92.26) ; CE8.2 v3(192.9,62.6) ; C751.2 v3(192.08,15.53) ; RX12.2 29.68,69.56 CX2.1 ; v3(93.43,27.4) 93.77,27.74 CD8.2 ; R69.2 v3(209.51,32.53) ; CW8.2 v3(56.67,27.85) ; RX20.2 21.9,55.62 v3(21.75,55.46) ; C72.2 v3(190.66,24.14) ; CW2.2 v3(44.96,29.05) ; CV20.2 156.44,115.58 v3(156.57,115.46) ; CV229.2 185.86,128.67 v3(185.96,128.77) ; CE4.2 v3(181.59,45.58) ; PC496.1 v3(75.44,97.05) ; CC2.2 103.32,80.55 104.58,79.29 106.74,79.29 v3(106.86,79.16) ; C71.2 v3(190.81,25.03) ; v3(228.83,156.3) 228.59,156.06 PR19.1 ; RX21.2 28.5,55.74 v3(27.03,54.27) ; CA14.2 202.55,17.69 v3(202.09,17.69) CA28.1 ; v3(31.81,94.43) CVG34.2 31.02,94.4 CVG43.1 ; CC3.2 116.06,89.55 v3(115.63,89.55) ; RV107.2 CV211.2 160.27,130.99 v3(160.27,132.25) ; CT31.1 17.76,91.07 v3(17.35,91.48) ; C73.2 v3(182.33,24.4) ; v3(30.88,104.71) R61.1 ; CD60.2 68.87,42.74 69.36,43.23 v3(69.36,43.63) ; C75.2 v3(214.79,38.75) ; PC488.1 v3(75.44,98.34) ; CD14.2 97.08,35.79 v3(97.16,35.7) ; CD16.2 v3(92.25,27.26) ; C8528.2 v3(35.49,9.9) ; v3(79.69,97.07) PC489.1 ; v3(48.6,25.97) CW3.2 ; v3(183.01,39.74) CE17.2 184.12,39.7 QE1.3 ; PC494.1 v3(79.69,94.53) ; PC497.1 v3(75.44,95.78) ; PC498.1 v3(75.46,94.52) ; CD20.2 v3(99.24,27.4) ; RL7.2 v3(47.55,110.83) ; CA12.2 v3(194.42,28.13) ; RVG135.2 v3(25.58,95.09) ; D4.1 205.07,101.3 v3(206.23,102.45) ; v3(15.55,80.89) CT29.2 ; CW5.2 43.48,31.68 43.06,32.09 v3(42.6,32.09) ; CC26.2 v3(226.83,16.12) ; RVG134.2 v3(28.25,95.16) ; RW8.1 43.9,34.56 v3(43.64,34.56) 43.16,34.08 CW4.2 ; C750.2 v3(184.51,13.55) ; C69.2 v3(182.05,25.82)
  BOTTOM w0.076: UC1.BB67 71.35,82.2 71.32,82.2 70.93,81.8 v3(70.72,81.65)
  BOTTOM w0.084: v3(73.92,43.68) 74.02,43.58
  BOTTOM w0.127: 90.04,108.82 89.27,108.05 89.27,106.5 v3(89.57,106.21)
  BOTTOM w0.152: UC1.BB60 75.81,82.64 75.81,81.77 v3(75.79,81.75)
  BOTTOM w0.178: UC1.BB43 85.6,81.73 v3(85.57,81.71) ; UC1.BB64 73.48,82.13 73.48,81.75 v3(73.48,81.75) ; UC1.AG71 68.46,91.15 68.3,91.31 v3(68.28,91.37) ; UV1.B7 130.59,158.17 v1(129.68,158.17) ; UC1.AM71 69.1,88.49 68.37,88.49 v3(68.28,88.41) ; v1(138.27,162.2) 138.4,162.07 UV1.N2 ; UV1.AJ2 151.21,161.17 v1(151.21,162.19) ; UC1.BB34 90.55,82.39 90.55,81.11 v3(90.51,81.07) ; UV1.R2 140,161.86 139.96,161.9 139.96,162.04 v1(139.84,162.16) ; UC1.BB55 78.43,82.27 78.43,81.79 v3(78.47,81.75) ; v1(144.66,162.2) 144.76,162.1 144.76,161.2 UV1.AA2 ; UC1.BB18 99.28,81.77 v3(99.31,81.74) ; v3(68.38,100.83) 68.46,100.75 UC1.H71 ; v3(95.59,81.7) 95.53,81.75 95.53,82.26 UC1.BB26 ; UC1.AT71 68.46,86.14 v3(68.28,86.14) ; UC1.BB30 93.18,82.01 93.18,81.62 v3(93.31,81.49) ; v3(88.24,81.68) 88.21,81.7 88.21,82.65 UC1.BB38 ; UC1.C25 94.8,103.99 94.8,104.87 94.62,105.04 94.62,105.09 94.54,105.17 94.54,105.2 v3(94.55,105.2)
  BOTTOM w0.203: UC1.C1 110.04,104 110.17,104.13 v3(110.17,104.23) ; UC1.AH6 106.38,90.01 106.02,90.01 UC1.AK8 ; UC1.AF63 74.36,91.4 74.36,90.7 UC1.AH63 ; UC1.AV1 110.21,84.82 v3(110.34,84.69) ; UC1.AL52 v3(80.96,89.87) ; UC1.AU20 98.79,84.67 98.82,84.64 ; UC1.AL45 v3(84.62,89.87) ; UC1.G10 v3(103.82,101.2) ; v3(94.68,99.68) UC1.J25 ; UC1.J28 v3(92.85,99.68) ; 98.82,84.64 98.85,84.61 UC1.AW18 99.77,84.61 99.8,84.64 100.09,84.64 100.12,84.61 UC1.AW16 100.57,84.61 v3(101.08,85.12) 101.59,84.61 UC1.AW14 102.19,84.61 102.22,84.64 102.51,84.64 102.54,84.61 UC1.AW12 103.32,84.61 v3(103.82,85.12) 104.12,84.82 UC1.AW10 104.61,84.61 104.64,84.64 104.93,84.64 104.96,84.61 UC1.AW8 105.76,84.61 105.78,84.64 106.07,84.64 106.1,84.61 UC1.AW6 ; 98.82,84.64 98.52,84.64 98.49,84.61 UC1.AW21 97.7,84.61 97.67,84.64 97.38,84.64 97.35,84.61 UC1.AW23 96.38,84.61 96.35,84.64 96.05,84.64 96.02,84.61 UC1.AW26 95.15,84.61 95.12,84.64 94.82,84.64 94.79,84.61 UC1.AW28 93.92,84.61 93.89,84.64 93.6,84.64 93.57,84.61 UC1.AW30 92.7,84.61 92.67,84.64 92.37,84.64 92.34,84.61 UC1.AW32 91.51,84.61 v3(91.02,85.1) 90.65,84.74 UC1.AW34 90.17,84.61 90.14,84.64 89.84,84.64 89.81,84.61 UC1.AW36 88.94,84.61 88.91,84.64 88.62,84.64 88.59,84.61 UC1.AW38 87.87,84.61 v3(87.36,85.12) 86.9,84.65 UC1.AW41 86.44,84.61 86.41,84.64 86.11,84.64 86.08,84.61 UC1.AW43 85.21,84.61 85.18,84.64 84.89,84.64 84.86,84.61 UC1.AW45 83.99,84.61 83.96,84.64 83.66,84.64 83.63,84.61 UC1.AW47 82.82,84.61 82.79,84.64 82.5,84.64 82.47,84.61 UC1.AW49 81.56,84.61 81.53,84.64 81.24,84.64 81.21,84.61 UC1.AW51 80.4,84.61 80.37,84.64 80.07,84.64 80.04,84.61 UC1.AW53 79.17,84.61 79.14,84.64 78.85,84.64 78.82,84.61 UC1.AW55 77.95,84.61 77.92,84.64 77.62,84.64 77.59,84.61 UC1.AW57 76.67,84.61 76.64,84.64 76.35,84.64 76.32,84.61 UC1.AW60 75.44,84.61 75.41,84.64 75.12,84.64 75.09,84.61 UC1.AW62 74.22,84.61 74.19,84.64 73.89,84.64 73.86,84.61 UC1.AW64 73.33,84.66 72.36,84.66 UC1.AW66 72.1,84.75 72.01,84.66 72,84.66 v3(71.82,84.48) UC1.AY66 UC1.BA66 ; UC1.V18 99.35,95 ; UTPM1.16 118.42,118.53 UTPM1.33 ; UC1.BA2 UC1.BA1 ; PU1.2 215.21,130.28 PC8.2 v3(216.31,130.44) ; UC1.AF4 108.02,91.8 108.42,91.8 UC1.AF2 UC1.AF1 110.06,91.51 110.45,91.12 v3(110.7,91.12) ; UV1.B11 130.55,155.01 129.7,155.01 v1(129.65,155.06) ; UC1.AK22 97.01,89.68 97.01,89.93 v3(97.19,90.11) 97.19,89.94 UC1.AK21 ; UC1.AL55 v3(79.13,89.87) ; UC1.AH67 71.01,89.94 UC1.AK68 71.01,89.75 71.42,89.34 71.42,89.07 71.33,88.98 UC1.AM68 ; v1(129.56,140.39) 129.72,140.55 130.59,140.55 UV1.B29 ; UC1.AL58 v3(77.31,89.87) ; UC1.AL66 UC1.AL65 73.04,88.81 73.08,88.76 73.46,88.76 73.51,88.81 UC1.AL64 ; UC1.AL48 v3(82.79,89.87) ; v1(129.72,142.14) 129.75,142.16 UV1.B27 ; UC1.K71 68.48,99.39 v3(68.38,99.38) ; UC1.AD20 98.2,92.93 97.77,92.93 UC1.AD21 ; v3(71.82,88.29) 71.52,88.59 UC1.AM68 ; UC1.K63 74.54,100.01 UC1.K61 ; UC1.F38 87.81,101.59 v3(87.35,101.19) 86.91,101.58 UC1.F40 ; UC1.AM68 71.33,88.11 71.36,88.08 71.36,87.78 71.33,87.75 UC1.AP68 71.33,86.88 71.36,86.85 71.36,86.56 71.33,86.53 UC1.AT68 71.33,85.72 71.38,85.55 71.38,85.37 71.33,85.32 71.33,84.95 UC1.AV68 ; v3(82.01,84.1) 81.57,84.1 UC1.AW50 ; v3(110.29,102.27) 110.13,102.12 UC1.F1 ; UC1.D48 UC1.D47 82.74,103.01 83.13,103.01 83.15,102.98 83.44,102.98 83.47,103.01 83.85,103.01 UC1.D45 UC1.D44 ; v3(99.3,94.93) 98.96,94.6 UC1.Y19 ; UC1.F33 v3(91.02,101.2) UC1.F32 ; v1(129.52,151.91) 129.67,151.75 130.59,151.75 UV1.B15 ; UC1.AJ4 UC1.AL4
  BOTTOM w0.254: JWLBT.57 v3(240.7,169.4) ; PC619.1 209,142.89 v3(208.41,142.31) 208.08,142.64 PC620.2 ; UC1.K64 v3(73.91,99.3) UC1.K63 ; PR307.2 v3(131.55,43.68) ; v1(74.86,116.85) 75.47,116.24 PC409.1 76.28,116.17 PR419.1 ; v1(129.72,143.79) 129.72,143.76 129.75,143.74 129.75,143.73 130.57,143.73 UV1.B25 ; UC1.AP38 88.28,87.66 UC1.AN37 ; UC1.AP38 v3(87.36,87.02) ; UC1.AP38 UC1.AN38 88.28,88.56 ; UV7.P10 v1(136.6,177.09) ; UV1.AW14 157.8,152.96 v1(157.96,153.12) ; UC1.BB70 69.37,82.18 68.86,82.18 v3(68.66,82.38) 69.06,82.77 UC1.BA71 ; v1(131.88,143.5) 131.94,143.56 UV1.F25 ; UC1.Y20 UC1.Y21 97.56,94.5 97.26,94.2 v3(97.26,94.11) 97.33,94.11 97.66,93.78 UC1.AB21 UC1.AD21 97.33,92.49 v3(97.33,92.4) ; UC1.AG17 99.61,90.49 UC1.AJ18 99.45,90.15 99.45,89.63 UC1.AK18 v3(99.25,88.93) ; UC1.AG17 100.39,91.28 100.78,91.28 UC1.AG16 101.56,91.79 UC1.AF15 101.74,91.8 102.01,91.8 102.46,92.26 v3(102.77,92.26) ; UC1.AG17 100.26,91.24 99.93,91.56 ; UV8.C1 v1(149.75,185.14) ; v1(152.18,180.96) 152.6,181.39 UV8.F5 ; UC1.J38 87.36,101.18 v3(87.35,101.19) ; UC1.BA28 v3(94.36,84.1) UC1.AW28 ; UV6.R12 v1(111.91,143.56) UV6.R11 ; v1(62.05,118.72) 62.62,119.29 PR440.1 62.92,119.34 PC427.1 ; UV8.U12 v1(161.8,175.49) ; v3(239.3,148.83) 239.32,148.86 239.32,149.56 JU3LC.18 ; UV7.R14 v3(137.8,173.69) ; 88.28,88.56 UC1.AN37 ; 88.28,88.56 UC1.AL38 ; UC1.AN37 UC1.AP35 ; UC1.T4 108.04,96.81 v3(108.22,96.63) 108.4,96.81 UC1.T2 ; UC1.E18 v3(99.25,102.47) ; v3(234.35,147.97) 234.56,147.97 JU3LC.9 ; v3(69.68,92.52) 69.78,92.42 UC1.AE69 UC1.AE68 UC1.AE67 UC1.AE66 UC1.AE65 UC1.AE64 73.91,91.99 73.96,91.99 73.98,91.96 v3(73.99,91.96) 74.08,91.83 74.07,91.77 UC1.AF63 ; v3(102.77,94.39) 102.57,94.64 UC1.W13 ; v1(130.66,180.86) 130.6,180.93 UV7.F5 ; PC127.1 169.88,170.63 v3(169.55,170.3) 170.11,169.74 ; UV8.C4 v1(150.6,182.69) UV8.C3 ; UC1.K65 v3(72.61,99.3) UC1.K66 ; UV7.R11 v1(138.2,176.29) UV7.R12 ; v3(73.91,90.13) UC1.AH63 ; v3(73.91,90.13) UC1.AH64 ; v3(73.91,90.13) UC1.AK63 UC1.AM61 v3(74.56,88.31) ; PR703.1 142.65,44.39 v3(142.17,43.91) 141.81,44.26 PC702.1 ; UV6.B5 v3(106.3,132.35) ; v3(105.94,98.53) UC1.L8 ; UV1.M39 137.6,133.57 v1(137.74,133.43) ; UC1.N13 102.77,97.58 v3(102.85,97.58) 102.74,97.55 UC1.R13 ; UC1.BA32 v3(91.85,84.1) UC1.AW32 ; v1(153.8,185.09) UV8.H1 ; PR313.1 PC319.2 v3(136,41.09) ; UC1.J11 v3(102.91,99.93) 102.57,99.71 UC1.J13 ; UV1.AW24 157.8,144.88 v1(158.02,145.1) ; v3(101.25,95.75) UC1.V16 UC1.Y17 ; v3(139,176.29) 139,176.29 UV7.U12 v1(139.8,175.49) ; UV1.AW20 158.02,147.54 v3(158.02,146.99) 158.02,146.38 UV1.AW22 ; UV8.C12 v1(149.8,175.49) ; UV6.A1 103.51,131.34 v1(103.54,131.31) ; UC1.B30 v3(91.97,103.48) UC1.D30 ; v3(131.47,160.19) 131.48,160.18 131.58,160.18 UV1.E5 ; Q24.4 131.66,48.06 v3(132.04,48.43) ; UV1.F9 132.24,156.4 v1(132.17,156.4) ; v1(129.67,185.36) 129.8,185.23 UV7.E1 ; PC106.2 182.73,165.55 v3(182.73,165.67) 182.51,165.9 PC109.2 ; v1(152.66,151.98) 152.66,152.22 UV1.AL14 ; v3(243.01,170.78) 242.88,170.9 JWLBT.51 ; UV8.H14 v1(153.8,173.89) 153.8,173.57 153.22,172.99 RV204.2 ; UC1.AF10 104.35,91.89 104.07,92.18 102.85,92.18 v3(102.77,92.26) ; UV6.C3 v1(105.51,133.96) UV6.C4 ; UV1.L6 136.6,159.34 136.8,159.54 v1(136.8,159.71) ; v3(111.91,144.36) 111.91,144.36 UV6.U12 v1(112.71,145.16) ; CV151.2 134.4,185.29 v1(134.2,185.09) UV7.K1 ; UC1.AM25 UC1.AM27 ; UC1.AM27 93.77,88.31 UC1.AN28 UC1.AP28 v3(92.85,87.02) UC1.AR28 UC1.AT28 ; UC1.AM27 93.77,89.16 UC1.AL28 94.22,89.63 UC1.AK27 ; UV5.R3 v1(105.51,165.18) 105.91,164.78 UV5.R4 ; v3(116.19,182.82) 116.19,182.82 U1.6 ; UV7.A14 126.96,174.65 126.94,174.65 126.94,174.66 v1(126.94,174.66) ; v1(145.73,133.36) 145.73,133.62 145.6,133.74 UV1.AB39 ; PC208.2 170.94,5.51 v3(170.92,5.53) ; UV6.R1 103.38,143.3 102.97,143.3 v1(102.81,143.46) ; v1(105.61,145.47) 105.61,145.26 UV6.U3 ; R9484.1 110.98,121.2 v3(109.99,122.19) ; PC5.2 PC4.2 v3(232.82,157.75) ; UV5.U1 103.39,166.38 103.11,166.66 v1(103.11,166.78) ; v3(73.65,87.66) 73.83,87.81 73.85,87.81 73.99,87.96 UC1.AN63 ; UV6.C11 v1(111.91,133.16) ; UV8.T10 v1(160.2,177.09) ; UV1.AJ33 150.96,136.92 v1(150.68,136.92) ; v3(98.34,87.66) 98.38,87.66 98.79,88.02 UC1.AN20 ; UV1.AR18 156.2,148.76 v1(155.98,148.53) 155.62,148.53 155.59,148.57 155.59,148.57 UV1.AP19 ; v1(128.9,138.37) 128.9,138.51 128.94,138.55 128.94,138.56 129.34,138.96 UV1.B31 ; JWLBT.45 v3(243.09,172.4) ; v1(138.23,177.11) 138.22,177.11 UV7.T10 ; UV1.AW30 157.85,139.71 157.85,138.21 UV1.AW32 v1(158.43,138.16) ; v3(178.57,163.67) 178.64,163.59 PC107.2 ; UV1.G2 133.6,161.73 v1(133.66,161.79) ; UV7.C12 v1(128.64,175.44) ; UV5.U3 105.68,166.94 v1(105.7,166.94) ; UV8.R14 v3(159.8,173.69) ; PC622.2 PR626.2 212.48,144.77 v3(212.32,144.62) ; UV8.G5 153.4,180.81 v1(153.5,180.71) ; v3(105.94,93.33) 105.71,93.69 UC1.AB8 ; v3(235.49,149.09) 235.56,149.09 JU3LC.12 ; v3(97.33,98.27) 97.33,98.17 UC1.N21 97.86,98.06 97.86,98.19 98.31,98.63 UC1.L20 ; UV1.B33 130.6,137.36 v1(129.93,137.36) ; UC1.AL65 72.96,88.52 v3(72.76,88.32) ; UV6.E1 103.62,135.16 104.02,135.56 104.71,135.56 UV6.E3 105.13,135.16 v1(105.51,134.78) ; UC1.K70 70.23,99.6 v3(70.52,99.6) 70.62,99.5 UC1.K68 71.23,99.7 UC1.K67 71.64,99.63 v3(71.96,99.3) ; UV1.AN2 154.44,161.2 154.44,162.07 v1(154.62,162.24) ; UV5.E3 105.13,156.78 v1(105.51,156.4) ; v1(109.91,82.31) 109.89,82.33 109.89,82.59 UC1.BA1 ; UV8.D10 v1(150.6,177.09) ; UC1.AW6 106.74,84.61 107,84.35 107.62,84.35 v3(108.01,83.96) ; UV1.R6 139.89,159.07 v1(139.89,158.56) ; UC1.F68 UC1.D69 v3(70.28,102.62) ; v3(144.08,133.38) 144,133.46 UV1.Y39 ; UV6.P10 v1(111.11,141.96) ; v1(136.68,162.18) 136.75,162.12 136.75,161.21 UV1.L2 ; UC1.AL32 91.94,89.8 v3(91.5,90.24) ; v1(103.17,133.96) 103.36,133.77 103.36,133.77 103.51,133.62 UV6.C1 ; UV7.N12 v1(135.8,175.49) ; UC1.F4 108.04,102.12 v3(108.22,101.94) 108.4,102.12 UC1.F2 ; UC1.C5 107.05,103.66 106.99,103.61 106.96,103.61 v3(106.84,103.48) 106.81,103.46 UC1.D6 ; v1(129.32,146.84) 129.44,146.96 UV1.B21 ; RV201.2 131.22,172.99 131.8,173.57 v1(131.8,173.89) UV7.H14 ; UC1.E50 v3(80.96,102.47) ; UC1.AP68 v3(70.72,87.32) UC1.AP70 ; UV6.C14 114.04,133.43 114.46,133.43 v1(114.51,133.49) ; v1(107.24,157.05) 107.24,157.11 106.77,157.58 UV5.F5 ; v1(130.56,162.04) 131,161.6 UV1.C1 ; UC1.AT23 v3(95.59,86.39) UC1.AR23 UC1.AP23 UC1.AN23 ; v3(111.91,165.98) 111.91,165.98 UV5.U12 v1(112.71,166.78) ; v1(149.03,181.86) UV8.B5 ; UV6.R4 105.91,143.16 v1(105.51,143.56) UV6.R3 ; v3(98.63,97.45) UC1.P20 98.19,96.89 97.78,96.89 UC1.P21 ; v3(98.63,97.45) 98.63,97.34 UC1.P19 99.3,96.59 UC1.T18 99.76,96.03 100.11,96.03 UC1.T17 100.51,96.43 100.51,96.71 100.26,96.97 UC1.P17 ; v3(98.63,97.45) UC1.N19 v3(99.29,98.27) UC1.L18 ; v1(133.13,154.42) 133.13,154.14 132.98,154 132.98,153.94 132.6,153.56 UV1.F13 ; UV8.N12 v1(157.8,175.49) ; UC1.AR8 v3(104.74,86.39) ; UV5.N1 103.38,163.31 103.05,163.31 v1(102.98,163.39) ; UV7.A3 126.13,183.09 v1(126.07,183.03) ; UV8.M10 UV8.L10 156.6,177.54 v1(156.17,177.97) ; UV1.F27 132.15,141.96 v1(131.98,142.13) ; UC1.B58 v3(77.1,103.48) UC1.D58 ; v3(97.42,88.29) 97.49,88.29 97.88,88.64 UC1.AM21 ; UC1.B39 v3(87.01,103.48) UC1.D39 ; UV5.K1 103.33,160.97 v3(102.97,160.97) ; UC1.AN42 v3(86.45,87.66) ; v3(86.45,87.66) UC1.AP42 UC1.AN43 ; v3(86.45,87.66) UC1.AN40 ; UC1.AU10 v3(103.82,85.12) ; UV1.V11 143.06,154.7 v1(143.06,154.55) ; UV8.E3 151.8,183.07 v1(151.42,182.69) ; UC1.AT56 v3(77.31,85.75) ; UC1.BA49 v3(82.01,84.1) UC1.AW49 ; v1(129.64,134.33) 129.98,134.66 130.07,134.76 UV1.A37 UV1.C39 UV1.E39 ; UC1.E56 v3(77.31,102.47) ; UC1.P21 97.32,97.35 v3(96.65,97.35) ; UC1.P21 UC1.T21 ; PC601.2 v3(219.77,151.2) ; UTPM1.2 115.42,121.53 UTPM1.33 ; v3(243.06,177.59) 242.74,177.9 JWLBT.23 ; UV6.D10 v1(111.11,133.96) ; v1(131.96,138.79) 131.96,138.76 UV1.F31 ; UC1.AT63 v3(73.65,86.39) UC1.AR63 ; JWLBT.69 240.88,166.4 v3(240.72,166.56) ; UC1.AK68 70.83,90 v3(70.52,90) 70.34,89.82 UC1.AK69 ; UC1.AW23 v3(96.84,84.1) UC1.BA23 ; UC1.AM55 v3(78.22,88.31) ; UV5.T10 v1(111.11,165.18) ; UC1.D14 v3(101.88,103.48) UC1.B14 ; UC1.R13 102.57,96.77 v3(102.77,96.53) ; UC1.R13 UC1.T15 ; v1(135.21,162.07) 135.2,162.06 UV1.J2 ; UV1.N6 138.19,159.17 138.19,159.6 138.11,159.68 v1(138.11,159.73) ; v3(71.15,105.62) 71.15,105.48 71.47,105.15 UC1.A67 ; CC7.2 89.08,117.88 89.08,116.31 91.69,113.7 91.69,109.13 91.37,108.82 90.04,108.82 ; UV5.K2 v1(103.92,160.38) ; v3(85.54,86.39) UC1.AR42 ; v3(85.54,86.39) UC1.AT42 ; v3(85.54,86.39) UC1.AR43 ; UV7.U14 v1(139.8,173.89) ; CV153.2 125,181.7 125.69,181.01 126.92,181.01 UV7.B5 v3(127,181.89) ; UC1.AL2 108.4,88.86 v3(108.22,88.68) 108.04,88.86 UC1.AL4 ; RV29.2 165.59,155.82 v3(165.16,156.25) ; PR132.2 PC128.2 174.33,177.31 v3(173.92,177.71) ; v1(103.86,158.78) 104.26,159.18 UV5.H2 ; v3(96.51,101.2) UC1.G22 ; v3(96.51,101.2) 96.46,101.2 96.05,101.55 UC1.F23 ; v3(96.51,101.2) 96.54,101.2 96.97,101.56 UC1.F22 ; R91.2 239.17,164.78 v3(239.35,164.61) ; UC1.AR15 v3(101.08,86.39) ; v1(149.37,159.55) 149.76,159.16 UV1.AG6 ; UC1.U10 v3(104.67,95.46) ; RC352.2 79.88,117.49 v1(79.88,117.96) ; v1(107.25,136.66) 107.25,136.7 107.19,136.76 UV6.G5 ; UC1.J32 v3(91.02,101.2) ; RC6.2 75.05,114.02 74.73,113.7 74.42,113.7 73.74,113.03 73.74,112.09 v3(73.65,112) ; UV5.E1 102.97,156.78 102.84,156.91 ; UV7.M10 UV7.L10 134.6,177.54 v1(134.17,177.97) ; JWLBT.30 v3(248.24,176.15) ; PR436.1 75.37,128.5 v1(74.99,128.88) 74.8,128.69 74.8,128.5 PC424.2 ; UC1.AP58 v3(76.39,87.02) ; UV1.F39 133.24,133.96 v1(133.33,133.87) ; UV1.B13 130.03,153.36 v1(129.6,153.79) ; 90.11,87.86 UC1.AN35 UC1.AP35 ; 90.11,87.86 UC1.AL35 ; 90.11,87.86 UC1.AP35 ; 90.11,87.86 UC1.AN33 UC1.AP32 v3(91.94,87.66) ; UV8.R11 v1(160.2,176.29) UV8.R12 ; UV8.A12 148.42,175.89 v1(148.1,175.57) 147.3,174.77 RV71.2 ; UC1.AB15 101.54,93.69 v3(101.25,94.08) 100.93,93.69 UC1.AB16 ; UV7.C1 128.22,184.69 v1(128.6,184.31) ; UC1.W6 106.66,94.56 v1(106.66,94.39) ; UC1.L11 v3(104.04,98.53) ; UV7.D10 v1(128.6,177.09) ; UC1.AN32 v3(91.94,87.66) ; v3(91.94,87.66) UC1.AN30 ; UV6.R14 v3(114.51,143.16) ; UV1.AL6 UV1.AK7 151.95,158.36 v1(151.66,158.65) 151.65,158.66 151.65,158.91 UV1.AJ6 ; UV1.AH39 v3(150.4,133.31) ; J1.1 223.58,122.14 v3(224.26,121.45) ; UC1.U63 v3(73.93,95.62) UC1.U64 ; UV7.B10 v1(127,177.09) ; UV1.V39 142.37,133.93 142.37,133.39 142.42,133.34 v3(142.42,133.33) ; UC1.E46 v3(82.79,102.47) ; JWLBT.29 242.57,176.4 242.98,175.99 v3(242.98,175.66) 242.73,175.4 JWLBT.33 ; UV8.N1 158.2,185.21 v1(158.16,185.26) ; v1(158.6,183.49) UV8.N3 ; v1(133.13,145.87) 133.13,145.99 133.1,146.02 133.1,146.12 132.6,146.62 UV1.F21 ; UV5.R1 103.38,164.91 102.97,164.91 v1(102.81,165.08) ; v3(173.87,5.93) 174.21,6.28 PQ201.1 ; UC1.AJ15 102.13,90.31 UC1.AH13 102.74,90.16 v3(102.72,90.06) ; PD5.2 243.76,160.66 v3(244.4,160.01) 243.82,159.42 PR8.2 ; v1(105.18,131.43) 105.11,131.49 UV6.A3 ; v1(154.13,149.49) 154.13,149.66 154.6,150.13 UV1.AN17 ; UC1.AR55 v3(78.22,86.39) ; v1(147.81,162.02) 147.96,161.86 147.96,161.2 UV1.AE2 ; v3(156.24,185.1) 156.21,185.1 UV8.K1 ; v1(103.11,158.78) UV5.H1 ; PQ105.3 170.91,165.27 v3(170.74,165.27) 170.57,165.27 170.31,165.01 PR110.1 ; UV6.T5 107,143.96 v1(107.35,144.31) ; UC1.G43 85.08,100.93 UC1.J42 ; UC1.G43 v3(84.62,101.2) ; UC1.G43 85.4,101.26 85.66,101.26 UC1.F42 ; v3(240.67,168.01) 240.78,167.9 JWLBT.63 ; UV7.E14 v1(129.8,173.69) ; UV6.B10 110.32,132.76 v1(110.19,132.63) ; UC1.F35 89.19,101.13 ; 89.19,101.13 UC1.F37 88.59,101.74 87.97,101.74 UC1.F38 ; 89.19,101.13 UC1.J35 ; UC1.J8 v3(104.74,99.93) ; UV8.H2 154.2,183.94 v1(153.8,184.34) ; UC1.B53 v3(79.58,103.48) UC1.D53 ; UV6.A12 112.31,131.47 v1(112.22,131.38) ; UV6.U14 v1(114.31,145.16) ; UC1.G66 v3(71.51,101.2) ; UV7.A1 v1(126.2,185.09) ; UC1.E71 68.5,102.55 v3(68.38,102.68) ; v1(129.98,156.63) 130.05,156.56 UV1.B9 ; v1(143.03,162.24) 143.11,162.16 143.11,161.93 143.21,161.83 143.21,161.17 UV1.W2 ; UC1.L16 v3(100.58,98.27) UC1.L17 ; UC1.G55 v3(78.22,101.2) ; UC1.AT20 v3(98.34,85.75) UC1.AU20 ; v3(149.41,133.77) 148.99,133.77 UV1.AF39 ; v1(152.8,162.04) UV1.AL2 ; UC1.AM8 105.17,88.71 v3(104.73,88.31) ; UC1.AM43 UC1.AL45 UC1.AM45 ; UV6.N3 105.31,141.56 105.71,141.16 105.75,141.16 105.75,141.16 106.08,141.16 106.08,141.16 106.31,141.16 UV6.M5 107.21,140.76 v1(107.22,140.76) ; UV8.C14 150.07,174.16 150.07,173.74 v1(150.13,173.69) ; v3(184.03,172.58) 183.75,172.86 PC116.2 ; v3(240.75,181.68) 240.97,181.9 JWLBT.7 ; v1(151.67,185.36) 151.8,185.23 UV8.E1 ; UV8.P10 v1(158.6,177.09) ; RV46.2 113.44,152.28 v1(112.64,153.08) 112.31,153.4 UV5.A12 ; UC1.AD62 75.06,92.87 v3(75.48,93.29) ; UV1.H39 134.35,133.91 v1(134.35,133.29) ; v3(172.04,4.76) 172.05,4.78 PQ201.4 ; v1(136.61,183.55) 136.61,183.5 UV7.N3 ; v1(134.27,180.84) 134.6,181.17 UV7.L5 ; UC1.B66 v3(72.14,103.48) UC1.D66 ; v3(236.48,150.1) 236.66,150.1 JU3LC.15 ; 99.93,91.56 UC1.AG18 99.29,90.83 99.16,90.83 98.96,91.03 UC1.AG19 98.82,91.01 98.45,91.01 UC1.AG20 98.31,91.05 v3(97.98,90.72) 98.31,90.4 UC1.AJ20 ; 99.93,91.56 UC1.AF17 100.6,92.32 v3(100.6,92.4) UC1.AD16 100.49,93.24 99.94,93.24 UC1.AB18 ; UV7.T5 138.6,181.28 138.86,181.02 v1(138.86,180.98) ; UV6.H1 v1(103.11,137.16) ; UV6.H2 v1(103.91,137.16) ; UC1.G48 v3(81.88,101.2) ; UV7.N14 136.03,174.12 136.03,173.76 v1(136.07,173.73) ; v3(233.53,147.23) 233.53,146.87 JU3LC.6 ; v1(91.5,118.85) 91.05,119.29 91.05,120.18 90.5,120.73 YC2.4 ; RV194.2 115.22,136.58 114.64,137.16 v1(114.31,137.16) UV6.H14 ; UC1.BA62 v3(74.65,84.1) UC1.AW62 ; UV5.T5 v1(106.33,165.2) ; v1(157.92,143.52) 157.92,143.38 157.8,143.26 UV1.AW26 ; UC1.G6 v3(105.65,101.2) ; UC1.AR20 v3(98.34,86.39) ; UV6.M10 UV6.L10 v1(110.17,139.96) ; v1(110.24,157.94) 110.33,157.94 110.71,158.32 UV5.G10 ; UC1.AW41 v3(86.9,84.1) UC1.BA41 ; UC1.L4 108.04,99.46 v3(108.22,99.29) 108.4,99.46 UC1.L2 ; UC1.K22 96.91,100.01 96.65,99.76 v3(96.65,99.51) ; UV5.F10 v1(111.11,157.18) ; UC1.AP35 UC1.AR35 v3(89.19,86.39) UC1.AT35 ; UV6.F5 107.28,135.96 v1(107.34,136.02) ; UV6.K13 v1(113.51,139.56) UV6.K14 114.05,139.02 115.44,139.02 115.88,139.45 RV32.2 CV79.2 ; UC1.G58 v3(76.39,101.2) ; UV5.G5 107.47,158.38 v1(107.57,158.48) ; Q24.1 v3(132.96,44.87) ; v3(79.19,48.89) 78.11,48.89 77.92,49.09 77.92,50.35 JDIMM2.61 ; UV1.W6 142.63,158.79 142.63,158.77 142.48,158.63 v1(142.33,158.63) 142.08,158.63 141.82,158.88 141.64,158.88 141.4,159.12 UV1.U6 ; UC1.AR5 v3(106.57,86.39) ; UC1.V18 99.82,95.55 100.04,95.55 UC1.V17 ; UC1.E21 v3(97.42,102.47) ; v3(99.25,100.56) UC1.H18 UC1.K18 ; v3(102.91,86.39) UC1.AR11 ; UV1.B17 130.54,150.1 130.52,150.1 130.51,150.11 129.89,150.11 129.88,150.1 129.74,150.1 v1(129.62,149.98) ; UC1.B48 v3(82.06,103.48) UC1.D48 ; v3(240.42,174.28) 240.8,173.9 JWLBT.39 ; UC1.B44 84.53,103.6 v3(84.66,103.47) 84.53,103.34 UC1.D44 ; v1(107.37,139.63) 107.04,139.96 UV6.L5 ; UV1.K14 135.8,152.33 v1(135.41,151.94) ; v1(146.15,162.27) 146.38,162.03 146.38,161.17 UV1.AC2 ; UV1.AL32 152.98,137.96 v1(152.59,138.36) 152.2,138.74 UV1.AK31 ; v1(107.37,161.58) UV5.L5 ; v1(132.04,140.22) 132.17,140.36 UV1.F29 ; UC1.AW18 v3(99.28,83.92) UC1.BA18 ; PR619.1 208.08,147.46 208.08,147.79 v3(208.44,148.15) ; UC1.W9 v3(105.31,94.39) ; UC1.U70 v3(70.03,95.62) UC1.U69 ; UC1.N10 104.67,97.6 v3(104.67,97.59) ; v3(114.31,152.96) 114.28,152.96 113.97,153.27 113.97,153.37 113.91,153.42 UV5.A14 ; UV7.C4 v1(128.6,182.69) UV7.C3 ; v1(104.9,152.99) 105.11,153.2 UV5.A3 ; UC1.B22 v3(96.92,103.48) UC1.D22 ; v1(89.59,121.52) 88.32,121.52 88,121.2 88,120.25 88.62,119.63 YC2.2 ; UC1.U67 v3(71.98,95.62) UC1.U66 ; v3(107.84,105.62) 107.75,105.62 107.42,105.29 UC1.A5 ; v3(213.52,143.78) 213.65,143.91 PC637.1 ; 170.11,169.74 v3(169.6,169.23) 169.96,168.87 PC125.1 ; 170.11,169.74 PC126.1 ; UC1.F13 v3(101.99,101.83) 101.96,101.83 101.54,102.21 UC1.E15 ; UV7.N1 136.2,185.21 v1(136.16,185.26) ; UV7.U3 139.77,182.72 140.11,182.72 v1(140.11,182.7) ; UC1.R6 v3(107.23,96.53) ; UC1.G5 v3(106.57,101.2) ; v3(102.77,92.26) 102.57,92.51 UC1.AD13 ; UV6.U1 v1(103.11,145.16) ; PC402.2 77.48,124.75 77.78,125.06 v3(77.78,125.21) 77.73,125.21 77.32,125.62 PC401.2 ; UV5.C1 v1(103.06,154.73) ; v1(146.12,159.63) 146.12,159.62 146.58,159.16 UV1.AC6 ; UV1.L11 136.6,155.41 v1(136.33,155.68) ; v1(130.04,161.35) 130.05,161.35 130.05,161.33 130.2,161.18 UV1.A3 ; v3(68.46,104.81) 68.77,104.5 UC1.B71 UC1.A70 ; v3(248.21,174.94) 248.42,174.94 248.71,174.65 JWLBT.36 ; UC1.AP18 99.69,87.38 v3(99.25,87.02) ; UC1.AN58 v3(76.39,87.66) ; UC1.F28 v3(93.77,101.83) UC1.F27 ; UV1.B23 130.56,145.4 130.54,145.4 130.48,145.35 129.69,145.35 v1(129.57,145.23) ; v1(132.43,148.26) 132.43,148.26 132.43,148.26 132.6,148.43 UV1.F19 ; UC1.AR45 v3(83.71,86.39) ; UC1.BA53 v3(79.61,84.1) UC1.AW53 ; PC103.1 v3(223.04,157.42) ; v1(161.09,180.58) 161.09,180.79 160.6,181.28 UV8.T5 v1(160.22,181.87) UV8.R4 159.65,182.45 159.65,182.93 UV8.R3 ; UV8.A3 148.22,183.09 v1(148.01,183.3) ; JU3LC.3 232.62,145.66 232.36,145.66 v3(232.14,145.89) ; v1(114.41,141.39) 114.08,141.39 UV6.N14 ; UV8.M5 157.4,180.99 v1(157.4,180.99) ; v1(129.65,148.54) 129.67,148.56 UV1.B19 ; UV7.G10 131.34,177.49 v1(130.99,177.84) ; UV7.U1 v1(139.8,185.09) ; UC1.BA36 v3(89.38,84.1) UC1.AW36 ; UC1.AT58 v3(76.39,86.39) UC1.AR58 ; v1(155.89,156.41) 155.88,156.41 155.53,156.76 UV1.AP9 ; v3(73.28,93.79) UC1.AA65 ; UV6.A14 114.31,131.56 114.92,131.56 v1(115.32,131.96) ; v1(106.34,154.01) UV5.B5 ; v3(248.19,177.54) 248.31,177.65 JWLBT.24 ; UV8.E14 v1(151.8,173.69) 151.8,172.33 CV166.2 ; UC1.AP63 v3(73.65,87.02) ; UV6.K1 103.36,139.16 103.3,139.22 102.95,139.22 102.86,139.31 v1(102.57,139.31) ; v3(106.49,89.05) 106.36,89.18 106.12,89.18 UC1.AK8 ; UV8.A14 148.45,174.29 148.39,174.23 148.29,174.23 147.98,173.92 v3(147.98,173.89) ; v3(101.08,100.56) UC1.H15 ; UV7.G5 131.4,181.01 131.34,180.95 v1(131.31,180.95) ; UC1.G63 v3(73.55,101.2) ; PC703.2 v3(145.9,48.35) ; v1(156.6,180.84) UV8.L5 ; UC1.AL66 72.31,88.78 v3(71.82,88.29) ; UV1.AP18 155.38,149.58 154.91,149.58 154.84,149.51 v3(154.79,149.51) 154.67,149.39 154.67,149.03 UV1.AN19 ; UV5.C11 v1(111.91,154.78) ; UV1.T39 140.8,133.76 140.9,133.66 v1(140.9,133.42) ; UV8.R1 v1(160.2,185.09) ; UC1.AT2 108.4,86.21 v3(108.22,86.03) 108.04,86.21 UC1.AT4 ; v1(133.08,150.76) 132.67,150.36 UV1.F17 ; UV1.AK39 152,133.72 151.69,133.42 v3(151.67,133.42) ; UV7.H13 v1(131.8,174.69) ; UC1.B10 v3(104.36,103.48) UC1.D10 UC1.D11 v3(102.91,102.47) UC1.E11 ; UV1.P39 139.2,133.77 139.53,133.44 v1(139.53,133.42) ; v1(152.96,177.96) 152.96,177.87 153.34,177.49 UV8.G10 ; UC1.AK16 v3(101.08,88.93) ; UV8.U3 161.77,182.72 162.34,182.72 v1(162.56,182.94) ; v3(89.57,106.21) 89.97,105.81 89.97,105.28 89.84,105.15 89.84,104.37 89.49,104.03 UC1.B34 UC1.D34 ; v1(107.22,162.38) 107.21,162.38 UV5.M5 106.31,162.78 105.75,162.78 105.71,162.81 105.68,162.81 105.31,163.18 UV5.N3 ; v1(144.5,158.72) 144.52,158.72 144.52,158.73 144.95,159.16 UV1.AA6 ; UC1.AW10 v3(104.12,84.1) UC1.BA10 ; UC1.AD19 98.75,92.61 98.51,92.61 UC1.AD20 ; UC1.AP10 v3(103.82,87.02) ; UV8.B10 v1(149,177.09) ; UC1.BB6 UC1.BA6 ; PC605.2 205.9,153.28 205.57,152.95 v3(205.57,152.85) 206,152.41 PC604.2 ; UV7.M5 135.4,180.99 v1(135.4,180.99) ; UV5.A1 v1(103.11,153.18) ; v3(190.91,184.82) 191.06,184.67 PR805.2 ; UV6.G10 110.6,136.64 110.6,136.26 110.71,136.14 UV6.F10 v1(111.15,135.52) ; UV5.N12 v1(112.71,162.78) ; UV6.T10 v1(111.11,143.56) ; UV8.U1 v1(161.8,185.09) ; UC1.AA4 108.04,94.16 v3(108.22,93.98) 108.4,94.16 UC1.AA2 ; PC417.2 v3(71.91,128.97) ; v1(161.02,174.72) 161.02,174.67 UV8.U14 ; UV1.AP17 155.35,150.36 154.87,150.84 v1(154.87,150.87) 155.05,150.87 155.35,151.16 UV1.AP16 ; UC1.AU38 v3(87.36,85.12) ; UC1.N65 73.08,97.73 v3(73.28,97.45) ; UV1.F23 132.39,145.16 v1(132.11,145.44) ; UC1.G45 v3(83.71,101.2) ; UV7.F10 v1(130.2,177.09) ; PC313.2 v3(130.64,12.26) ; v1(133.38,174.66) 133.8,175.08 UV7.K13 v1(134.2,174.69) UV7.K14 ; UV5.C4 105.91,155.18 v1(105.51,155.58) UV5.C3 ; UV5.B10 v1(111.11,153.98) ; UV1.AE6 148.2,159.47 v1(147.94,159.73) ; UC1.AR46 v3(82.79,86.39) ; UV8.K2 v1(155.4,184.29) ; UC1.AA68 v3(71.33,93.79) ; UC1.D18 v3(99.4,103.48) UC1.B18 ; PC318.2 133.33,41.49 v3(133.74,41.09) ; UC1.G65 72.75,101 v3(72.52,101.23) 72.94,101.65 UC1.F65 ; PR705.2 v3(137.34,44.97) ; UV7.A12 126.42,175.89 v1(126.1,175.57) 125.88,175.35 RV58.2 ; v3(84.42,84.1) UC1.BA45 ; PC115.2 v3(181.26,167.71) ; RV70.2 156.04,171.11 CV160.2 155.66,172.35 155.66,174.15 UV8.K14 v1(156.2,174.69) UV8.K13 155.8,175.09 v1(155.4,174.69) ; UC1.K16 v3(101.25,99.11) ; UC1.BA14 v3(101.7,83.95) UC1.AW14 ; UC1.AK11 v3(104.04,89.21) ; UV7.R1 v1(138.2,185.09) ; UC1.AR50 v3(80.96,86.39) UC1.AR52 v3(80.05,86.39) ; UV5.D10 v1(111.11,155.58) ; UC1.G60 v3(75.48,101.2) ; UV8.H13 v1(153.8,174.69) ; UC1.AR16 v3(100.17,86.39) ; PC117.1 173.82,166.97 v3(173.44,166.59) 173.92,166.11 PR115.1 ; UV5.C12 v1(112.71,154.78) ; UV8.A1 v1(148.2,185.09) ; v3(101.99,88.29) 102.03,88.29 102.45,88.68 UC1.AM13 ; JWLBT.1 241,183.4 v3(240.39,184.01) ; v1(91.12,107.74) 91.88,107.74 92.7,108.56 92.7,115.61 91.45,116.87 CC6.2 ; PC701.2 v3(140.04,43.91) ; UV5.E12 v1(112.71,156.38) ; UC1.AP20 v3(98.34,87.02) ; UV1.AW16 157.94,151.1 v1(157.94,151.5) ; JWLBT.18 v3(248.24,179.15) ; UC1.G52 v3(80.05,101.2) ; UC1.AU32 v3(91.02,85.1) ; UC1.AM46 UC1.AL48 ; UV7.C11 v1(127.8,176.29) ; UV6.E14 v1(114.51,135.16) ; v3(72,90.13) UC1.AH67 ; UV6.H13 v1(113.51,137.16) ; v3(71.33,97.45) 71.13,97.73 UC1.N68 ; PQ4.4 v3(240.58,158.22) ; UV7.K2 v1(133.4,184.29) ; UV6.N1 103.38,141.7 103.05,141.7 v1(102.98,141.77) ; UV1.AG2 149.6,161.22 149.56,161.26 149.56,162.48 v1(149.59,162.5) ; v1(158.07,173.73) 158.03,173.76 158.03,174.12 UV8.N14 ; v1(114.51,155.11) 114.46,155.05 114.04,155.05 UV5.C14 ; UV1.U2 141.64,161.2 141.64,161.24 141.63,161.24 141.63,162.12 v1(141.65,162.14) ; v1(128.13,173.69) 128.07,173.74 128.07,174.16 UV7.C14 ; UV7.H1 v1(131.8,185.09) ; UV7.E3 v1(130.16,183.45) ; UC1.AD8 v3(105.94,92.26) ; UV7.R3 v1(138.2,182.69) 137.8,182.29 UV7.R4 ; UV8.E12 v1(151.4,175.49) ; UV5.H14 v1(114.31,158.78) ; UC1.N6 v3(107.23,97.59) ; PC315.2 v1(131.43,40.02) ; UC1.AR53 v3(79.13,86.39) ; v1(145.78,136.95) 145.99,136.95 146.57,136.36 UV1.AC34 ; UC1.E6 v3(105.65,102.47) ; UC1.AR48 v3(81.88,86.39) ; v1(133.12,151.85) 133.08,151.85 133.08,151.86 133.03,151.9 132.66,151.9 UV1.F15 ; UV6.N12 v1(112.71,141.16) ; v3(74.56,102.47) 74.62,102.52 UC1.D62 v3(74.62,103.48) UC1.B62 ; UC1.AM60 v3(75.48,88.31) ; v3(101.08,85.12) UC1.AU15 ; UC1.E65 v3(72.53,102.47) ; UC1.D25 94.49,103.01 UC1.D26 v3(94.45,103.48) ; v3(243.08,164.9) JWLBT.75 ; UV8.F10 v1(152.2,177.09) ; v1(154.16,142.43) 153.53,142.43 UV1.AL26 ; UV6.K2 v1(103.92,138.76) ; UV5.E14 v1(114.51,156.78) ; v1(135.44,133.42) 135.44,133.4 UV1.K39 ; UC1.F8 v3(104.74,101.83) ; UC1.AW57 v3(77.13,84.1) UC1.BA57 ; UV7.H2 v1(131.8,184.29) ; UV6.C12 v1(112.76,134) ; UV1.AM31 153.8,138.76 v1(154.2,138.36) 154.6,137.96 UV1.AN32 ; UV1.AL23 153,145.43 v3(152.51,145.92) ; UV8.C11 v1(149.8,176.29) ; UV6.E12 v1(112.71,134.76) ; v3(68.36,84.14) 68.97,84.75 UC1.AV71 UC1.AV70 UC1.AV69 v3(70.86,84.75) UC1.AV68 71.34,84.91 71.78,84.48 v3(71.82,84.48) ; UC1.E53 v3(79.13,102.47) ; UV7.E12 v1(129.4,175.49) ; UV5.H13 v1(113.51,158.78)
  BOTTOM w0.305: v3(77.74,35.78) 77.92,35.96 JDIMM1.61 ; JDIMM1.190 119.02,30.59 v3(119.28,30.85) ; JDIMM1.134 102.22,28.95 102.22,30.3 v3(102.28,30.37) ; JDIMM1.139 103.72,37.15 103.72,35.88 v3(103.45,35.61) ; v3(74.29,35.68) 74.32,35.7 JDIMM1.49 ; UV1.AM9 153.75,156.76 v1(153.37,157.14) 153.37,157.16 153,157.54 UV1.AL8 ; UV1.AJ28 151.6,141.16 v1(152.33,141.16) ; UV1.T31 140.25,138.76 v1(139.81,139.21) 139.36,138.76 UV1.P31 UV1.N31 ; v3(117.22,30.33) 117.22,28.95 117.22,28.95 JDIMM1.184 ; JDIMM2.44 72.82,43.3 v3(72.62,43.5) ; JDIMM1.156 108.82,28.95 108.82,28.95 v3(108.82,30.43) ; UV1.AP9 UV1.AN10 ; JDIMM1.60 77.62,30.39 v3(77.7,30.47) ; JDIMM2.72 81.22,41.3 v3(80.68,40.76) ; v3(117.3,43.52) 117.22,43.44 117.22,42.15 JDIMM2.184 ; JDIMM2.144 105.22,42.15 105.22,43.5 v3(105.24,43.52) ; v3(61.52,43.58) 62.02,43.08 JDIMM2.8 ; UV1.AN6 154.6,159.16 v1(155,158.77) 155.02,158.77 155.4,158.39 UV1.AP7 UV1.AN8 ; JDIMM1.65 79.12,38.34 78.81,38.65 78.54,38.65 78.54,38.65 v3(78.52,38.65) JDIMM1.63 ; JDIMM1.3 v3(60.52,35.68) ; v3(120.82,30.33) 120.82,28.95 120.82,28.95 JDIMM1.196 ; JDIMM1.162 110.62,28.95 110.62,28.95 v3(110.62,30.33) ; v3(101.67,40.69) 102.22,41.24 102.22,42.15 JDIMM2.134 ; v3(62.06,35.81) 62.32,36.07 JDIMM1.9 ; v3(103.35,30.47) 103.42,30.4 103.42,28.95 103.42,28.95 JDIMM1.138 ; JDIMM1.20 65.62,28.95 v3(65.62,30.33) ; JDIMM2.43 72.52,48.84 71.86,48.18 v3(71.41,48.18) ; JDIMM1.185 117.52,37.15 117.52,36 117.49,35.97 v3(117.49,35.77) ; JDIMM2.155 108.52,51.55 v3(108.3,51.77) ; v3(120.52,48.88) JDIMM2.195 120.52,51.26 v3(119.68,52.1) 119.25,52.1 118.72,51.58 JDIMM2.189 ; JDIMM2.153 107.92,49.25 107.68,49.01 107.68,48.94 v3(107.64,48.91) 107.62,48.91 107.32,49.21 JDIMM2.151 ; v3(110.14,162.12) 110.45,162.12 UV5.M10 ; JDIMM1.150 107.02,28.95 107.02,28.95 v3(107.02,30.34) ; v3(107.09,40.78) 107.02,40.86 107.02,42.15 JDIMM2.150 ; JDIMM2.173 113.92,52.13 113.93,52.14 ; JDIMM2.161 110.32,49.14 v3(110.5,48.96) ; v3(249.43,158.89) 249.21,158.89 248.72,159.37 CRF21.2 CRF22.2 ; v3(120.88,43.67) 120.82,43.61 120.82,43.61 120.82,42.15 JDIMM2.196 ; UTPM1.23 115.42,117.5 115.09,117.18 115.09,116.98 v3(115.08,116.98) ; JDIMM1.168 112.42,28.95 112.42,28.95 v3(112.42,30.33) ; JDIMM1.153 107.92,37.15 107.92,38.05 108.13,38.27 v3(108.13,38.85) ; v3(76.18,48.63) 76.12,48.69 JDIMM2.55 ; JDIMM1.26 v3(67.42,30.34) ; JDIMM1.136 102.82,28.95 102.82,27.59 v3(102.81,27.58) ; UV1.AG9 150.12,156.76 v1(150.6,156.28) 150.92,155.96 UV1.AJ10 ; JDIMM1.43 v3(72.52,35.78) ; v3(114.51,164.78) 114.51,164.78 UV5.R14 ; UV5.R12 v1(111.91,165.18) UV5.R11 ; v3(87.76,130.8) v3(87.76,131.69) 87.91,131.83 87.91,132.62 R18.2 ; v3(60.09,43.59) 60.22,43.46 JDIMM2.2 ; v3(101.78,48.91) 101.92,49.04 101.92,50.35 JDIMM2.133 ; UV1.AM35 153.51,135.65 152.9,135.65 v1(152.84,135.71) 152.84,136.2 UV1.AL34 ; v3(119.01,40.77) 119.01,42.14 JDIMM2.190 ; v3(65.41,48.99) 65.32,49.08 JDIMM2.19 ; 67.42,43.66 JDIMM2.26 ; 67.42,43.66 v3(67.41,43.67) ; 67.42,43.66 68.02,43.06 JDIMM2.28 ; v3(115.47,43.52) 115.42,43.47 JDIMM2.178 ; JDIMM2.14 63.82,43.36 v3(63.68,43.5) ; v3(229.98,145.73) 229.98,145.32 R107.1 ; JDIMM1.38 v3(71.02,27.24) ; v3(158.02,142.2) 157.98,142.16 UV1.AV27 ; JDIMM1.173 113.92,38.4 113.87,38.44 v3(113.87,38.6) ; JDIMM1.179 115.72,35.92 v3(115.53,35.73) ; v3(68.01,27.5) 68.02,27.51 JDIMM1.28 ; UV5.N14 114.35,163.18 v1(114.48,163.05) ; UV1.AF10 148.8,156.1 148.29,156.6 148.26,156.6 v1(148.22,156.55) 148.17,156.6 147.73,156.6 147.6,156.73 UV1.AD9 ; JDIMM2.38 71.02,43.53 v3(70.97,43.58) ; v3(220.99,149.37) 221.44,149.82 PR643.2 ; v3(80.92,48.86) JDIMM2.71 ; v3(104.04,48.83) 103.72,49.16 JDIMM2.139 ; UC1.BA6 v3(106.54,84.1) 106.5,84.15 UC1.AW6 ; JDIMM2.170 113.02,43.32 112.71,43.62 v3(112.42,43.62) 112.42,43.62 112.42,42.15 JDIMM2.168 ; UV5.U14 v1(114.31,166.78) ; v3(108.52,35.75) JDIMM1.155 ; JDIMM1.128 100.42,28.95 100.42,30.46 v3(100.43,30.47) ; JDIMM2.187 118.12,49.39 v3(117.79,49.06) 117.52,49.32 JDIMM2.185 ; JDIMM2.37 70.72,49.44 70.39,49.11 v3(70.39,48.63) ; v1(110.24,161.15) 110.67,161.58 UV5.L10 ; JDIMM1.19 v3(65.32,35.78) ; UTPM1.9 v3(119.82,122.03) ; JDIMM1.187 118.12,37.15 118.06,37.22 v3(118.06,38.57) ; JDIMM2.162 110.62,43.5 v3(110.57,43.55) ; v1(152.63,155.49) 152.2,155.05 UV1.AK11 UV1.AJ11 ; JDIMM2.179 115.72,51.61 v3(115.6,51.73) ; JDIMM2.49 74.32,49.41 v3(73.82,48.91) ; JDIMM1.172 113.62,28.95 113.62,28.95 v3(113.62,30.33) ; JDIMM1.72 81.22,28.95 81.22,30.44 v3(81.25,30.47) ; v1(114.17,122.6) 114.32,122.45 UTPM1.32 ; v3(97.33,92.4) 97.21,92.28 97.21,91.66 97.66,91.21 UC1.AG21 97.66,91.05 v3(97.98,90.72) ; v3(59.67,48.3) 59.85,48.3 60.52,48.97 JDIMM2.3 ; v1(148.14,136.95) 148.2,136.89 UV1.AE34 ; JDIMM1.127 v3(100.12,35.75) ; JDIMM2.9 62.32,49.17 v3(62.16,49.01) ; JDIMM1.54 75.82,28.95 v3(75.82,30.31) ; JDIMM1.195 120.52,37.15 120.52,38.41 v3(120.64,38.53) ; JDIMM2.167 112.12,49.17 v3(112.32,48.96) ; v3(118.76,35.77) 118.72,35.81 118.72,37.15 JDIMM1.189 ; v3(105.52,35.7) 105.52,37.15 JDIMM1.145 ; v3(113.02,27.56) 113.02,28.95 JDIMM1.170 ; v3(79.19,48.89) 79.12,48.97 JDIMM2.65 79.12,51.46 v3(78.83,51.76) 78.52,51.45 JDIMM2.63 ; v1(111.11,163.58) UV5.P10 ; JDIMM1.37 v3(70.72,38.6) ; v1(154.74,154.4) 154.74,154.82 UV1.AN11 154.8,155.16 UV1.AP11 ; JDIMM1.31 v3(68.92,35.78) ; JDIMM2.145 105.52,51.47 v3(105.29,51.7) ; JDIMM1.48 74.02,28.95 74.02,30.46 v3(74.01,30.47) ; v3(79.73,30.61) 79.42,30.3 79.42,28.95 JDIMM1.66 ; UV1.AC11 146.61,155.16 147.1,154.68 v3(147.1,154.65) ; v1(154.21,136.77) 154.21,136.69 154.54,136.36 UV1.AN34 ; JDIMM2.138 103.42,42.15 103.42,43.6 v3(103.35,43.67) ; v3(107.58,38.5) 107.32,38.24 JDIMM1.151 ; UV1.AM11 153.8,155.03 v1(153.37,155.46) 153,155.09 UV1.AL11 ; v3(102.98,40.63) 102.9,40.71 102.89,40.71 102.82,40.78 102.82,42.15 JDIMM2.136 ; UV5.K14 v1(113.51,160.37) ; JDIMM2.60 v3(77.62,40.76) ; JDIMM1.44 v3(72.82,30.36) ; JDIMM2.128 100.42,40.79 v3(100.31,40.68) ; JDIMM2.156 108.82,42.15 108.82,43.44 v3(108.7,43.56) ; JDIMM2.13 63.52,49.23 63.07,48.78 v3(62.79,48.78) 62.79,49.09 62.92,49.21 JDIMM2.11 ; v3(80.76,35.78) 80.92,35.94 JDIMM1.71 ; JDIMM2.20 65.62,43.61 v3(65.7,43.69) ; JDIMM1.178 115.42,30.25 v3(115.48,30.31) ; v1(153.5,149.55) 153.5,149.66 UV1.AL17 ; v3(102.22,35.65) 101.92,35.95 101.92,37.15 JDIMM1.133 ; JDIMM2.66 v3(79.42,40.69) ; JDIMM1.13 63.52,35.89 v3(63.4,35.78) 63.38,35.8 63.23,35.8 62.92,36.11 JDIMM1.11 ; UV5.K13 v1(113.51,161.18) ; JDIMM1.25 v3(67.12,35.71) ; v1(156.55,160.29) 156.52,160.29 156.1,159.87 UV1.AR5 ; v3(76.47,44.27) 76.17,44.27 75.82,43.93 JDIMM2.54 ; v3(105.26,30.47) 105.22,30.44 JDIMM1.144 ; JDIMM2.46 73.42,43.18 v3(73.92,43.68) ; JDIMM2.25 67.12,49.45 v3(66.66,48.99) ; v3(69.12,49.01) 68.92,49.21 JDIMM2.31 ; UV1.H9 v1(133.8,157.16) ; v3(69.36,43.63) 69.22,43.49 JDIMM2.32 ; v3(76.12,35.75) JDIMM1.55 ; v1(158.17,149.9) 157.91,150.16 UV1.AV17 ; v3(100.12,48.93) JDIMM2.127 ; v3(69.22,27.32) JDIMM1.32 ; v3(113.62,40.73) JDIMM2.172 ; 74.02,43.58 JDIMM2.48
  BOTTOM w0.356: JDIMM1.2 v3(60.22,30.32) ; JDIMM1.14 v3(63.82,30.34) ; JDIMM1.8 v3(62.02,30.33) ; v1(149.12,145.78) 149.5,146.16 UV1.AG22 UV1.AH21
  BOTTOM w0.381: CV98.2 103,137.27 v1(103.11,137.16) ; v3(167.44,156.63) 167.44,155.64 CV77.2 ; UV1.AC23 146.6,145.26 v1(147.1,145.76) 147.2,145.76 UV1.AD22 148.09,146.66 v1(148.21,146.66) 148.21,146.77 UV1.AF21 148.6,147.27 v1(149.06,147.73) 149.17,147.73 UV1.AG20 ; CV118.2 101.2,158.78 v1(103.11,158.78) ; 113.87,92.19 RC378.2 ; 113.87,92.19 113.9,92.17 v3(113.9,91.3) ; 113.87,92.19 RC384.2 ; CC6.2 91.45,118.8 v1(91.5,118.85) ; v1(146.08,151.71) 146.05,151.71 UV1.AB15 ; v3(114.69,97.86) 115.25,98.41 RC386.2 ; v3(42.07,119.42) DL1.3 v3(39.6,119.42) ; UV1.AC13 146.6,153.09 145.67,152.16 UV1.AB15 ; RV45.2 117.18,164.77 v3(117.18,165.32) ; UV1.T11 140.2,154.76 v1(140.2,154.62) ; v1(114.51,155.11) 114.51,154.92 116.05,153.39 CV130.2 ; UV1.AC28 146.6,141.29 v1(146.97,141.66) 147.47,142.16 UV1.AD27 ; UV1.J8 UV1.H9 ; v1(148.09,144.82) 148.09,144.72 147.6,144.24 UV1.AD24 147.24,143.8 v1(147.1,143.8) 146.6,143.31 UV1.AC26 UV1.AB27 145.46,142.16 v1(145,141.7) 144.6,141.3 UV1.AA28 ; RV130.1 163.38,155.87 v3(163.46,155.95) ; UV1.G6 133.42,159.16 v1(133.79,158.79) ; PC808.2 v3(174.96,177.84) ; C8497.2 C8496.2 114.13,114.87 113.62,114.37 v3(113.62,114.16) ; v1(132.06,154.78) 132.44,155.16 UV1.F11 ; CV128.2 102.07,154.29 102.52,154.73 v1(103.06,154.73) ; v3(134.6,158.76) 135,159.16 UV1.J6 UV1.K7 ; CV76.2 137.5,129.68 v3(138.18,129) ; UV1.AB15 145.49,152.16 v1(145.03,151.69) 144.6,151.27 UV1.AA16 144.6,151.02 143.74,150.16 UV1.Y17 143.14,149.7 v1(143.08,149.7) 142.6,149.21 UV1.V18 142.17,148.73 142.17,148.63 141.7,148.16 UV1.U20 141.16,147.72 v1(141,147.72) 140.6,147.32 UV1.T21 140.16,146.72 140.16,146.66 139.66,146.16 UV1.R22 UV1.N23 UV1.M24 137.05,143.61 v1(137.04,143.61) 136.99,143.61 136.6,144 UV1.L24 ; RC32.1 85.6,117.46 86.04,117.9 v1(86.42,117.9) ; CV86.2 101.17,139.31 v1(102.57,139.31) ; v1(112.22,131.38) 112.22,131.23 112.85,130.6 RV33.2 ; UV1.AL20 153,147.8 v1(153.42,148.22) ; v1(141.06,141.57) 141.6,142.11 UV1.U27 UV1.V26 142.6,143.31 v1(143.06,143.77) 143.45,144.16 UV1.Y24 143.73,144.16 144.6,145.03 UV1.AA23 144.6,145.3 v1(144.99,145.69) 145.46,146.16 UV1.AB22 145.63,146.16 146.6,147.13 UV1.AC21 146.6,147.31 v1(147.02,147.73) 147.45,148.16 UV1.AD20 147.75,148.16 148.6,149.01 UV1.AF18 148.6,149.2 v1(149.1,149.7) 149.56,150.16 UV1.AG17 ; v1(148.09,151.5) 148.09,151.67 UV1.AD15 ; D12.3 15.4,65.32 v3(15.47,65.39) ; UV7.K14 133.66,174.15 133.66,172.76 134.09,172.33 CV133.2 RV57.2 ; JDIMM1.46 v3(73.42,27.51) ; v1(119.18,93.41) 119.31,93.54 119.31,94.07 118.95,94.43 RC71.2 ; v1(114.51,156.78) 114.84,156.78 116.24,155.38 RV198.2 ; PC441.2 66.54,115.04 v1(66.54,114.59) ; 164.65,129.2 164.33,129.2 163.56,129.97 CV18.2 163.56,130.96 v3(163.95,131.36) ; JDIMM1.161 v3(110.32,38.62) ; RV109.2 CV212.2 156.27,128.82 v3(156.39,128.69) ; RV25.2 136.61,129.17 v3(136.56,129.12) ; CV181.2 156.37,185.23 v3(156.24,185.1) ; UV1.AF16 UV1.AD17 147.49,150.16 v1(147.02,149.68) 147.02,149.58 UV1.AC18 146.6,149.08 146.16,148.64 146.08,148.64 UV1.AB20 145.46,148.16 v1(145.04,147.74) 145.04,147.6 UV1.AA21 144.26,146.82 144.26,146.66 144.09,146.66 UV1.Y22 UV1.V23 142.6,145.08 142.15,144.62 142.06,144.62 UV1.U24 141.58,144.16 141.04,143.62 v1(141,143.62) 140.98,143.6 140.98,143.54 UV1.T26 ; UV1.F7 133,157.96 v1(133,157.95) ; RC350.2 116.95,94.76 116.82,94.63 v3(116.82,94.05) ; CC7.2 88.76,118.22 v1(88.76,118.85) YC2.2 ; v3(143.14,141.72) 143.58,142.16 UV1.Y27 143.74,142.16 144.24,142.66 144.24,142.8 UV1.AA26 144.6,143.28 v1(145.04,143.72) 145.16,143.72 UV1.AB24 ; YC2.4 90.16,120.94 v1(89.59,121.52) ; v1(135.29,142.24) 135.29,142.05 UV1.J27 ; UV1.M22 UV1.N21 138.6,147.25 v1(139.07,147.72) 139.16,147.72 UV1.R20 139.74,148.16 140.19,148.61 140.19,148.75 UV1.T18 140.6,149.25 v1(141.03,149.68) 141.12,149.68 UV1.U17 141.72,150.16 142.18,150.62 142.18,150.74 UV1.V16 142.6,151.16 v1(143.13,151.69) 143.6,152.16 UV1.Y15 ; v3(121.01,93.49) 120.96,93.44 RC74.2 ; CV129.2 101.68,156.91 v3(102.42,156.91) 102.84,156.91 ; v3(112.12,35.78) JDIMM1.167 ; UV1.AB12 145.61,154.16 146.6,155.15 UV1.AC11 ; PRT404.2 v3(32.42,69.99) ; CV106.2 v3(116.46,165.3) ; UV1.W31 142.79,138.76 v3(142.15,138.11) 142.15,138.17 141.6,138.72 UV1.U31 141.45,138.76 141.44,138.76 v1(140.97,138.76) 140.97,138.76 UV1.T31 ; UV1.L17 136.6,150.13 v1(137.04,149.69) 137.51,150.16 UV1.M17 UV1.N16 139,151.56 v1(139,151.67) 139.48,152.16 UV1.R15 140.08,152.64 v1(140.1,152.64) 140.6,153.14 UV1.T13 ; v1(156.57,135.27) 156.68,135.16 156.68,135.08 UV1.AU37 ; CV119.2 101.58,160.97 v3(102.97,160.97) ; U150.2 v3(221.4,47.52) ; 99.35,95 v3(99.3,94.93) ; UV1.H31 UV1.J31 135,138.79 135.21,139 135.56,139 UV1.K31 135.8,138.73 136.03,138.5 v1(136.3,138.5) 136.57,138.5 136.8,138.73 UV1.L31 136.8,138.81 136.4,139.21 v1(136.26,139.21) ; UV1.N18 138.6,149.22 139.54,150.16 UV1.R17 139.75,150.16 140.14,150.55 140.14,150.7 UV1.T16 140.6,151.23 141.01,151.64 141.08,151.64 UV1.U15 141.6,152.2 v1(142.08,152.68) ; v3(95.14,140.64) 94.4,139.9 U4.2 ; v3(128.91,128.94) 128.91,129.17 128.53,129.55 RV20.2 CV73.2 ; v3(39.33,114.62) DL2.3 v3(41.66,114.62) ; v1(137.09,145.71) 136.63,146.16 UV1.L22 ; C132.2 v3(220.4,50.84) ; UV1.R27 UV1.N26 138.6,143.25 138.97,143.62 138.97,143.66 v1(138.99,143.68) 139.02,143.7 139.14,143.7 UV1.R24 139.66,144.16 140.2,144.7 140.2,144.76 UV1.T23 140.95,145.51 140.95,145.59 v1(141,145.65) 141.09,145.65 UV1.U22 141.6,146.22 142.03,146.65 142.09,146.65 UV1.V21 142.6,147.27 v1(143.05,147.72) 143.49,148.16 UV1.Y20 143.7,148.16 144.6,149.06 UV1.AA18 144.6,149.28 v1(145,149.68) 145.48,150.16 UV1.AB17 145.74,150.16 146.6,151.02 UV1.AC16 ; v3(131.71,129.07) 131.17,129.61 RV24.2 CV75.2 ; CV74.2 133.89,129.53 134.27,129.15 134.3,129.15 v3(134.35,129.1) 134.4,129.15 134.45,129.15 134.83,129.53 RV21.2 ; R153.2 v3(221.37,44.44) ; v1(114.51,135.16) 115.25,135.16 115.73,134.69 CV99.2 ; RV17.1 158.93,129.25 v3(159.19,129) 159.06,128.87 RV147.1
  BOTTOM w0.508: v3(235.9,169.84) 236.79,170.74 JDCIN1.8 236.05,172.51 v3(235.26,172.51) ; v1(181.98,175.05) 181.62,175.41 PC122.2 ; PC7.2 228.56,156.58 v3(228.83,156.3) ; v3(66.05,110.91) 66.53,111.39 RC201.1 ; v3(109.99,122.19) 109.99,122.67 110.42,123.1 C8499.2 ; v3(86.49,127.17) 86.49,128.48 USROM1.4 ; v3(128.12,92.11) 128.71,92.7 129.09,92.7 129.6,93.21 RV167.2 ; CC22.2 78.47,132.42 v1(78.92,132.88) ; v3(90.99,140.53) 91.46,140.06 R2.2 ; PR418.1 PC408.2 76.08,121.48 v3(75.93,121.63) ; v3(191.73,123.26) 191.73,125.42 JHDD.13 ; USROM1.7 80.28,131.08 v1(80.07,131.29) ; RX5.2 17.63,63.41 v3(17.53,63.51) ; v3(191.52,180.13) 191.57,180.18 PC9.2 ; v3(244.86,164.68) 244.86,164.5 v3(244.43,164.07) 244.16,163.8 JWLBT.77 ; C1.2 v3(119.44,177.56) ; CC46.2 126.87,95.61 v3(127.11,95.37) ; RV94.1 160.78,129.77 v3(160.14,129.14) ; PC6.2 v3(230.26,157.04) ; RC394.2 120.07,118.09 119.59,117.6 v3(119.59,117.01) ; UV15.3 126.42,93.31 126.83,92.9 126.83,92.88 v3(126.81,92.88) ; v3(145.57,130.34) 145.8,130.11 RV145.2 RV146.2 ; C9.2 91.56,136.83 v3(90.91,137.48) ; SW1.1 v3(221.09,124.38) ; JHDD.17 196.82,123.27 v3(196.81,123.26) ; v3(17.56,61.58) 18.12,62.14 RX7.2 ; C123.2 17.53,51.02 v3(17.58,51.07) ; PC705.1 v3(145.8,51.53) ; v3(91.24,133.52) 91.24,133.61 U3.2 ; PC225.2 v3(183.55,11.62) ; CRF6.2 v3(223.45,50.46) ; v3(93.78,142.74) 93.86,142.74 94.27,143.15 94.27,143.17 ; v3(65.69,113.27) 65.54,113.27 64.81,114 JFAN.7 63.22,114 v3(62.44,113.22) ; v3(57.56,122.95) 57.21,123.31 CRF15.2 CRF16.2 ; v3(122.66,125.01) R9489.1 123.42,125.8 C8498.2 ; CRF10.2 97.29,139.13 v3(97.29,140.07) ; v1(180.59,178.6) 181.08,178.11 PC123.2 ; v3(89.16,134.94) 88.63,134.94 87.51,133.82 C8.2 ; C50.2 122.32,123.47 C51.2 v3(122.32,122.03) ; PC218.1 184.84,11.57 v3(184.87,11.6) ; v3(175.37,123.66) 175.23,123.8 JHDD.4 ; PRT6.2 196.14,166.56 v3(196.22,166.49) ; v3(199.35,123.26) 199.36,123.27 JHDD.19 ; v3(137.09,124.07) CC25.2 ; v1(130.74,117.2) 130.87,117.32 130.87,118.1 UC8M2.4 ; v3(182.56,186.29) PR802.1 PC803.2 ; v3(95.38,130.7) 95.38,130.69 95.38,129.07 D1.1 ; JREAD2.6 v3(25.27,32.25) ; JHDD.7 179.04,123.83 v3(179.51,123.36) ; v3(239.83,176.9) 239.81,176.87 PC3.2 ; PR302.1 v3(140.98,37.56) ; JHDD.1 v3(171.42,122.21) ; R235.1 v3(227.59,132.04) ; CC272.2 122.36,92.69 v1(122.17,92.88) ; v3(229.39,154.65) 230.31,153.74 JRTC.2 ; JREAD2.3 32.78,29.5 v3(32.98,29.3) ; v3(148.32,130.37) 148.6,130.09 RV148.2 ; JME1.2 JCMOS1.2 127.48,69.1 126.55,68.18 v3(126.24,68.18) ; C131.2 v3(223.01,45.06) ; v3(189.19,123.26) 189.2,123.27 JHDD.11 ; v3(28.33,34.53) CW14.2 30.04,34.53 CW13.2 ; v3(198.08,123.26) 198.09,123.27 JHDD.18 ; SW1.2 222.79,131.38 v3(222.03,132.15) ; v3(29.85,32.81) 29.85,32.96 CW12.2 ; CC258.2 119.54,96.97 v1(120.3,97.73) ; CRF5.2 v3(223.45,51.35) ; PC2.2 v3(240.42,174.28) ; C11.2 92.79,137.53 v3(92.79,136.84)
  vias: v1(83.88,111.61) v1(86.29,117.26) v1(86.92,117.26) v1(87.56,117.26) v1(92.89,119.36) v1(94.61,119.42) v1(95.94,119.42) v1(127.97,152.74) v1(133,137.58) v1(133,136.77) v1(133.79,135.93) v1(135.46,135.71) v1(137.07,135.9) v1(140.12,135.69) v1(144.64,164) v1(154.82,142.43) v1(154.76,141.12) v1(155.91,142.44) v1(155.96,140.39) v2(17.77,43.73) v2(22.15,82.97) v2(22.15,51.4) v2(40.93,100.88) v2(45.04,126.02) v2(55.28,107.81) v2(138.69,59.12) v2(144.46,80.33) v2(169.63,130.01) v2(170.14,178.4) v2(190.23,175.1) v2(194.09,149.87) v2(194.49,131.59) v2(207.24,164.99) v2(222.69,3.88) v2(226.29,176.67) v3(0.82,74.59) v3(1.96,51.42) v3(2.04,34.41) v3(2.04,26.94) v3(2.06,30.49) v3(2.14,11.77) v3(2.55,7.61) v3(3.87,70.65) v3(4.98,74.51) v3(5.52,97.93) v3(5.57,83.81) v3(6.51,53.46) v3(7.63,26.99) v3(7.65,49.54) v3(7.7,30.57) v3(7.75,34.36) v3(8.01,104.23) v3(8.03,80.61) v3(8.16,77.33) v3(8.21,11.8) v3(8.82,70.86) v3(9.28,68.21) v3(9.33,56.25) v3(11.64,30.72) v3(12.88,36.64) v3(13.04,47.79) v3(13.06,25.08) v3(13.09,13.71) v3(13.52,4.71) v3(14.38,0.78) v3(14.81,49.9) v3(15.45,59.73) v3(15.8,78.53) v3(16.47,12.61) v3(16.48,8.68) v3(17.23,105.32) v3(17.35,64.4) v3(17.74,4.46) v3(17.74,0.78) v3(17.94,105.81) v3(17.86,18.28) v3(17.94,6.65) v3(18.4,54.28) v3(22.13,52.03) v3(22.13,50.74) v3(22.1,50.05) v3(22.92,64.23) v3(22.89,62.68) v3(22.89,61.15) v3(23.17,50.33) v3(23.35,0.78) v3(23.37,4.87) v3(24.64,64.3) v3(24.64,61.18) v3(24.67,62.73) v3(24.8,44.72) v3(25.79,41.34) v3(26.02,57.29) v3(26.22,47.28) v3(26.22,46.59) v3(26.35,64.25) v3(26.3,62.68) v3(26.27,61.15) v3(26.35,51.03) v3(26.35,50.33) v3(26.92,47.28) v3(26.92,46.59) v3(26.9,15.33) v3(27.04,51.03) v3(27.04,50.33) v3(27.57,89.68) v3(27.62,88.43) v3(27.62,87.39) v3(27.62,47.28) v3(27.62,46.59) v3(27.74,51.03) v3(27.74,50.33) v3(27.87,77.45) v3(27.87,13.83) v3(28.02,72.3) v3(28.68,89.65) v3(28.66,88.42) v3(28.69,87.39) v3(29.01,76.04) v3(29.24,65.75) v3(29.34,72.25) v3(29.65,89.65) v3(29.68,88.47) v3(29.88,4.46) v3(29.98,0.78) v3(32.06,27.98) v3(32.31,63.64) v3(32.31,62.93) v3(32.34,62.24) v3(32.34,61.1) v3(32.95,68.59) v3(33.94,74.51) v3(33.92,19.09) v3(33.92,18.12) v3(34.14,76.57) v3(34.93,19.09) v3(34.93,18.12) v3(35.13,77.05) v3(35.29,4.28) v3(35.31,0.78) v3(35.62,102.55) v3(35.64,87.93) v3(35.85,39.77) v3(35.85,39.08) v3(35.85,38.34) v3(36.12,103.01) v3(36.33,91.66) v3(36.51,40.15) v3(36.51,39.46) v3(36.51,38.72) v3(36.73,128.72) v3(36.76,94.96) v3(37.17,39.71) v3(37.17,39.03) v3(37.17,38.29) v3(37.67,19.17) v3(37.78,40.07) v3(37.78,39.38) v3(37.78,38.65) v3(37.95,74.82) v3(38.18,78.5) v3(38.66,82.26) v3(38.87,78.5) v3(39.02,74.79) v3(39.07,82.92) v3(39.3,82.29) v3(39.58,78.5) v3(39.73,34.46) v3(40.44,42.99) v3(40.44,42.31) v3(40.44,41.57) v3(40.37,4.54) v3(40.52,0.8) v3(41.61,58.59) v3(41.61,57.39) v3(41.89,128.72) v3(41.94,58) v3(41.97,56.78) v3(42,40.62) v3(42.35,98.31) v3(42.35,58.59) v3(42.35,57.39) v3(42.68,58) v3(42.7,56.78) v3(42.69,40.62) v3(43.03,58.59) v3(43.03,57.39) v3(43.36,58) v3(43.39,56.78) v3(43.43,40.62) v3(43.74,58.59) v3(43.74,57.39) v3(44.08,58) v3(44.1,56.78) v3(44.46,58.59) v3(44.46,57.39) v3(44.79,58) v3(44.81,56.78) v3(44.76,0.8) v3(45.17,58.59) v3(45.17,57.39) v3(45.5,58) v3(45.52,56.78) v3(45.88,58.59) v3(45.88,57.39) v3(46.21,58) v3(46.23,56.78) v3(46.62,57.39) v3(46.69,128.72) v3(46.74,118.58) v3(46.74,116.5) v3(46.95,58) v3(46.97,56.78) v3(47.35,57.39) v3(47.71,117.58) v3(47.68,58) v3(47.71,56.78) v3(47.83,125.16) v3(48.04,57.39) v3(48.06,58.61) v3(48.37,58) v3(48.39,56.78) v3(48.67,118.58) v3(48.75,58.61) v3(48.75,57.39) v3(48.93,38.7) v3(49.08,58) v3(49.1,56.78) v3(49.18,32.07) v3(49.18,30.34) v3(49.18,0.8) v3(49.46,58.61) v3(49.46,57.39) v3(49.79,58) v3(49.82,56.78) v3(49.97,38.32) v3(50.09,31.26) v3(50.17,58.61) v3(50.17,57.39) v3(50.3,125.13) v3(50.5,58) v3(50.53,56.78) v3(50.53,23.69) v3(50.88,58.61) v3(50.88,57.39) v3(51.01,32.04) v3(51.01,30.34) v3(51.21,58) v3(51.24,56.78) v3(51.57,58.64) v3(51.59,57.39) v3(51.82,23.66) v3(52.1,128.72) v3(52.48,127.75) v3(53.04,23.61) v3(53.12,127.75) v3(53.09,115.97) v3(53.27,100.12) v3(53.27,0.8) v3(53.9,100.12) v3(54.36,94.3) v3(55,94.3) v3(55.35,101.13) v3(55.4,37.17) v3(55.51,110.63) v3(56.04,107.81) v3(56.11,101.13) v3(56.6,128.72) v3(56.57,19.98) v3(56.98,101.11) v3(57.46,24.42) v3(57.92,100.52) v3(58.07,118.1) v3(58.22,24.42) v3(59.24,24.42) v3(60.03,8.57) v3(60.1,45.61) v3(60.13,24.42) v3(60.13,0.78) v3(60.28,31.59) v3(60.46,34.33) v3(60.79,100.62) v3(60.86,94.4) v3(61.3,128.84) v3(61.42,88.4) v3(61.52,100.62) v3(61.5,94.4) v3(61.63,19.7) v3(61.96,90.59) v3(62.06,32.65) v3(62.16,94.4) v3(62.26,100.62) v3(62.72,90.62) v3(62.79,94.4) v3(63.07,47.41) v3(63.37,88.4) v3(63.76,85.49) v3(63.86,31.59) v3(63.98,91.71) v3(64.06,100.65) v3(64.45,38.72) v3(64.55,46.27) v3(64.65,88.38) v3(64.67,90.62) v3(64.93,86.53) v3(65.21,0.78) v3(65.28,34.38) v3(65.63,31.99) v3(65.92,82.49) v3(66.4,85.46) v3(66.62,90.62) v3(66.58,83.07) v3(67.38,31.98) v3(67.62,80.3) v3(67.61,77.63) v3(67.61,75.68) v3(67.57,23.13) v3(67.9,47.72) v3(68,130.06) v3(68.23,23.13) v3(68.81,38.55) v3(68.94,34.23) v3(69.25,32.02) v3(69.32,45.25) v3(69.46,78.93) v3(69.46,76.98) v3(69.78,122.21) v3(69.78,121.39) v3(69.78,120.56) v3(70.29,0.78) v3(70.36,8.37) v3(70.54,122.21) v3(70.54,121.39) v3(70.54,120.56) v3(71.3,122.21) v3(71.3,121.39) v3(71.3,120.56) v3(71.48,32.02) v3(71.59,78.34) v3(71.59,76.36) v3(71.91,23.15) v3(72.13,122.21) v3(72.13,121.39) v3(72.13,120.56) v3(72.45,34.51) v3(72.55,44.82) v3(72.57,23.15) v3(72.8,31.69) v3(73.52,76.58) v3(73.52,74.63) v3(74.25,33.47) v3(75.37,132.98) v3(75.37,0.78) v3(75.55,8.37) v3(75.77,31.74) v3(76.13,34.36) v3(76.19,77.23) v3(76.18,75.94) v3(76.19,74.63) v3(77.1,90.72) v3(77.73,34.51) v3(77.65,31.87) v3(77.96,134.51) v3(78.28,76.98) v3(78.28,74.38) v3(78.49,45.66) v3(79.23,108.37) v3(79.15,47.56) v3(79.5,78.93) v3(79.5,76.98) v3(79.5,75.03) v3(79.69,93.23) v3(79.69,91.99) v3(79.92,32.63) v3(80.45,0.78) v3(80.55,110.58) v3(80.52,44.24) v3(80.73,34.51) v3(80.7,8.57) v3(81.27,31.74) v3(81.55,77.46) v3(81.55,74.86) v3(81.67,137.17) v3(82.11,109.57) v3(82.12,107.61) v3(84.16,109.67) v3(84.21,77.52) v3(84.21,75.57) v3(84.59,34.23) v3(84.87,45.33) v3(85.32,140.63) v3(85.53,0.78) v3(85.78,127.17) v3(85.79,79.14) v3(85.79,77.01) v3(85.79,74.41) v3(87.31,127.17) v3(87.89,143.68) v3(88.25,78.44) v3(88.25,76.49) v3(88.25,74.43) v3(90.02,79.09) v3(90.02,77.14) v3(90.02,75.19) v3(90.02,73.02) v3(90.61,0.78) v3(90.86,148.38) v3(91.8,76.49) v3(91.8,74.54) v3(92.69,152.31) v3(92.69,122.03) v3(92.84,91.58) v3(92.87,92.85) v3(93.48,98.44) v3(93.48,97.32) v3(93.48,96.28) v3(93.48,94.96) v3(93.48,93.59) v3(93.63,45.18) v3(93.61,34.08) v3(93.68,78.44) v3(93.68,76.49) v3(93.68,74.56) v3(94.24,157.19) v3(94.47,31.15) v3(94.67,122.11) v3(94.77,124.27) v3(95.33,178.65) v3(95.31,173.32) v3(95.31,165.7) v3(95.28,79.09) v3(95.28,77.14) v3(95.28,75.19) v3(95.69,0.78) v3(96.17,46.04) v3(96.25,31.18) v3(96.27,34.41) v3(96.93,124.3) v3(97.26,76.49) v3(97.65,78.58) v3(99.8,146.98) v3(100.03,173.57) v3(100.13,47.56) v3(100.42,44.98) v3(100.72,133.39) v3(100.84,132.42) v3(100.77,0.78) v3(100.99,126.99) v3(101.81,46.83) v3(101.92,39.37) v3(102.04,112.23) v3(101.96,52.49) v3(102.01,31.69) v3(102.27,33.36) v3(102.65,126.15) v3(102.75,185.64) v3(103.36,44.97) v3(103.43,34.18) v3(103.47,31.76) v3(103.64,178.6) v3(105.24,44.82) v3(105.22,31.87) v3(105.52,34.05) v3(105.47,21.76) v3(105.57,47.44) v3(105.85,0.78) v3(106.38,108.68) v3(106.36,31.59) v3(106.64,26.35) v3(107.64,48.27) v3(107.65,112.18) v3(107.91,154.95) v3(108.11,185.66) v3(108.08,163.11) v3(108.59,34.18) v3(110.32,71.03) v3(110.62,31.79) v3(110.72,178.6) v3(110.93,0.78) v3(112.2,114.16) v3(112.38,46.85) v3(112.38,31.89) v3(113.54,31.84) v3(113.59,89.5) v3(113.57,85.03) v3(113.65,35.27) v3(114.23,83.33) v3(115.45,47.97) v3(115.45,46.67) v3(115.5,120.23) v3(115.5,34.3) v3(116.01,0.78) v3(116.13,120.21) v3(117.18,31.64) v3(117.33,45.02) v3(117.46,88.53) v3(117.48,34.38) v3(117.79,47.56) v3(118.04,121.71) v3(118.42,88.56) v3(119.16,45.61) v3(119.21,4.69) v3(119.46,188.23) v3(119.61,32.73) v3(119.66,31.8) v3(120.28,35.23) v3(120.53,47.56) v3(121.09,0.78) v3(121.58,186.79) v3(123.63,188.2) v3(123.7,114.19) v3(124.34,114.19) v3(124.47,188.2) v3(124.97,114.19) v3(125.63,114.19) v3(126.02,29.66) v3(126.02,28.67) v3(126.04,27.62) v3(126.29,114.19) v3(126.32,37.35) v3(126.32,36.57) v3(126.73,27.65) v3(126.68,22.18) v3(126.8,20.49) v3(126.75,4.69) v3(126.93,114.19) v3(126.9,39.94) v3(127.13,188.2) v3(127.12,58.56) v3(127.08,57.85) v3(127.06,57.16) v3(127.21,102.96) v3(127.22,101.86) v3(127.31,22.18) v3(127.46,20.52) v3(127.72,180.25) v3(127.84,48.68) v3(127.84,47.92) v3(127.84,47.23) v3(127.87,49.8) v3(127.92,45.68) v3(128,188.2) v3(128.71,0.8) v3(130.23,133.26) v3(130.38,123.38) v3(130.64,65.14) v3(130.66,188.2) v3(130.84,89.55) v3(130.77,61.63) v3(131.15,62.55) v3(131.25,65.47) v3(131.25,60.31) v3(131.25,33.59) v3(131.25,32.96) v3(131.22,32.3) v3(131.53,188.2) v3(131.78,62.55) v3(132,33.49) v3(132,32.81) v3(132.11,123.38) v3(132.85,0.78) v3(133,90.18) v3(133,89.55) v3(134.42,90.29) v3(134.42,89.65) v3(135.13,38.52) v3(135.13,37.53) v3(135.34,94.53) v3(135.34,93.87) v3(135.62,38.03) v3(135.97,90.16) v3(135.97,89.52) v3(136.1,38.5) v3(136.1,37.56) v3(136.35,31.36) v3(137.06,94.53) v3(137.06,93.87) v3(137.8,188.2) v3(137.83,0.8) v3(138,180.04) v3(138.66,57.04) v3(138.69,55.87) v3(138.82,94.63) v3(138.82,93.97) v3(138.77,54.68) v3(138.97,57.62) v3(138.97,56.45) v3(138.99,55.28) v3(139.05,54.07) v3(139.05,52.87) v3(139.33,57.04) v3(139.38,62.09) v3(139.38,61.46) v3(139.35,55.87) v3(139.4,54.68) v3(139.4,53.48) v3(139.63,57.62) v3(139.63,56.45) v3(139.73,128.79) v3(139.66,55.28) v3(139.68,54.07) v3(139.68,52.87) v3(139.93,94.6) v3(139.91,93.89) v3(140.01,61.46) v3(139.96,57.04) v3(139.99,55.87) v3(140.06,54.68) v3(140.06,53.48) v3(140.14,50.78) v3(140.14,50.08) v3(140.14,49.32) v3(140.14,48.62) v3(140.26,57.62) v3(140.26,56.45) v3(140.29,55.28) v3(140.34,54.07) v3(140.34,52.87) v3(140.26,39.59) v3(140.65,61.46) v3(140.7,53.48) v3(140.75,25.06) v3(140.85,54.57) v3(140.98,52.87) v3(141.28,50.78) v3(141.28,50.08) v3(141.28,49.32) v3(141.28,48.62) v3(141.4,84.64) v3(141.59,25.08) v3(141.61,0.8) v3(141.74,126.81) v3(141.69,10.89) v3(142.27,72.56) v3(142.45,84.65) v3(142.6,94.6) v3(142.6,93.94) v3(142.83,24.65) v3(142.83,24.02) v3(142.83,23.36) v3(142.83,22.72) v3(143.01,72.56) v3(142.96,15.91) v3(143.01,12.13) v3(143.24,94.6) v3(143.24,93.97) v3(143.47,25.59) v3(143.47,24.93) v3(143.47,24.3) v3(143.47,23.64) v3(143.47,23) v3(143.64,72.56) v3(143.72,77.13) v3(143.67,15.91) v3(143.72,12.13) v3(143.82,80.13) v3(143.82,79.49) v3(143.82,78.83) v3(143.85,78.12) v3(143.9,129.17) v3(144.1,25.31) v3(144.13,24.68) v3(144.13,24.04) v3(144.13,23.38) v3(144.13,22.75) v3(144.15,126.13) v3(144.33,72.56) v3(144.43,79.8) v3(144.43,79.14) v3(144.43,78.5) v3(144.43,77.76) v3(144.35,77.13) v3(144.41,15.91) v3(144.38,12.13) v3(144.76,24.93) v3(144.76,24.3) v3(144.76,23.64) v3(144.76,23) v3(145.01,77.13) v3(145.01,72.56) v3(145.09,80.1) v3(145.09,79.44) v3(145.09,78.81) v3(145.12,78.09) v3(145.34,25.36) v3(145.4,24.68) v3(145.4,24.04) v3(145.4,23.38) v3(145.4,22.75) v3(145.85,128.49) v3(146.03,110.66) v3(146.03,110.02) v3(146.03,109.36) v3(146.03,107.96) v3(146.03,106.54) v3(146.03,105.88) v3(146.03,105.22) v3(146.03,104.59) v3(146.13,188.2) v3(146.06,108.68) v3(146.06,0.78) v3(146.64,110.99) v3(146.64,110.35) v3(146.64,109.69) v3(146.64,106.82) v3(146.64,106.16) v3(146.64,105.5) v3(146.64,104.87) v3(146.67,108.93) v3(146.67,108.27) v3(146.67,107.61) v3(146.84,138.37) v3(146.89,139.08) v3(147.22,111.32) v3(147.22,110.66) v3(147.22,110.02) v3(147.22,109.36) v3(147.25,108.6) v3(147.25,107.94) v3(147.25,107.28) v3(147.25,106.54) v3(147.25,105.88) v3(147.25,105.22) v3(147.25,104.59) v3(147.83,111.6) v3(147.83,110.94) v3(147.83,110.3) v3(147.83,109.64) v3(147.88,108.9) v3(147.88,108.24) v3(147.88,107.58) v3(147.86,106.82) v3(147.86,106.16) v3(147.86,105.5) v3(147.86,104.87) v3(148.44,111.95) v3(148.44,111.29) v3(148.44,110.63) v3(148.44,110) v3(148.44,109.34) v3(148.49,108.68) v3(148.49,108.02) v3(148.49,107.35) v3(148.49,106.54) v3(148.49,105.88) v3(148.49,105.22) v3(149.03,37.12) v3(149.05,112.23) v3(149.05,111.57) v3(149.05,110.91) v3(149.05,110.28) v3(149.05,109.62) v3(149.1,108.96) v3(149.1,108.29) v3(149.1,107.63) v3(149.1,106.82) v3(149.1,106.16) v3(149.1,105.5) v3(149.54,31.54) v3(149.54,27.73) v3(149.54,23.15) v3(149.66,112.03) v3(149.66,111.34) v3(149.66,110.68) v3(149.66,110) v3(149.66,109.36) v3(149.69,108.68) v3(149.69,107.99) v3(149.69,107.23) v3(149.69,106.54) v3(149.69,105.86) v3(150.17,0.78) v3(150.3,111.67) v3(150.3,111.04) v3(150.3,110.4) v3(150.3,109.64) v3(150.3,108.88) v3(150.3,108.24) v3(150.3,107.61) v3(150.3,106.97) v3(150.3,106.21) v3(150.7,11.06) v3(150.83,4.1) v3(151.42,3.72) v3(151.59,11.55) v3(152.08,179.65) v3(152.08,31.54) v3(152.08,27.73) v3(152.3,11.55) v3(153.12,3.7) v3(153.35,11.55) v3(153.8,3.72) v3(153.98,165.35) v3(154.03,11.55) v3(154.13,133.49) v3(154.46,3.7) v3(155.45,133.44) v3(155.76,0.78) v3(156.09,133.42) v3(156.57,113.78) v3(157.33,188.23) v3(157.31,90.01) v3(158.43,114.97) v3(159.93,179.6) v3(161.56,92.09) v3(161.88,183.45) v3(162.11,0.78) v3(162.62,186.6) v3(164.78,162.47) v3(165.41,140.76) v3(165.54,162.47) v3(165.72,102.38) v3(165.83,188.23) v3(165.79,142.41) v3(165.79,141.39) v3(166.05,140.76) v3(166.07,11.37) v3(166.25,162.3) v3(166.43,142.41) v3(166.43,141.39) v3(166.45,12.03) v3(166.6,188.23) v3(166.63,10.73) v3(166.68,140.76) v3(166.86,11.42) v3(167.04,10.07) v3(167.06,141.39) v3(167.06,0.78) v3(167.21,12.03) v3(167.44,152.57) v3(167.44,151.8) v3(167.37,10.71) v3(167.57,11.42) v3(167.7,9.13) v3(167.7,8.47) v3(167.77,10.07) v3(167.95,12) v3(168.2,152.57) v3(168.2,151.8) v3(168.15,10.68) v3(168.41,188.23) v3(168.36,11.42) v3(168.64,12.03) v3(168.84,130.79) v3(168.92,10.48) v3(169.09,11.39) v3(169.35,162.42) v3(169.35,161.66) v3(169.28,129.33) v3(169.4,181.29) v3(169.4,180.66) v3(169.42,179.72) v3(169.4,179.08) v3(169.42,12.03) v3(169.75,11.14) v3(169.75,10.45) v3(170.14,162.42) v3(170.16,161.66) v3(170.24,11.75) v3(170.74,188.23) v3(171,162.45) v3(171,161.63) v3(171.05,11.77) v3(171.58,11.14) v3(172.22,0.78) v3(172.27,11.57) v3(172.52,152.57) v3(172.52,151.8) v3(173.97,173.12) v3(174.05,103.67) v3(174.4,172.63) v3(176.08,120.18) v3(176.46,172.56) v3(176.46,171.69) v3(176.49,170.88) v3(177.32,172.58) v3(177.29,171.71) v3(177.32,170.88) v3(177.4,0.8) v3(177.96,112.38) v3(178.14,171.69) v3(178.16,172.58) v3(178.16,170.88) v3(178.92,112.41) v3(178.97,3.67) v3(179.15,117.64) v3(179.18,117.01) v3(179.18,2.94) v3(179.63,3.67) v3(179.89,173.47) v3(179.86,131.08) v3(179.91,2.94) v3(180.22,143.47) v3(180.22,142.84) v3(180.22,142.18) v3(180.37,132.2) v3(180.37,3.67) v3(180.83,2.96) v3(180.9,149.04) v3(180.85,148.05) v3(181.03,152.8) v3(180.96,144.41) v3(181.01,132.2) v3(181.13,3.67) v3(181.44,112.66) v3(181.44,0.78) v3(181.51,148.05) v3(181.57,149.04) v3(181.62,144.41) v3(181.57,2.96) v3(181.69,152.8) v3(181.9,3.7) v3(182.15,148.05) v3(182.17,189.57) v3(182.2,149.04) v3(182.33,152.8) v3(182.25,144.41) v3(182.3,2.99) v3(182.58,112.64) v3(183.01,2.81) v3(183.75,152.9) v3(183.83,151.76) v3(183.75,150.62) v3(183.79,149.46) v3(183.93,2.81) v3(184.18,152.34) v3(184.18,151.2) v3(184.18,150.05) v3(184.16,148.4) v3(184.21,147.77) v3(184.23,147.13) v3(184.26,146.5) v3(184.31,145.3) v3(184.31,144.16) v3(184.31,143.02) v3(184.46,181.22) v3(184.49,180.56) v3(184.49,179.87) v3(184.49,179.24) v3(184.51,151.78) v3(184.51,150.64) v3(184.56,149.47) v3(184.59,145.89) v3(184.64,144.72) v3(184.64,143.58) v3(184.82,183.18) v3(184.84,182.36) v3(184.84,152.34) v3(184.84,151.2) v3(184.84,150.05) v3(184.89,148.45) v3(184.94,147.82) v3(184.94,145.3) v3(184.94,144.16) v3(184.94,143.02) v3(184.92,3.11) v3(184.97,147.18) v3(184.99,146.55) v3(185.15,151.78) v3(185.15,150.64) v3(185.2,149.47) v3(185.22,145.89) v3(185.27,144.72) v3(185.27,143.58) v3(185.27,2.48) v3(185.48,152.34) v3(185.48,151.2) v3(185.48,150.05) v3(185.55,148.43) v3(185.6,147.79) v3(185.63,147.16) v3(185.6,145.3) v3(185.6,144.16) v3(185.6,143.02) v3(185.65,146.52) v3(185.71,3.14) v3(185.81,151.78) v3(185.81,150.64) v3(185.86,149.47) v3(185.88,145.89) v3(185.93,144.72) v3(185.93,143.58) v3(185.93,114.8) v3(186.04,2.48) v3(186.14,152.34) v3(186.14,151.2) v3(186.14,150.05) v3(186.19,148.4) v3(186.24,147.77) v3(186.26,147.13) v3(186.29,146.5) v3(186.26,145.3) v3(186.26,144.16) v3(186.26,143.02) v3(186.44,23.64) v3(186.39,3.16) v3(186.47,151.78) v3(186.47,150.64) v3(186.52,149.47) v3(186.54,145.89) v3(186.49,25.52) v3(186.52,0.78) v3(186.59,144.72) v3(186.59,143.58) v3(186.62,3.82) v3(186.75,4.97) v3(186.72,2.5) v3(186.8,152.34) v3(186.8,151.2) v3(186.8,150.05) v3(186.85,148.4) v3(186.9,147.77) v3(186.92,147.13) v3(186.9,145.3) v3(186.9,144.16) v3(186.9,143.02) v3(186.95,146.5) v3(187.1,151.78) v3(187.1,150.64) v3(187.05,3.14) v3(187.15,149.47) v3(187.18,145.89) v3(187.23,144.72) v3(187.23,143.58) v3(187.43,152.34) v3(187.43,151.2) v3(187.43,150.05) v3(187.36,3.82) v3(187.48,148.4) v3(187.53,147.77) v3(187.46,2.5) v3(187.56,147.13) v3(187.59,146.5) v3(187.56,145.3) v3(187.56,144.16) v3(187.56,143.02) v3(187.76,150.64) v3(187.79,149.47) v3(187.76,3.14) v3(187.94,145.89) v3(188.07,150.05) v3(188.12,3.82) v3(188.19,148.4) v3(188.22,147.66) v3(188.25,146.57) v3(188.17,2.53) v3(188.4,150.64) v3(188.42,149.47) v3(188.5,3.14) v3(188.58,145.94) v3(188.7,150.05) v3(188.89,148.82) v3(188.94,148.16) v3(188.88,3.85) v3(188.93,2.53) v3(189.03,150.64) v3(188.99,146.92) v3(189.06,149.47) v3(189.34,150.05) v3(189.27,147.53) v3(189.26,3.16) v3(189.59,148.81) v3(189.58,148.16) v3(189.63,146.9) v3(189.64,2.53) v3(189.67,150.64) v3(189.69,149.47) v3(189.81,151.26) v3(189.9,152.34) v3(189.93,147.54) v3(189.95,143.02) v3(189.97,150.05) v3(189.97,144.16) v3(190.23,174.13) v3(190.2,173.45) v3(190.23,151.78) v3(190.23,148.83) v3(190.24,148.13) v3(190.3,150.64) v3(190.3,144.74) v3(190.28,143.6) v3(190.35,149.47) v3(190.63,152.34) v3(190.63,151.2) v3(190.63,150.05) v3(190.61,144.16) v3(190.58,143.02) v3(190.86,175.12) v3(190.86,174.44) v3(190.89,173.78) v3(190.94,151.78) v3(190.94,150.64) v3(190.86,148.83) v3(190.9,148.15) v3(190.94,144.74) v3(190.91,143.6) v3(190.99,149.47) v3(191.24,143.02) v3(191.27,152.34) v3(191.27,151.2) v3(191.27,150.05) v3(191.27,144.16) v3(191.5,175.45) v3(191.5,174.82) v3(191.5,174.13) v3(191.52,173.47) v3(191.55,148.83) v3(191.6,166.44) v3(191.6,151.78) v3(191.6,150.64) v3(191.65,149.47) v3(191.6,144.74) v3(191.57,143.6) v3(191.6,0.78) v3(191.93,152.34) v3(191.93,151.2) v3(191.93,150.05) v3(191.93,144.16) v3(191.9,143.02) v3(192.16,175.12) v3(192.16,174.44) v3(192.18,173.78) v3(192.23,143.6) v3(192.26,151.78) v3(192.26,150.64) v3(192.26,144.74) v3(192.54,143.02) v3(192.64,166.44) v3(192.59,152.34) v3(192.59,151.2) v3(192.59,150.05) v3(192.56,144.16) v3(192.79,175.48) v3(192.79,174.84) v3(192.79,174.16) v3(192.82,173.5) v3(192.89,151.78) v3(192.89,150.64) v3(192.89,144.74) v3(192.87,143.6) v3(193.12,152.98) v3(193.15,131.99) v3(193.22,152.34) v3(193.22,151.2) v3(193.22,144.16) v3(193.2,143.02) v3(193.22,131.1) v3(193.4,175.17) v3(193.4,174.54) v3(193.4,173.85) v3(193.43,173.19) v3(193.43,166.44) v3(193.53,151.78) v3(193.53,143.6) v3(193.55,144.74) v3(193.6,114.83) v3(193.72,152.74) v3(193.86,151.14) v3(193.91,131.99) v3(193.86,131.1) v3(194.01,174.79) v3(194.01,174.16) v3(194.01,173.47) v3(194.04,172.81) v3(194.19,36.36) v3(196.14,118.28) v3(196.65,131.1) v3(196.68,0.78) v3(197.03,131.92) v3(197.29,118.28) v3(197.41,131.1) v3(197.92,166) v3(198.13,115.18) v3(199.75,165.9) v3(199.95,11.5) v3(199.98,3.72) v3(200.59,11.5) v3(200.77,3.72) v3(200.95,67.68) v3(200.97,68.37) v3(201.09,68.99) v3(201.22,11.5) v3(201.76,0.78) v3(201.9,11.51) v3(201.89,3.72) v3(202.14,165.83) v3(202.67,3.72) v3(202.88,183.68) v3(203.69,3.72) v3(203.87,11.5) v3(204.5,165.83) v3(204.5,11.5) v3(204.48,3.72) v3(205.21,128.89) v3(205.39,184.44) v3(205.37,183.73) v3(205.39,11.09) v3(205.54,4.08) v3(206.08,165.85) v3(206.81,97.32) v3(206.76,27.65) v3(206.84,0.78) v3(207.57,54.24) v3(207.68,184.44) v3(207.65,183.73) v3(207.65,27.65) v3(207.83,19.5) v3(207.85,85.64) v3(207.85,83.99) v3(207.88,22.11) v3(207.88,21.22) v3(207.85,20.41) v3(208.34,165.8) v3(208.41,26.79) v3(208.51,28.23) v3(208.64,19.5) v3(208.74,22.09) v3(208.72,21.25) v3(208.69,20.39) v3(209.63,22.06) v3(209.63,21.27) v3(209.63,20.41) v3(209.66,19.52) v3(210.06,55.92) v3(210.5,22.11) v3(210.47,21.33) v3(210.47,20.41) v3(210.47,19.5) v3(211.94,153.76) v3(211.94,153.02) v3(211.94,152.31) v3(211.94,151.6) v3(211.92,0.78) v3(212.6,153.76) v3(212.6,153.02) v3(212.6,152.31) v3(212.6,151.6) v3(212.86,62.07) v3(212.99,52.11) v3(213.24,153.76) v3(213.24,153.02) v3(213.24,152.31) v3(213.24,151.6) v3(213.37,59.22) v3(213.9,153.76) v3(213.9,153.02) v3(213.9,152.31) v3(213.9,151.6) v3(214.43,68.29) v3(214.43,67.6) v3(214.43,66.87) v3(217,0.78) v3(220.22,135.93) v3(220.43,95.59) v3(220.43,90.51) v3(220.43,85.43) v3(220.43,80.35) v3(220.43,75.27) v3(220.81,71.59) v3(221.04,3.85) v3(221.42,188.23) v3(221.72,184.44) v3(221.72,182.82) v3(221.91,3.88) v3(222.03,98.46) v3(222.08,0.78) v3(225.13,70.91) v3(225.35,2.2) v3(225.61,2.83) v3(225.76,176.06) v3(225.76,175.43) v3(226.02,172.86) v3(226.02,171.67) v3(226.02,154.98) v3(226.09,188.23) v3(226.07,2.2) v3(226.22,155.59) v3(226.32,171.08) v3(226.37,172.28) v3(226.37,2.83) v3(226.6,185.41) v3(226.6,184.44) v3(226.65,172.86) v3(226.65,171.67) v3(226.75,2.2) v3(226.9,155.61) v3(227.01,172.28) v3(226.96,171.08) v3(227.13,2.83) v3(227.16,0.78) v3(227.34,172.86) v3(227.34,171.67) v3(227.64,171.08) v3(227.69,172.28) v3(228,172.89) v3(228,171.69) v3(228.3,171.11) v3(228.35,172.3) v3(228.58,70.91) v3(228.66,172.89) v3(228.66,171.69) v3(229.01,172.3) v3(228.96,171.11) v3(229.42,131.03) v3(229.42,125.95) v3(229.42,120.87) v3(229.42,115.79) v3(229.42,110.71) v3(229.42,105.63) v3(229.42,67.05) v3(229.42,33.49) v3(229.42,30.75) v3(229.42,27.83) v3(229.55,8.93) v3(229.7,134.63) v3(231.17,188.23) v3(231.43,58.1) v3(231.43,53) v3(231.43,47.92) v3(231.43,42.86) v3(231.4,0.83) v3(231.73,24.37) v3(231.73,19.29) v3(231.73,14.21) v3(231.73,9.13) v3(231.73,4.05) v3(232.19,148.05) v3(232.42,135.47) v3(232.64,148.5) v3(233.23,142.28) v3(233.52,151.6) v3(234.47,151.27) v3(234.8,153.05) v3(235.87,151.32) v3(236.23,155.79) v3(236.25,188.23) v3(237.5,135.47) v3(238.03,142.61) v3(238.49,143.07) v3(238.56,185.74) v3(238.61,184.44) v3(239,145.35) v3(240.32,139.54) v3(240.42,184.77) v3(240.39,153.25) v3(240.39,152.31) v3(241.33,188.23) v3(242.4,135.65) v3(242.63,185.69) v3(243.74,150.18) v3(243.67,149.52) v3(245.01,158.12) v3(244.99,137.96) v3(245.45,185.33) v3(246.61,167.71) v3(246.59,166.87) v3(248.09,141.01) v3(250.35,164.05) v3(250.4,185.28) v3(250.4,160.03) v3(250.42,152.14) v3(250.42,149.06) v3(250.42,143.98) v4(11.84,97.86) v4(14.56,53) v4(47.66,116.3) v4(48.16,18.33) v4(54.34,127.67) v4(87.46,6.16) v4(95.31,149.09) v4(97.82,154.6) v4(100.01,177.03) v4(111.84,182.77) v4(127.56,38.01) v4(132.7,33.54) v4(135.49,39.51) v4(146.06,25.41) v4(159.09,3.6) v4(178.34,169.92) v4(193.1,2.83) v4(201.83,101.31) v4(205.11,2.88) v4(207.4,162.57) v4(214,65.11) v4(218.62,40.71) v4(219.97,103.24) v4(227.59,125.41) v4(231.53,170.91) v4(235.51,136.72)
