# Allegro board Lenovo ThinkPad E460 E560 BE560 NM-A561 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDRB_CS0_DIMMB#: length 51.8
  IN1 w0.076: v3(85.67,79.81) 86.42,79.06 86.42,78.24 87.13,77.54 87.13,72 86.97,71.84
  IN1 w0.165: v5(97.38,45.19) 97.85,44.73 97.85,43.2 98.08,42.97 98.42,42.97 98.66,43.2 98.66,45.1 97.62,46.14 97.62,58.23 86.82,69.03 86.82,71.69 86.97,71.84
  BOTTOM w0.076: v3(85.67,79.81) 86.03,80.17 86.03,80.83 86.16,80.96 86.16,81.18 86.3,81.32 86.3,82.3 UC1.BB42
  BOTTOM w0.178: v5(97.38,45.19) 96.22,44.03 JDIMM2.114
DDRB_CS1_DIMMB#: length 53.7
  IN1 w0.076: v3(85.79,77.66) 86.49,76.96 86.49,72.63 86.38,72.52
  IN1 w0.165: v5(96.28,53.36) 96.3,53.38 96.3,55.77 95.24,56.82 95.24,57.06 95.96,57.78 95.96,58.01 95.72,58.26 95.49,58.26 94.76,57.53 94.53,57.53 94.1,57.97 94.1,58.23 94.74,58.87 94.74,59.23 91.47,62.5 91.24,62.5 90.52,61.78 90.28,61.78 90.04,62.02 90.04,62.25 90.76,62.97 90.76,63.21 90.52,63.45 90.29,63.45 89.56,62.73 89.33,62.73 89.11,62.94 89.11,63.23 89.81,63.93 89.81,64.16 89.57,64.4 89.33,64.4 88.61,63.68 88.38,63.68 88.16,63.9 88.16,64.18 88.86,64.88 88.86,65.11 88.62,65.35 88.38,65.35 88.01,64.99 87.78,64.99 87.56,65.2 87.56,65.49 87.91,65.83 87.91,66.06 87.66,66.31 87.43,66.31 87.16,66.04 86.93,66.04 86.69,66.28 86.69,66.52 86.95,66.78 86.95,67.02 86.71,67.26 86.48,67.26 86.21,66.99 85.98,66.99 85.74,67.24 85.74,67.47 86,67.73 86,67.97 85.5,68.47 85.5,71.64 86.38,72.52
  BOTTOM w0.076: 86.37,78.75 86.37,80.7 86.49,80.82 86.49,81.04 86.63,81.18 86.63,81.93 86.69,81.99 86.69,82.48 86.68,82.51 86.59,82.72 86.53,82.88 86.53,83.37 UC1.AY42
  BOTTOM w0.102: v3(85.79,77.66) 86.37,78.24 86.37,78.75
  BOTTOM w0.178: v5(96.28,53.36) 96.31,53.33 97.54,53.33 98.32,52.55 JDIMM2.121
DDRB_ODT0_DIMMB#: length 52.5
  IN1 w0.076: v3(85.79,78.31) 86.82,77.28 86.82,72.35 86.42,71.95
  IN1 w0.165: v3(97.38,44.43) 96.88,43.93 96.88,43.32 96.42,42.86 95.43,42.86 95.04,43.26 95.04,43.88 95.23,44.07 95.64,44.07 96.3,44.73 96.3,45.18 96.96,45.84 96.96,46.2 97.17,46.42 97.17,58.05 86.16,69.06 86.16,71.69 86.42,71.95
  BOTTOM w0.076: UC1.BA42 86.26,82.84 86.4,82.7 86.41,82.69 86.41,82.69 86.53,82.44 86.53,82.11 86.46,82.05 86.46,81.25 86.33,81.11 86.33,80.89 86.2,80.76 86.2,78.89 85.79,78.48 v3(85.79,78.31)
  BOTTOM w0.178: v3(97.38,44.43) 96.82,43.87 JDIMM2.116
DDRB_ODT1_DIMMB#: length 53.4
  IN1 w0.076: 87.48,71.52 87.48,78.04 87.31,78.21 86.92,78.21 86.75,78.38 86.75,78.62 86.92,78.79 87.31,78.79 87.48,78.96 87.48,79.75 87.33,79.9 87.05,79.9 86.87,79.72 86.52,79.72 86.39,79.85 86.39,80.79 85.91,81.26 85.6,81.26 85.37,81.04 85.37,80.72 v3(85.63,80.47)
  IN1 w0.165: 87.48,71.52 87.48,69.3 87.61,69.18 87.61,68.87 98.06,58.42 98.06,46.33 98.81,45.58 99.34,45.58 99.73,45.19 99.73,44.46 99.52,44.25 v5(99.16,44.25)
  BOTTOM w0.076: v3(85.63,80.47) 85.63,80.68 86,81.04 86,81.25 86.13,81.39 86.13,82.02 86,82.15 86,82.24 86,82.24 86,82.44 86.03,82.52 86.05,82.54 86.05,82.77 86,82.88 86,83.09 86.03,83.17 86.03,83.45 86,83.48 86,83.79 86.03,83.83 86.03,84.06 UC1.AW42
  BOTTOM w0.178: JDIMM2.120 98.02,42.15 98.02,43.13 99.14,44.25 v5(99.16,44.25)
DGPU_HOLD_RST#: length 56.7
  TOP w0.114: RPC9.3 148.83,91.69 148.57,91.43 v3(147.96,91.43)
  IN1 w0.076: 108.89,95.85 105.78,95.85 105.39,95.46 v3(105.31,95.46)
  IN1 w0.14: 108.89,95.85 109.99,96.96 112.63,96.96 113.07,97.4 114.86,97.4 115.02,97.55 119.74,97.55 120.25,97.04 122.08,97.04 122.23,97.19 122.23,97.4 v3(122.41,97.58) 122.74,97.58 123.27,97.04 124.87,97.04 126.26,95.66 126.26,95.07 127.09,94.24 134.11,94.24 135.01,95.14 140.58,95.14 143.43,92.29 147.1,92.29 147.28,92.47 147.68,92.47 148.04,92.11 148.04,91.51 v3(147.96,91.43)
  BOTTOM w0.076: UC1.U9 v3(105.31,95.46)
  BOTTOM w0.114: UV15.2 124.33,94.34 v2(123.63,95.04) 123.47,95.19 123.47,97.16 123.06,97.58 v3(122.41,97.58)
DGPU_PWREN#: length 5.3
  TOP w0.114: RV161.2 RV164.1 176.72,124.31 QV19.3 ; RV161.2 RV163.1 ; RV161.2 v4(177.58,122.93)
DGPU_PWROK: length 264.5
  TOP w0.114: RC411.1 119.18,94.27 v1(118.74,93.83) ; RV210.2 165.66,178.27 RC402.1 168.13,177.15 168.9,176.38 168.9,175.55 168.08,174.73 168.08,167.17 170.62,164.63 172.27,164.63 175.13,161.77 180.59,161.77 182.87,164.06 200.02,164.06 203,161.08 v3(203,160.82)
  TOP w0.254: PR605.1 207.83,147.44 206.58,146.19 v3(206.58,142.97)
  IN1 w0.14: v3(203,160.82) 203.38,161.2 207.88,161.2 211.71,157.37 216.86,157.37 218.14,156.1 218.14,154.26 214.53,150.66 212.22,150.66 206.58,145.02 v3(206.58,142.97) 207.1,142.44 207.1,139.91 204.44,137.25 204.44,136.71 203.39,135.66 203.39,132.48 202.43,131.52 202.43,129.11 203.5,128.05 203.5,120.75 201.55,118.79 201.55,112.25 v3(201.33,112.03) ; v3(130.21,82.13) 130.92,81.42 130.92,76.06 132.34,74.64 137.04,74.64 138.87,72.81 138.87,72.15 139.17,71.85 147,71.85 147.52,72.37 147.52,77.11 146.96,77.67 146.96,79.78 145.68,81.07 v3(145.68,83.45)
  IN3 w0.114: v1(169.5,103.04) 168.23,103.04 166.01,100.81 165.21,100.81 164.17,99.77 164.17,98.65 161.73,96.22 160.69,96.22 156.61,92.14 156.61,91.2 153.01,87.59 151.11,87.59 148.72,85.21 146.82,85.21 145.68,84.06 v3(145.68,83.45) ; v1(118.74,93.83) 118.74,93.15 118.93,92.96 119.41,92.96 120.94,91.43 122.2,91.43 123.73,89.9 123.73,89.61 126.7,86.64 126.7,84.55 127.39,83.86 127.39,82.11 128.26,81.24 129.32,81.24 v3(130.21,82.13)
  BOTTOM w0.114: v3(201.33,112.03) 201.33,113.63 199.28,115.67 189.5,115.67 184.44,110.61 176.1,110.61 169.5,104 v1(169.5,103.04) ; RC67.2 RC71.1 118.42,94.88 118.42,94.15 v1(118.74,93.83)
DGPU_PWROK_R: length 313.3
  TOP w0.114: RC433.2 124.76,69.76 122.42,69.76 121.98,70.21 121.41,70.21 120.63,69.43 v3(120.63,68.88) ; v1(168.08,176.13) 167.96,176.24 RC402.2
  IN1 w0.14: v1(168.08,176.13) 168.71,175.49 168.71,170.63 163.46,165.37 163.46,159.42 164.8,158.08 170.11,158.08 173.42,161.39 180.84,161.39 181.03,161.58 207.88,161.58 211.82,157.64 216.98,157.64 218.41,156.21 218.41,154.15 214.64,150.39 212.33,150.39 207.8,145.87 207.8,140.23 204.71,137.14 204.71,136.6 203.66,135.55 203.66,132.37 202.7,131.41 202.7,129.41 204.03,128.07 204.03,120.9 201.85,118.72 201.85,94.93 202.47,94.3 202.47,77.1 191.69,66.32 189.63,66.32 187.28,63.97 181.01,63.97 180.04,64.94 177.5,64.94 176.84,64.28 176.84,62.93 179.28,60.49 179.28,55.44 178.29,54.45 178.29,52.9 177.86,52.47 177.86,50.31 v3(178.06,50.1) ; v1(159.04,53.13) 158.45,53.13 155.2,56.38 154.31,56.38 151.72,58.97 151.11,58.97 147.53,62.55 140.37,62.55 136.38,66.54 128.76,66.54 126.57,68.72 122.1,68.72 121.8,68.42 121.09,68.42 v3(120.63,68.88)
  IN3 w0.114: v3(178.06,50.1) 175.55,52.62 159.54,52.62 v1(159.04,53.13)
  BOTTOM w0.076: 105.99,80.65 105.87,80.76 104.32,80.76 103.5,81.58 103.5,82.28 UC1.BB11
  BOTTOM w0.102: 105.99,80.65 107.35,79.29 107.35,76.39 108.57,75.17
  BOTTOM w0.114: 108.57,75.17 109.94,75.17 110.32,74.79 110.32,74.28 113.25,71.35 117.33,71.35 118.33,70.35 118.34,70.35 119.81,68.88 v3(120.63,68.88)
DH_1.35V: length 7.6
  TOP w0.254: v3(136.15,35.19) 136.12,35.22 v4(136.12,35.83)
  IN3 w0.762: 132.16,27.95 132.16,28.06 135.59,31.49 135.59,33.52
  vias: v3(132.19,27.01) v3(132.19,26.38) v3(136.15,34.56)
DH_CHG: length 17.1
  TOP w0.114: v4(181.92,171.19) v3(181.31,171.19)
  IN3 w0.762: 182.2,171.19 195.61,171.19 197.82,168.98
  vias: v3(180.68,171.19) v3(197.62,168.26) v3(198.25,168.26)
DIFFCLK_BIASREF: length 13.5
  TOP w0.178: v3(94.52,105.83) 94.49,105.86 RC379.1
  IN3 w0.178: v1(90.73,107.23) 90.35,106.85 89.53,106.85 89.02,106.34 89.02,104.94 88.07,103.99 86.76,103.99 86.44,103.67 v1(86.44,102.53)
  BOTTOM w0.076: UC1.E42 86.16,102.24 v1(86.44,102.53)
  BOTTOM w0.178: v1(90.73,107.23) 92.23,107.23 93.63,105.83 v3(94.52,105.83)
DISCRETE_PRESENCE: length 68.3
  TOP w0.114: v3(83.47,105.32) 83.47,109.74 v1(83.5,109.77)
  IN1 w0.114: v3(83.47,105.32) 83.24,105.09 83.24,99.15 82.89,98.8 82.89,93.36 81.97,92.45 80.63,92.45 80.17,91.99 80.17,89.73 81.11,88.79 86.59,88.79 86.9,88.48 86.9,88.05 87.48,87.47 91.09,87.47 91.52,87.9 91.52,88.51 91.75,88.74 93.02,88.74 93.71,89.42 93.71,92.57 94.27,93.13 95.38,93.13 97.52,91 97.52,90.49 97.72,90.29 98.28,90.29 98.55,90.55 98.85,90.55 99.28,90.12 99.28,89.84 99.75,89.37 101.35,89.37 101.61,89.63 104.3,89.63 104.5,89.42 104.5,88.91 104.27,88.69 104.27,87.5 v3(104.75,87.03)
  BOTTOM w0.076: v3(104.75,87.03) 104.55,87.03 UC1.AR10
  BOTTOM w0.114: v1(83.5,109.77) 83.5,110.91 83.11,111.29 83.11,114.4 v2(84.64,115.93) 84.69,115.98 RC32.2 86.14,118.58 RC29.2
DL_1.35V: length 15.4
  TOP w0.254: v4(137.62,37.43) v3(137.62,36.64)
  IN3 w0.762: 140.9,21.58 138.82,23.66 138.82,35.3
  vias: v3(138.11,36.13) v3(141.66,21.43) v3(142.35,21.43)
DL_CHG: length 13.3
  TOP w0.114: v3(180.85,172.79) 180.83,172.76 v4(180.12,172.76)
  IN3 w0.762: 182.15,173.37 187.81,173.37 190.91,176.47 193.43,176.47
  vias: v3(180.85,173.42) v3(194.62,176.47) v3(195.28,176.47)
DMIC_CLK: length 222.9
  TOP w0.114: JLCD.15 96.02,135.33 96.02,132.2 v3(95.89,132.07) ; v3(172.27,35.98) 174.26,33.99 190.96,33.99 191.67,33.28 203.58,33.28 205.8,31.05 211.17,31.05 212.34,29.88 v4(214.76,29.88) 216.03,29.88 217.54,28.37 217.54,27.65 216.46,26.57 216.46,25.44 CA40.1 RA31.1
  IN1 w0.14: v3(141.64,123.05) 141.09,123.6 134.5,123.6 133.67,124.42 126.88,124.42 125.77,123.31 116.13,123.31 113.87,121.05 109.56,121.05 109.56,121.04 108.49,121.04 106.08,123.45 106.08,124.27 105.78,124.58 105.78,125.56 100.73,130.61 97.35,130.61 v3(95.89,132.07) ; v3(172.27,35.98) 170.11,35.98 168.2,37.89 168.2,56.94 167.38,57.76 167.38,58.65 164.23,61.8 164.23,65.51 160.37,69.37 158.67,69.37 155.78,72.25 155.78,75.43 151.75,79.47 151.64,79.47 v3(151.54,79.57)
  BOTTOM w0.114: v3(141.64,123.05) 141.64,123.1 142.3,123.76 144.81,123.76 147.99,120.59 147.99,119.46 156.67,110.78 156.67,97.43 154.86,95.62 152.74,95.62 151.36,94.25 151.36,90.69 150.61,89.93 150.61,88.23 150.17,87.79 150.17,85.59 150.53,85.23 150.53,82.16 151.54,81.14 v3(151.54,79.57)
DMIC_DATA: length 225.5
  TOP w0.114: v3(172.22,35.24) 173.97,33.49 190.76,33.49 191.47,32.78 203.37,32.78 205.59,30.56 210.97,30.56 212.15,29.38 215.75,29.38 v4(217.05,28.08) 217.05,27.85 CA43.1 215.88,25.87 215.47,25.47 213.82,25.47 212.25,23.89 211.44,23.89 210.98,23.43 UA1.1 ; v3(96.65,132.78) 96.6,132.83 96.6,135.24 95.89,135.96 95.89,136.03 JLCD.14
  IN1 w0.14: v3(151.57,78.83) 151.59,78.81 151.67,78.81 155.1,75.38 155.1,72 158.25,68.85 160.15,68.85 163.66,65.34 163.66,61.63 166.86,58.43 166.86,57.55 167.65,56.76 167.65,51.83 167.16,51.35 167.16,43.55 167.27,43.45 167.27,37.96 169.98,35.24 v3(172.22,35.24)
  IN2 w0.14: v3(96.65,132.78) 96.91,132.78 99.13,130.56 101.2,130.56 103.01,128.74 117.16,128.74 118.53,127.38 137.34,127.38 139.66,125.06 139.66,122.93 139.96,122.62 140.47,122.62 v3(140.87,123.03)
  BOTTOM w0.114: v3(151.57,78.83) 152.08,79.34 152.08,81.32 151.02,82.37 151.02,85.5 150.73,85.79 150.73,87.54 151.92,88.74 151.92,93.97 153.04,95.09 155.02,95.09 157.16,97.23 157.16,110.98 148.52,119.62 148.52,120.79 145.05,124.26 142.09,124.26 140.87,123.04 v3(140.87,123.03)
DMINUS: length 14.3
  TOP w0.114: TPV20.1 161.17,138.06 v3(161.02,138.06)
  IN3 w0.084: v1(150.5,139.84) 150.5,139.94 150.99,140.43 152.93,140.43 152.98,140.38 155.34,140.38 155.74,140.79 158.04,140.79 159.39,139.44 159.65,139.44 160.1,138.98
  IN3 w0.114: v3(161.02,138.06) 160.1,138.98
  BOTTOM w0.084: UV1.AG29 150.5,139.86 v1(150.5,139.84)
DOCK_AUX: length 277.3
  TOP w0.114: UX1.55 28.65,64.95 28.73,64.86 29.01,64.86 v5(29.27,65.11)
  IN3 w0.114: v3(230.4,146.22) 230.4,146.69 230.27,146.83 229.7,146.83 229.57,146.7 229.24,146.7 229.12,146.83 228.78,146.83 228.66,146.7 228.33,146.7 228.2,146.83 227.87,146.83 227.74,146.7 227.41,146.7 227.29,146.83 226.35,146.83 226.09,146.58 226.09,146.4 225.86,146.16 225.68,146.16 217.28,137.76 217.28,136.71 206.9,126.33 190.15,126.33 189.69,126.79 180.71,126.79 179,125.07 179,123.29 178.67,122.96 174.73,122.96 174.03,122.26 173.04,122.26 170.44,124.87 164.1,124.87 161.78,127.19 159.99,127.19 156.97,130.21 149.98,130.21 149.12,131.08 137.06,131.08 136.38,130.39 124.5,130.39 121.76,127.65 83.43,127.65 78.95,123.17 78.95,121.75 77.17,119.97 77.17,119.41 75.58,117.82 68.87,117.82 66.35,115.31 63.04,115.31 62.48,115.86 55.3,115.86 46.28,106.85 44.01,106.85 32.15,94.99 31.68,94.99 29.39,92.7 25.63,92.7 24.26,91.33 24.26,86.88 21.16,83.78 21.16,78.96 24.93,75.19 24.93,68.69 28.71,64.91 29.06,64.91 v5(29.27,65.11)
  BOTTOM w0.114: v3(230.4,146.22) 230.55,146.37 230.71,146.37 230.89,146.19 R107.2 231.36,145.7 231.75,145.31 232.01,145.05 232.01,144.86 JU3LC.1
DOCK_AUX#: length 277.3
  TOP w0.114: UX1.54 28.66,64.55 28.74,64.63 29.03,64.63 v3(29.18,64.48)
  IN3 w0.114: v3(230.96,146.78) 230.96,146.78 230.61,146.78 230.35,147.03 226.26,147.03 217.07,137.84 217.07,136.79 206.81,126.53 190.23,126.53 189.78,126.99 180.63,126.99 178.8,125.16 178.8,123.38 178.59,123.17 174.65,123.17 173.95,122.47 173.13,122.47 170.52,125.07 164.19,125.07 161.86,127.4 160.08,127.4 157.05,130.42 150.07,130.42 149.21,131.28 136.98,131.28 136.29,130.6 124.42,130.6 121.67,127.85 83.34,127.85 78.75,123.26 78.75,121.83 76.97,120.05 76.97,119.5 75.49,118.02 68.78,118.02 66.27,115.51 63.13,115.51 62.57,116.07 55.22,116.07 46.2,107.05 43.92,107.05 32.06,95.19 31.6,95.19 29.31,92.9 25.55,92.9 24.06,91.41 24.06,86.97 20.96,83.87 20.96,78.87 24.73,75.11 24.73,68.61 28.62,64.71 28.96,64.71 v3(29.18,64.48)
  BOTTOM w0.114: JU3LC.2 232.32,145.25 232.13,145.25 231.84,145.54 231.51,145.87 R106.2 231.08,146.33 230.96,146.44 v3(230.96,146.78)
DOCK_CONSUMP: length 74.5
  TOP w0.114: v3(240.67,170.12) v4(241.33,170.12) 241.66,170.12 243.09,171.55 JU3LF.9
  IN3 w0.114: v3(240.67,170.12) 239.63,170.12 237.45,167.93 237.45,162.7 235.21,160.47 231.68,160.47 229.44,158.22 211.29,158.22 205.72,163.79 185.36,163.79 v3(182.56,166.59)
  BOTTOM w0.254: v3(182.56,166.59) 182.38,166.77 PR108.2
DOCK_TX0+: length 285.2
  TOP w0.114: UX1.40 26.47,58.66 26.37,58.57 26.37,58.21 v1(26.63,57.95)
  IN3 w0.114: v3(232.57,146.37) 232.57,146.67 232.37,146.88 231.65,146.88 230.84,147.69 230.49,147.69 230.37,147.56 230.04,147.56 229.91,147.69 229.58,147.69 229.45,147.56 229.12,147.56 228.99,147.69 228.66,147.69 228.54,147.56 228.21,147.56 228.08,147.69 226.2,147.69 216.21,137.7 216.21,136.63 206.97,127.4 202.93,127.4 202.09,128.23 188.91,128.23 188.78,128.11 181.07,128.11 179.87,129.31 172.42,129.31 171.48,128.37 171.48,127.52 169.52,125.57 165.11,125.57 162.74,127.93 162.58,127.93 159.59,130.93 150.26,130.93 149.24,131.95 136.8,131.95 136,131.15 124.27,131.15 121.48,128.36 83.11,128.36 78.24,123.48 78.24,122.03 76.43,120.22 76.43,119.69 75.38,118.63 67.77,118.63 67.29,118.15 67.29,118.05 65.79,116.55 65,116.55 64.42,117.13 63.38,117.13 62.95,116.7 55.15,116.7 46.03,107.58 43.09,107.58 28.94,93.44 25.38,93.44 23.02,91.07 23.02,86.68 20.47,84.13 20.47,78.67 23.22,75.91 23.22,69.36 28.05,64.54 28.05,60.31 26.35,58.61 26.35,58.24 v1(26.63,57.95)
  BOTTOM w0.114: v3(232.57,146.37) 232.96,146.37 233.2,146.12 233.2,145.79 JU3LC.4
DOCK_TX0-: length 285.2
  TOP w0.114: v5(26,57.93) 26.14,58.07 26.14,58.54 26.07,58.61 UX1.39
  IN3 w0.114: v3(233,146.88) 232.99,146.87 232.66,146.87 232.45,147.08 231.74,147.08 230.93,147.89 226.12,147.89 216.01,137.78 216.01,136.72 206.89,127.6 203.01,127.6 202.17,128.44 188.82,128.44 188.69,128.31 181.16,128.31 179.95,129.52 172.33,129.52 171.27,128.46 171.27,127.6 169.44,125.77 165.19,125.77 162.83,128.13 162.67,128.13 159.67,131.13 150.35,131.13 149.32,132.16 136.71,132.16 135.91,131.36 124.19,131.36 121.39,128.56 83.03,128.56 78.03,123.57 78.03,122.11 76.23,120.31 76.23,119.78 75.29,118.84 67.69,118.84 67.09,118.23 67.09,118.13 65.71,116.75 65.09,116.75 64.5,117.34 63.29,117.34 62.86,116.91 55.07,116.91 45.95,107.79 43.01,107.79 28.86,93.64 25.3,93.64 22.82,91.16 22.82,86.76 20.26,84.21 20.26,78.58 23.02,75.83 23.02,69.28 27.84,64.45 27.84,60.4 26.14,58.7 26.14,58.07 v5(26,57.93)
  BOTTOM w0.114: v3(233,146.88) 233,146.65 233.53,146.12 233.58,146.12 JU3LC.5
DOCK_TX1+: length 295.2
  TOP w0.114: v3(25.08,57.98) 24.95,58.1 24.95,58.31 25.09,58.46 25.09,58.7 25.27,58.88 UX1.37
  IN3 w0.114: v3(25.08,57.98) 25.04,57.98 24.85,58.16 24.85,58.39 27.21,60.76 27.21,64.33 22.51,69.03 22.51,75.63 19.6,78.54 19.6,84.41 21.28,86.09 21.28,90.98 24.63,94.32 28.69,94.32 42.76,108.4 45.58,108.4 47,109.81 47,111.46 51.4,115.86 52.03,115.86 53.6,117.44 62.41,117.44 62.82,117.85 65.31,117.85 66.81,119.34 73.72,119.34 74.68,120.31 75.52,120.31 77.5,122.29 77.5,123.79 82.83,129.12 121.24,129.12 124.16,132.04 129.5,132.04 129.93,132.48 136.26,132.48 136.44,132.65 149.55,132.65 150.57,131.64 159.87,131.64 162.86,128.64 163.02,128.64 165.36,126.3 169.27,126.3 170.78,127.81 170.78,129.45 172.23,130.9 174.09,130.9 174.9,130.09 182.56,130.09 183.39,130.93 185.58,130.93 185.65,131 186.37,131 187.28,130.09 201.28,130.09 203.26,128.11 206.66,128.11 215.19,136.64 215.19,137.7 219.82,142.32 219.82,145.22 225.67,151.07 229.76,151.07 229.89,150.94 230.22,150.94 230.35,151.07 230.68,151.07 230.8,150.94 231.13,150.94 231.26,151.07 231.59,151.07 231.72,150.94 232.05,150.94 232.18,151.07 232.47,151.07 232.62,150.92 v1(232.62,150.53)
  BOTTOM w0.114: v1(232.62,150.53) 233.08,150.53 233.58,150.03 233.58,147.77 233.99,147.36 233.99,147.31 234.22,147.08 234.22,146.89 JU3LC.7
DOCK_TX1-: length 295.2
  TOP w0.114: v1(24.44,57.98) 24.72,58.26 24.72,58.41 24.87,58.55 UX1.36
  IN3 w0.114: v1(233.08,151.04) 232.78,151.04 232.55,151.27 225.58,151.27 219.61,145.3 219.61,142.41 214.99,137.78 214.99,136.73 206.58,128.31 203.34,128.31 201.36,130.29 187.36,130.29 186.45,131.21 185.57,131.21 185.49,131.13 183.31,131.13 182.47,130.29 174.99,130.29 174.17,131.1 172.14,131.1 170.57,129.54 170.57,127.89 169.19,126.51 165.44,126.51 163.11,128.84 162.95,128.84 159.95,131.84 150.65,131.84 149.64,132.86 136.35,132.86 136.18,132.68 129.84,132.68 129.41,132.25 124.08,132.25 121.15,129.32 82.75,129.32 77.3,123.87 77.3,122.37 75.44,120.51 74.6,120.51 73.63,119.55 66.72,119.55 65.23,118.05 62.74,118.05 62.33,117.64 53.52,117.64 51.95,116.07 51.31,116.07 46.79,111.55 46.79,109.89 45.5,108.6 42.68,108.6 28.61,94.53 24.54,94.53 21.08,91.07 21.08,86.17 19.4,84.49 19.4,78.45 22.31,75.55 22.31,68.94 27.01,64.24 27.01,60.84 24.64,58.48 24.64,58.18 v1(24.44,57.98)
  BOTTOM w0.114: JU3LC.8 234.53,147.28 234.34,147.28 234.22,147.41 234.22,147.45 233.81,147.86 233.81,150.12 233.08,150.86 v1(233.08,151.04)
DOCKDP_HPD: length 392.7
  TOP w0.114: UX1.32 23.27,58.22 v3(23.17,58.13) 22.66,57.62 R108.1 ; v3(244.26,155.41) 244.9,155.41 247.83,158.35 247.83,160.67 245.84,162.66 245.84,169.39 246.31,169.86 246.31,171.03 245.88,171.46 245.42,171.46 245,171.05 JU3LF.8 ; v3(157.66,32.49) 157.78,32.49 159.37,34.08 169,34.08 171.7,36.77 172.83,36.77 174.88,34.72 186.48,34.72 v4(188.25,36.49) v3(189.41,36.49)
  IN1 w0.14: v3(189.41,36.49) 189.51,36.49 191.17,38.15 191.17,38.73 197.98,45.54 197.98,50.47 200.59,53.08 200.59,62.61 201.5,63.52 201.5,65.27 202.07,65.84 202.07,68.96 207.79,74.68 207.79,81.52 206.3,83.01 206.3,93.21 207.7,94.6 207.7,109.64 v3(206.69,110.66)
  IN2 w0.14: v3(23.17,58.13) 25.4,55.9 26.21,55.9 29.13,52.99 29.13,37.54 32.31,34.35 32.31,28.77 32.95,28.13 32.95,26.41 37.47,21.88 37.5,21.88 41.94,17.44 v3(41.94,17.31)
  IN3 w0.114: v3(159.14,19.43) 158.79,19.08 152.56,19.08 147.61,14.14 141.46,14.14 138.12,10.8 121.12,10.8 114.11,17.81 42.44,17.81 v3(41.94,17.31) ; v3(244.26,155.41) 244.26,154.62 234.17,144.53 234.17,143.04 233.86,142.74 232.49,142.74 223.14,133.39 222.08,133.39 216.64,127.96 216.64,121.22 206.69,111.27 v3(206.69,110.66)
  BOTTOM w0.114: v3(157.66,32.49) 159.14,31.02 v3(159.14,19.43)
DP_DDC_CLK: length 11.2
  TOP w0.076: v3(112.4,99.15) 112.54,99.29 114.06,99.29 114.64,99.86 RC1.2
  IN1 w0.076: v3(106.58,97.59) 106.97,97.98 108.09,97.98
  IN1 w0.14: v3(112.4,99.15) 111.44,100.11 110.22,100.11 108.09,97.98
  BOTTOM w0.076: UC1.N7 v3(106.58,97.59)
DP_DDC_DAT: length 14.5
  TOP w0.076: RC2.2 117.33,99.13 117.05,99.4 115.2,99.4 115.02,99.58 114.64,99.58 114.1,99.04 112.94,99.04 112.64,98.74 112.15,98.74 v3(111.72,99.18)
  IN1 w0.14: v3(111.72,99.18) 111.06,99.83 110.26,99.83 107.62,97.19 106.34,97.19 v3(105.94,97.59)
  BOTTOM w0.076: UC1.N8 v3(105.94,97.59)
DP_HPD_R: length 2.7
  TOP w0.305: UVG2.11 29.08,91.8 29.37,92.09 v4(29.37,92.34) 29.37,93.28 RVG129.2
DPAB: length 7.7
  TOP w0.114: v3(162.29,138.04) 162.49,138.04 TPV21.1
  BOTTOM w0.084: UV1.AW28 157.8,140.92 159.25,139.46 160.1,139.46
  BOTTOM w0.114: v3(162.29,138.04) 162.29,138.17 160.99,139.46 160.1,139.46
DPCD: length 1.5
  TOP w0.084: TPV22.1 158.4,149.16 v1(158.3,149.06)
  BOTTOM w0.102: UV1.AW18 158,149.36 v1(158.3,149.06)
DPLS: length 14
  TOP w0.084: 160.1,138.39 159.44,137.73 v3(158.87,137.73)
  TOP w0.114: 160.1,138.39 TPV18.1
  IN3 w0.084: v3(158.87,137.73) 157.74,137.73 156.2,139.28 155.52,139.28 155.32,139.47 152.27,139.47 151.89,139.09 150.05,139.09 149.71,139.44 v1(149.41,139.44)
  BOTTOM w0.084: v1(149.41,139.44) 149.41,139.75 UV1.AF29
DRAM_RST: length 17.6
  TOP w0.305: v1(151.75,155.51) 151.54,155.31 CV78.1
  IN3 w0.305: v1(151.75,155.51) 152.28,154.98 154.34,154.98 154.82,155.46 158.96,155.46 160.15,156.66 v3(161.37,156.66)
  BOTTOM w0.254: RV28.2 164.67,154.68 RV29.1 164.67,155.97 v4(163.99,156.66) v3(161.37,156.66)
  BOTTOM w0.305: UV1.AH11 150.6,155.26 150.81,155.46 151.69,155.46 v1(151.75,155.51)
DRVON: length 183.4
  TOP w0.254: v3(123.04,114.19) 123.04,115.5 122.8,115.74 122.8,120.63 123.22,121.05 123.22,123 121.6,124.63 v3(121.6,125.01) ; v3(142.8,88.69) 143.01,88.89 143.01,91.85 141.46,93.4 141.46,95.46 139.77,97.14 131.88,97.14 129.97,99.05 127.56,99.05 125.24,101.36 v3(125.24,102.11)
  IN1 w0.254: v3(38.31,76.85) 38.31,76.98 37.6,77.69 37.6,79.36 40.37,82.13 40.37,90.24 49.36,99.23 v3(52.2,99.23)
  IN2 w0.254: v3(52.2,99.23) 52,99.23 51.67,99.56 51.67,101.63 53.55,103.51 53.55,106.08 57.36,109.89 58.1,109.89 61.65,113.45 61.65,116.05 64.18,118.58 66.68,118.58 67.19,118.07 67.19,117.54 67.42,117.31 v1(67.47,117.31) 67.85,117.31 68.38,117.84 68.38,117.84 68.38,118.86 68.09,119.15 68.09,121.92 69.44,123.27 72.04,123.27 74.33,125.56 76.35,125.56 78.48,127.69 87.69,127.69 88.22,127.16 88.22,126.91 88.82,126.3 98.58,126.3 99.27,125.62 102.88,125.62 103.94,126.68 116.43,126.68 117.68,125.43 121.17,125.43 v3(121.6,125.01)
  BOTTOM w0.203: PU401.35 68.76,117.89 68.18,117.31 v1(67.47,117.31)
  BOTTOM w0.254: PU403.3 38.22,76.76 v3(38.31,76.85) ; v3(123.04,114.19) 123.04,113.76 122.4,113.11 122.4,108.89 124.42,106.87 124.42,103.29 125.05,102.66 125.05,102.3 v3(125.24,102.11) 126.32,102.11 PU402.3 ; v3(142.8,88.69) 142.8,87.54 141.65,86.38 PU404.3
EC_AGND: length 4.9
  TOP w0.203: UE1.75 184.63,52.87 184.49,52.72
  TOP w0.381: LE2.1 181.51,52.87 CE2.2 CE3.2 183.42,52.87 183.83,52.47 v2(184.21,52.47) 184.46,52.72 184.49,52.72
EC_DPWROK: length 101.1
  TOP w0.114: v3(122.94,63.01) 120.53,63.01 118.65,61.13 110.42,61.13 108.93,62.62 108.93,63.77 109.09,63.94 RC392.2 109.45,64.39 v4(108.96,64.88) 108.67,64.88 106.36,67.2 106.36,69.94 RC383.1 105.58,70.72 104.51,70.72 104.21,71.02 RC286.1 ; v3(186.95,45) 186.95,44.79 186.62,44.47 UE1.96
  IN2 w0.14: v3(122.94,63.01) 123.48,63.54 132.21,63.54 134.22,61.53 137.4,61.53 138.85,60.07 141.09,60.07 144.78,56.39 154.02,56.39 v3(158.81,51.6)
  IN3 w0.114: v3(186.95,45) 186.77,44.82 184.51,44.82 182.53,46.8 175.42,46.8 174.02,48.2 165.89,48.2 163.51,50.59 159.82,50.59 v3(158.81,51.6)
EC_DPWROK_R: length 13.2
  TOP w0.114: v3(102.05,74.88) 102.83,74.1 102.83,72.65 RC373.2 RC286.2
  BOTTOM w0.076: 100.55,78.54 100.55,78.95 99.34,80.16 99.34,80.92 98.75,81.51 98.75,82.3 UC1.BB20
  BOTTOM w0.102: 100.55,78.54 100.55,75.97 101.64,74.88 v3(102.05,74.88)
EC_FAN_PWM: length 328.5
  TOP w0.114: v3(196.3,56.38) 196.39,56.47 UE1.31 202.81,56.47 203.08,56.73 203.08,57.11 202.88,57.32 202.88,57.72 v2(202.95,57.8) 203.46,57.8 203.88,57.38 RE8.1 ; v3(149.66,40.48) 152.61,40.48 154.13,38.95 167.47,38.95 169.81,41.29 v3(172.4,41.29)
  IN1 w0.14: v3(174.71,60.62) 175.68,59.65 175.68,54.68 174.66,53.67 174.66,43.05 172.9,41.29 v3(172.4,41.29)
  IN2 w0.14: v3(174.71,60.62) 175.01,60.92 182.6,60.92 183.67,59.86 184.71,59.86 185.73,58.84 187.48,58.84 190.58,55.74 195.66,55.74 v3(196.3,56.38) ; v3(149.66,40.48) 147.91,40.48 146.23,42.15 129.1,42.15 128.89,41.94 128.89,34.27 124.59,29.98 124.59,16.82 122.58,14.81 49.32,14.81 36.58,27.54 36.58,34.3 36.43,34.46 32.39,38.5 32.39,60.34 31.6,61.13 31.6,63.31 30.92,64 30.92,66.44 30.11,67.25 30.11,71.09 30.46,71.45 30.46,73 32.3,74.84 32.3,76.56 33.86,78.13 33.86,78.62 37.32,82.07 37.32,83.21 39.6,85.5 39.6,94.01 49.33,103.74 49.33,110.39 55.76,116.82 v3(55.76,118.8)
  BOTTOM w0.114: v3(55.76,118.8) 55.76,118.8 55.76,118.81 56.5,118.07 JFAN.1
EC_FAN_SPEED: length 350
  TOP w0.114: v3(149.66,41.14) 152.77,41.14 154.65,39.26 167.34,39.26 170.01,41.92 v3(172.4,41.92) ; v3(194.25,57.19) 194.11,57.33 UE1.47 194.11,60 194.17,60.06 194.17,61.01 193.56,61.61 193.56,63.42 194.39,64.25 194.39,65.6 192.46,67.53 191.46,67.53 189.15,65.22 189.15,64.39 188.87,64.11 188.17,64.11 187.79,64.49 185.44,64.49 184.29,63.34 v4(180.42,63.34) 178.95,63.34 177.86,64.42 RPE3.7
  IN1 w0.14: v3(172.4,41.92) 174.37,43.9 174.37,53.75 175.41,54.8 175.41,58.9 174.15,60.16 174.15,62.3 v3(173.41,63.03)
  IN2 w0.14: v3(173.41,63.03) 174.07,62.37 189.07,62.37 v3(194.25,57.19) ; v3(149.66,41.14) 147.81,41.14 146.46,42.48 138.58,42.48 137.79,43.27 136.4,43.27 135.77,42.64 129.15,42.64 128.58,42.07 128.58,34.4 124.29,30.11 124.29,16.95 122.42,15.08 49.8,15.08 36.89,27.99 36.89,34.64 32.8,38.73 32.8,63.92 32.37,64.35 31.55,64.35 31.2,64.71 31.2,66.77 30.38,67.58 30.38,70.83 30.74,71.19 30.74,72.9 32.56,74.72 32.56,76.45 34.13,78.02 34.13,78.51 37.59,81.96 37.59,83.1 39.87,85.39 39.87,93.9 49.6,103.63 49.6,106.28 52.66,109.34 52.66,110.99 55.96,114.29 v3(56.9,114.29)
  BOTTOM w0.114: JFAN.3 59,115.78 57.51,114.29 v3(56.9,114.29)
EC_GS_ON#: length 76
  TOP w0.114: UE1.106 190.91,44.36 v3(193,46.45) ; RG4.1 197.85,70.98 v4(200.73,73.86) 203.45,73.86 204.7,75.12 206.81,75.12 208.21,73.73 216.85,73.73 217.56,73.01 217.56,64.73 216.21,63.39 216.21,60.36 214.6,58.75 214.6,50.17 v3(213.19,48.76)
  BOTTOM w0.114: v3(193,46.45) 196.32,49.77 200.06,49.77 200.26,49.98 212.55,49.98 213.19,49.34 v3(213.19,48.76)
EC_MUTE#: length 45.5
  TOP w0.114: v3(216.07,32.84) 216.78,32.84 218.07,31.56 v4(218.07,30.09) 218.07,26.89 217.25,26.08 DA5.1 ; v3(186.98,41.21) 187.31,41.21 187.71,40.81 187.87,40.81 RE32.1 RE31.1 188.78,41.52 188.51,41.78 UE1.100
  BOTTOM w0.114: v3(186.98,41.21) 187.51,41.21 189.31,39.41 195,39.41 199.19,35.22 213.7,35.22 v3(216.07,32.84)
EC_ON: length 97.8
  TOP w0.114: v3(178.81,48.83) 179.06,49.09 180.07,49.09 181.95,50.97 182.81,50.97 183.19,50.59 RE39.1 183.7,50.41 184.44,49.67 UE1.83
  TOP w0.254: v3(164.12,4.05) 163.96,3.9 v4(163.96,3.42) 164.09,3.29 PR206.1
  IN1 w0.14: v3(178.81,48.83) 179.43,48.21 179.43,40.91 176.46,37.94 176.46,15.36 v3(175.52,14.42)
  IN3 w0.114: v3(175.52,14.42) 173.89,12.79 151.75,12.79 149.28,10.32 149.28,2.71 149.59,2.4 162.36,2.4 164.01,4.05 v3(164.12,4.05)
EC_ON2: length 308.5
  TOP w0.114: v3(139.17,43.93) 139.76,43.35 152.2,43.35 155.71,39.84 167.06,39.84 169.25,42.03 v4(169.25,54.93) v3(169.91,55.59) ; v3(181.31,187.03) 181.31,186.43 PD801.1 ; v3(186.18,164.89) 183.13,164.89 180.4,162.16 175.13,162.16 169.58,167.71 v3(169.58,167.96) ; v3(205.87,54.78) 205.8,54.78 205.03,55.54 RE42.2
  TOP w0.254: PD801.1 182.2,186.86 PR801.1
  IN1 w0.14: v3(194.42,67.78) 194.65,67.78 202.74,75.87 202.74,94.41 202.11,95.04 202.11,118.61 204.3,120.79 204.3,128.18 203.43,129.05 203.43,129.45 205.14,131.15 v3(206.23,131.15)
  IN2 w0.14: v3(206.23,131.15) 207.63,131.15 211.55,135.08 211.55,137.25 212.85,138.55 214.25,138.55 224.06,148.36 224.06,157.54 221.89,159.7 212.85,159.7 208.22,164.33 186.73,164.33 v3(186.18,164.89) ; v3(181.31,187.03) 180.12,185.85 175.64,185.85 174.94,186.55 172.7,186.55 170.53,184.38 170.53,178.39 169.28,177.15 169.28,171.25 170.14,170.4 170.14,168.52 v3(169.58,167.96)
  BOTTOM w0.114: v3(194.42,67.78) 197.36,67.78 202.75,62.4 202.75,62.12 203.33,61.53 203.92,61.53 207.47,57.98 207.47,56.38 v3(205.87,54.78) 204.11,54.78 203.86,54.54 202.6,54.54 200.93,56.2 199.61,56.2 197.44,58.37 188.29,58.37 187.57,57.65 181.06,57.65 178.29,54.88 176.87,54.88 176.52,55.22 174.45,55.22 174.33,55.35 172.87,55.35 172.4,55.82 170.14,55.82 v3(169.91,55.59)
  BOTTOM w0.254: PR701.1 v3(139.17,43.93)
EC_ON2_R: length 3
  TOP w0.114: UE1.28 v4(202.73,55.27) 203.16,55.69 203.94,55.69 RE42.1
EC_RSMRST#: length 117.5
  TOP w0.114: 103.23,73.15 103.23,75.38 v3(102.12,76.49) ; 104.72,72.68 105.48,72.68 ; UE1.93 v3(186.95,45.67)
  TOP w0.127: 103.23,73.15 RC373.1 104.72,72.68 ; 105.48,72.68 RC27.2
  IN2 w0.14: v3(120.71,64.44) 122.37,64.44 122.74,64.07 132.43,64.07 134.44,62.06 137.62,62.06 139.07,60.61 141.31,60.61 143.47,58.45 152.33,58.45 158.68,52.11 159.06,52.11 v3(159.57,51.6)
  IN3 w0.114: v3(159.57,51.6) 160.25,50.92 163.84,50.92 165.94,48.81 174.05,48.81 175.67,47.18 182.66,47.18 184.17,45.67 v3(186.95,45.67)
  BOTTOM w0.076: 102.19,75.6 102.12,75.67 v3(102.12,76.49) 102.12,78.6 99.87,80.85 99.87,81.99 99.68,82.18 99.68,82.44 99.73,82.56 99.73,82.7 99.67,82.93 99.67,83.05 99.74,83.26 99.84,83.37 99.94,83.48 UC1.AY17 ; 104.4,70.17 103.65,70.92
  BOTTOM w0.102: 103.65,70.92 102.67,71.9 102.67,75.12 102.19,75.6
  BOTTOM w0.114: v3(120.71,64.44) 119.44,64.44 118.68,63.68 113.54,63.68 110.09,67.13 107.44,67.13 104.4,70.17
EC_RX: length 146.6
  TOP w0.114: UE1.16 199.94,50.47 v3(199.7,50.23)
  IN1 w0.14: v3(223.04,155.72) 223.5,155.26 223.5,154.66 220.71,151.87 220.71,149.81 220.51,149.6 220.51,146.45 218.67,144.62 216.26,144.62 215.13,143.49 215.13,141.84 215.47,141.49 215.47,140.53 212.96,138.01 212.63,138.01 211.57,136.95 211.57,134.62 210.98,134.03 210.98,129.18 208.25,126.45 208.25,94.38 206.85,92.98 206.85,83.21 208.32,81.74 208.32,74.46 202.6,68.74 202.6,64.75 202.7,64.65 202.7,61.39 202.29,60.98 202.29,57.32 202.09,57.11 202.09,53.74 199.7,51.35 v3(199.7,50.23)
  BOTTOM w0.114: R90.2 238.51,167.04 v4(237.8,166.33) 237.8,158.46 237.22,157.88 235.49,157.88 234.84,157.23 231.38,157.23 229.89,155.74 228.7,155.74 227.85,156.59 223.92,156.59 v3(223.04,155.72)
EC_SCI#: length 201.5
  TOP w0.114: RPC22.2 114.73,64.3 v3(114.81,64.38) ; v4(154.01,53.48) v3(153.37,53.48) ; v3(199.45,53.41) 199.59,53.27 UE1.23
  IN1 w0.076: v3(107.3,98.52) 107.97,98.52 108.64,99.18 108.64,99.46
  IN1 w0.14: v3(149.33,98.19) 148.72,97.58 148.27,97.58 147.1,98.74 145.64,98.74 144.37,97.47 128,97.47 125.33,100.14 123.65,100.14 123.47,99.96 120.34,99.96 119.89,99.51 117.1,99.51 116.2,100.41 114.24,100.41 113.47,101.18 111.72,101.18 111.13,100.59 109.78,100.59 108.64,99.46 ; v3(166.6,52.16) 166.55,52.11 164.85,52.11 162.44,54.52 162.44,57.9 155.71,64.63 155.71,65.9 150.68,70.93 v3(150.22,70.93)
  IN2 w0.14: v3(153.37,53.48) 152.81,54.04 144.48,54.04 140.42,58.1 138.18,58.1 136.63,59.66 131.97,59.66 131.76,59.45 130.64,59.45 129.11,60.97 126.65,60.97 125.94,60.26 118.93,60.26 v3(114.81,64.38) ; v3(149.33,98.19) 149.41,98.11 149.41,96.18 148.58,95.35 148.58,93.56 147.96,92.94 147.96,92.14 148.44,91.66 148.44,90.92 147.94,90.41 147.94,76.37 148.39,75.91 148.39,72.76 v3(150.22,70.93)
  IN3 w0.114: v3(166.6,52.16) 166.4,52.36 154.49,52.36 v3(153.37,53.48)
  BOTTOM w0.076: UC1.M1 109.61,98.8 109.28,98.46 107.35,98.46 v3(107.3,98.52)
  BOTTOM w0.114: v3(166.6,52.16) 168.43,52.16 169.07,52.8 188.55,52.8 191.16,55.41 195.3,55.41 196.45,54.26 198.6,54.26 v3(199.45,53.41)
EC_SMB_CK1: length 234.4
  TOP w0.178: UE1.115 194.51,44.56 v3(194.99,45.04)
  TOP w0.203: RPE5.8 195.14,40.01 194.51,40.64 UE1.115
  TOP w0.254: RPE5.8 195.14,39.5 194.44,38.8 194.44,37.35 IT1.1 ; PR15.2 v3(195.28,184.85)
  IN1 w0.254: v3(195.28,184.85) 195.07,184.63 194.43,184.63 193,183.2 191.47,183.2 185.72,177.45 179.37,177.45 178.8,178.02 177.11,178.02 175.9,176.81 175.9,176.58 172.54,173.22 171.58,173.22 v3(171.33,173.47) ; v3(226.24,183.07) 226.17,183 226.17,177.59 224.34,175.76 224.34,159.65 222.54,157.85 222.54,154.57 221.43,153.46 219.64,153.46 218.98,152.8 218.98,149.85 219.92,148.91 219.92,146.72 218.42,145.22 215.93,145.22 214.46,143.75 214.46,140.91 v3(214.61,140.76) ; v3(194.99,45.04) 194.85,45.18 194.85,56.43 195.21,56.78 195.21,59.68 197.17,61.65 197.17,62.92 199.06,64.8 199.06,67.77 201.05,69.76 201.66,69.76 205.21,73.31 205.21,95.75 204.55,96.41 204.55,102.63 205.9,103.98 v3(205.9,104.41)
  IN2 w0.254: v3(226.24,183.07) 226.24,183.35 225.71,183.89 221.21,183.89 220.63,183.3 216.34,183.3 215.63,184.01 211.61,184.01 209.23,186.4 199.7,186.4 197.92,184.62 195.51,184.62 v3(195.28,184.85)
  BOTTOM w0.254: v3(214.61,140.76) 214.61,139.89 212.68,137.96 211.51,137.96 205.59,132.04 205.59,130.32 206.38,129.53 206.38,115.28 202.47,111.37 202.47,109.06 205.85,105.68 205.85,104.47 v3(205.9,104.41) ; PR121.1 v3(171.33,173.47)
EC_SMB_CK3: length 451.1
  TOP w0.114: v3(146.97,88.81) 148.19,87.59 158.65,87.59 v5(158.88,87.37) ; UE1.94 184.59,45.27 183.63,44.31 182.73,44.31 v3(182.17,44.87) ; v3(196.2,40.5) 196.2,40.35 196.64,39.9 RPE5.5 ; v3(204.27,62.19) 205.39,63.31 210.24,63.31 213.34,66.41 213.34,67.53 212.96,67.91 211.94,67.91 211.5,68.36 QG2.6 ; JU3LF.6 244.27,170.04 242.02,170.04 240.93,168.95 240.37,168.95 v3(239.93,169.38) ; v3(161.63,144.52) 161.4,144.29 RV144.2 161.75,143.85 162.01,144.11 162.01,144.24 162.47,144.7 QV5.6
  IN1 w0.14: v3(177.86,63.79) 182.17,59.48 v3(182.17,44.87) ; v3(112.12,95.8) 112.53,96.21 112.8,96.21 113.26,96.67 115.11,96.67 115.32,96.89 116.97,96.89 117.25,96.61 119.34,96.61 119.7,96.24 124.53,96.24 125.2,95.57 125.2,93.26 126.17,92.29 126.88,92.29 127.51,92.93 134.14,92.93 134.54,92.53 141.3,92.53 143.87,89.96 146.28,89.96 146.79,89.45 146.79,88.99 v3(146.97,88.81)
  IN2 w0.14: v3(177.86,63.79) 177.5,64.15 170.83,64.15 161.19,73.79 161.19,74.69 160.61,75.27 160.61,85.64 v5(158.88,87.37) 158.32,87.92 158.32,91 160.57,93.25 160.57,96.16 160.84,96.42 160.84,114.04 158.25,116.63 158.25,118.15 159.03,118.92 161.74,118.92 165.39,122.57 165.39,123.57 163.58,125.37 163.58,130.39 163.06,130.91 163.06,133.07 v1(163.12,133.14) 162.95,133.31 162.95,142.86 161.63,144.18 v3(161.63,144.52) 163,145.89 163,152.34 162.62,152.72 162.62,158.54 163,158.92 163,162.14 168.75,167.89 168.75,177.37 170,178.61 170,184.74 167.41,187.33 124,187.33 120.15,183.48 120.15,182.26 v3(120.12,182.23) ; v3(182.17,44.87) 183.27,45.96 184.44,45.96 188.73,41.67 195.36,41.67 196.2,40.83 v3(196.2,40.5)
  IN3 w0.114: v1(163.12,133.14) 163.19,133.2 164.2,133.2 165.6,131.8 171.12,131.8 171.86,132.54 178.11,132.54 178.53,132.96 201.63,132.96 202.8,134.12 207.1,134.12 212.8,139.82 214.98,139.82 218.16,143 218.16,145.9 227.72,155.46 227.72,156.76 228.89,157.93 229.48,157.93 231.77,160.21 235.34,160.21 237.69,162.56 237.69,167.79 239.27,169.38 v3(239.93,169.38) ; v3(204.27,62.19) 203.33,61.25 192.03,61.25 190.86,62.42 179.23,62.42 v3(177.86,63.79)
  BOTTOM w0.076: v3(112.12,95.8) 113.23,95.8 113.9,95.12 114.46,95.12 115.31,95.98 QC2.1
  BOTTOM w0.114: v3(120.12,182.23) 119.79,182.56 118.75,182.56 118.19,183.12 U1.10
EC_SMB_DA1: length 232.4
  TOP w0.178: UE1.116 194.91,44.27 v3(195,44.36)
  TOP w0.203: v3(195.26,40.76) 194.91,41.1 UE1.116
  TOP w0.254: PR14.2 v3(195.33,183.99) ; RPE5.7 195.64,40.37 v3(195.26,40.76) ; v5(193.91,40.22) 193.58,39.89 IT2.1
  IN1 w0.254: v3(225.53,183.2) 225.71,183.02 225.71,177.81 223.91,176.01 223.91,159.83 222.1,158.03 222.1,154.75 221.25,153.89 219.47,153.89 218.55,152.98 218.55,149.67 219.49,148.73 219.49,146.9 218.24,145.66 215.73,145.66 214.03,143.96 214.03,140.71 v3(213.95,140.63) ; v3(195.33,183.99) 195.13,184.19 194.68,184.19 193.26,182.77 191.65,182.77 185.9,177.01 179.19,177.01 178.62,177.59 177.29,177.59 176.33,176.63 176.33,176.4 172.72,172.79 171.51,172.79 v3(171.3,172.58) ; v3(195,44.36) 194.93,44.36 194.39,44.9 194.39,56.61 194.77,56.99 194.77,59.96 196.74,61.93 196.74,63.09 198.63,64.98 198.63,67.95 200.87,70.19 201.48,70.19 204.76,73.47 204.76,95.54 204.12,96.18 204.12,102.81 205.27,103.96 v3(205.27,104.43)
  IN2 w0.254: v3(195.33,183.99) 195.54,184.19 198.1,184.19 199.88,185.97 209.05,185.97 211.44,183.58 215.45,183.58 216.16,182.87 220.81,182.87 221.39,183.45 225.28,183.45 v3(225.53,183.2)
  BOTTOM w0.254: v3(213.95,140.63) 213.95,139.92 212.48,138.45 211.31,138.45 205.11,132.24 205.11,130.12 205.9,129.33 205.9,115.48 201.98,111.57 201.98,108.86 205.42,105.42 205.42,104.58 v3(205.27,104.43) ; v3(195.26,40.76) 194.44,40.76 v5(193.91,40.22) ; PR120.1 v3(171.3,172.58)
EC_SMB_DA3: length 459.2
  TOP w0.114: v3(240.72,167.22) 241.13,167.63 241.13,168.8 242.09,169.76 243.21,169.76 243.43,169.55 JU3LF.5 ; RV142.2 164.24,143.43 QV5.3 163.77,144.45 v3(163.53,144.69) ; v3(147.28,89.45) 148.85,87.87 158.65,87.87 v3(158.91,88.13) ; QG2.3 212.8,66.3 210.11,63.62 204.83,63.62 v3(203.43,62.21) ; v3(183.85,43.22) 183.85,43.9 184.82,44.87 UE1.95 ; v3(189.79,35.47) 190.54,34.72 191.27,34.72 191.98,34.01 197.34,34.01 197.72,34.39 197.72,35.55 197.19,36.08 197.19,38.77 196.86,39.11 196.4,39.11 196.14,39.36 RPE5.6
  IN1 w0.14: v3(189.79,35.47) 188.81,35.47 185.78,38.5 185.78,41.3 v3(183.85,43.22) 183.83,43.22 182.68,44.36 182.68,60.26 v3(179.15,63.79) ; v3(110.34,96.23) 110.45,96.23 110.67,96.46 112.74,96.46 113.17,96.89 115.02,96.89 115.23,97.11 117.14,97.11 117.35,96.89 119.49,96.89 119.87,96.51 124.64,96.51 125.72,95.43 125.72,94.85 126.87,93.7 134.48,93.7 135.04,93.14 141.53,93.14 143.32,91.35 144.86,91.35 145.73,90.49 146.39,90.49 147.28,89.6 v3(147.28,89.45)
  IN2 w0.14: v3(119.39,182.08) 119.39,183.17 123.86,187.64 167.47,187.64 170.26,184.85 170.26,178.5 169.02,177.26 169.02,167.78 163.26,162.03 163.26,158.81 162.88,158.43 162.88,152.83 163.85,151.86 163.85,145.01 v3(163.53,144.69) 163.53,141.54 163.26,141.28 163.26,133.63 163.63,133.26 v1(163.63,132.75) 163.38,132.5 163.38,131.02 163.85,130.55 163.85,125.48 165.66,123.68 165.66,122.46 161.85,118.66 159.14,118.66 158.63,118.15 158.63,116.63 161.11,114.15 161.11,96.31 160.84,96.05 160.84,92.98 158.91,91.05 v3(158.91,88.13) 161.22,85.82 161.22,76.77 161.55,76.44 161.55,73.88 170.9,64.53 178.42,64.53 v3(179.15,63.79)
  IN3 w0.114: v1(163.63,132.75) 163.82,132.95 164.08,132.95 165.47,131.55 171.21,131.55 171.96,132.3 178.21,132.3 178.63,132.71 201.73,132.71 202.9,133.88 207.2,133.88 212.83,139.51 215.01,139.51 218.4,142.9 218.4,145.8 227.96,155.36 227.96,156.66 228.99,157.68 230.28,157.68 232.55,159.96 235.42,159.96 237.93,162.46 237.93,165.93 239.22,167.22 v3(240.72,167.22) ; v3(179.15,63.79) 180.27,62.68 190.97,62.68 192.14,61.51 202.72,61.51 v3(203.43,62.21)
  BOTTOM w0.076: v3(110.34,96.23) 110.52,96.41 113.05,96.41 114.03,95.43 114.33,95.43 114.71,95.81 114.71,97.12 115.19,97.6 115.91,97.6 116.23,97.28 QC2.4
  BOTTOM w0.114: v3(119.39,182.08) 118.55,182.08 117.69,182.94 U1.9
EC_SMCA: length 7.7
  TOP w0.254: PR15.1 v4(197.06,186.04)
  TOP w0.508: PR15.1 198.51,184.85 PD7.3 199.24,187.27 JBATT1.3
EC_SMDA: length 10.1
  TOP w0.114: v4(197.01,182.82) 197.01,183.94 PR14.1
  TOP w0.254: PR14.1 198.05,183 199.59,183 200.65,184.06 201.12,184.06 PD7.2
  TOP w0.508: JBATT1.4 201.17,187.34 PD7.2
EC_TX: length 145.8
  TOP w0.114: v3(199.07,50.26) 199.67,50.87 UE1.17
  IN1 w0.14: v3(223.04,155.03) 223.04,154.6 220.43,151.99 220.43,149.9 220.24,149.71 220.24,146.59 218.55,144.9 216.09,144.9 214.81,143.63 214.81,141.71 215.19,141.33 215.19,140.68 212.91,138.39 212.6,138.39 211.28,137.07 211.28,134.74 210.7,134.15 210.7,129.3 207.97,126.57 207.97,94.49 206.57,93.1 206.57,83.12 208.06,81.63 208.06,74.57 202.34,68.85 202.34,64.64 202.44,64.54 202.44,61.5 202.03,61.09 202.03,57.43 201.78,57.19 201.78,53.89 199.07,51.17 v3(199.07,50.26)
  BOTTOM w0.114: R89.2 238.26,165.24 v4(238.26,164.35) 238.04,164.14 238.04,158.36 237.32,157.63 235.59,157.63 234.94,156.99 231.48,156.99 229.99,155.5 228.6,155.5 227.75,156.35 224.47,156.35 223.15,155.03 v3(223.04,155.03)
EC_TX_R: length 20.1
  IN1 w0.14: v3(238.49,171.54) 238.49,168.11 240.72,165.88 v3(240.72,165.77)
  IN2 w0.14: v3(240.72,165.77) 243.49,168.54 247.63,168.54 v3(248.29,167.88)
  BOTTOM w0.114: v3(238.49,171.54) 238.49,172.12 R152.2 ; JWLBT.64 248.52,167.65 v3(248.29,167.88) ; R89.1 R91.1 240.21,165.27 v3(240.72,165.77)
EC_WAKE#: length 168.8
  TOP w0.114: 200.34,44.87 200.08,44.61 200.08,44.06 202.16,41.98 v4(202.16,41.09) 203,40.25 RE40.2 ; 200.34,44.87 UE1.2 ; 200.34,44.87 199.32,45.89 199.32,47.06 198.91,47.46 198,47.46 197.19,48.27 194.93,48.27 194.34,47.69 193.53,47.69 193.17,48.05 188.47,48.05 v3(187.99,47.56)
  IN1 w0.14: v1(114.99,114.09) 114.64,114.44 114.64,115.23 115.52,116.11 115.52,116.72 118.71,119.91 122.15,119.91 122.82,120.58 133.04,120.58 134.02,119.6 140.93,119.6 141.51,119.01 154.13,119.01 157.18,115.97 157.18,113.71 158.48,112.41 158.48,108.32 160.81,105.98 160.81,96.64 158.41,94.24 158.41,76.18 161.96,72.63 163.02,72.63 171.41,64.24 171.41,62.52 172.68,61.25 172.68,59.33 174.09,57.91 174.09,56.93 173.66,56.5 173.66,55.39 173.82,55.23 173.82,54.7 172.9,53.79 172.9,50.48 v1(173.03,50.36)
  IN2 w0.14: v1(173.03,50.36) 173.89,50.36 176.51,47.74 182.1,47.74 183.77,49.4 186.67,49.4 187.99,48.08 v3(187.99,47.56)
  BOTTOM w0.114: v1(114.99,114.09) 114.99,113.88 112.13,111.03 RC40.1
EC_WAKE#_L: length 8.7
  BOTTOM w0.076: UC1.A6 106.84,105.4 107.74,106.3 109.03,106.3 110.78,108.04 111.28,108.04 v2(111.31,108.07)
  BOTTOM w0.114: RC40.2 112.13,108.89 v2(111.31,108.07)
EC_WLAN_WAKE#: length 185.2
  TOP w0.114: RPE1.5 206.32,58.6 205.92,58.21 205.92,57.52 206.17,57.27 208.34,57.27 208.83,57.76 210.35,57.76 211.6,56.5 212.65,56.5 213.44,55.72 213.44,51.3 211.89,49.75 211.89,48.25 v4(212.98,47.16) 213.54,46.6 v3(214.94,46.6) ; v3(198.63,51.98) 198.95,51.67 UE1.19
  IN1 w0.14: v3(243.03,169.36) 241.64,167.96 241.64,165.55 240.24,164.15 240.24,162.15 238.21,160.12 238.21,150.47 228.02,140.28 228.02,138.72 223.83,134.54 223.83,123.36 216.06,115.58 216.06,111.01 216.62,110.45 216.62,107.46 215.29,106.13 215.29,69.92 219.14,66.06 219.14,60.3 216.52,57.68 216.52,48.17 v3(214.94,46.6)
  BOTTOM w0.114: v3(214.94,46.6) 214.94,48.55 213.24,50.26 202.49,50.26 200.77,51.98 v3(198.63,51.98) ; JWLBT.55 242.78,169.9 243.03,169.65 v3(243.03,169.36)
EDP_COMP: length 2.3
  TOP w0.508: v3(80.05,102.47) 80.05,102.87 RC344.2
  BOTTOM w0.254: UC1.E52 v3(80.05,102.47)
EN_1.8VSP: length 5.9
  TOP w0.114: PD801.2 184.26,185.61 v4(184.61,185.61)
  TOP w0.254: PD801.2 183.68,187.03 v3(183.79,187.14) 183.47,187.47 PR801.2
  BOTTOM w0.254: 183.51,184.63 184.16,185.28 PC803.1 PR802.2 184.16,186.78 v3(183.79,187.14)
ENBKL: length 136.5
  TOP w0.114: v1(121.47,98.15) 121.29,98.15 121.02,98.41 121.02,98.64 RC209.1 ; UE1.81 186.72,50.47 187.25,51 187.25,51.02 187.84,51.6 190.48,51.6 192.84,53.96 v3(192.84,54.47)
  IN1 w0.076: v3(103.4,96.53) 103.92,96.01 108.53,96.01 109.73,97.21
  IN1 w0.14: v3(149.13,81.07) 149.13,86.48 148.29,87.31 148.29,90.59 148.91,91.21 148.91,92.69 148.7,92.9 147.28,92.9 147.01,92.64 144.82,92.64 144.35,93.11 144.35,94.42 143.37,95.4 134.89,95.4 134.25,94.76 126.98,94.76 126.52,95.21 126.52,95.77 124.97,97.32 123.43,97.32 122.72,98.03 121.58,98.03 v1(121.47,98.15) 121.44,98.17 116.91,98.17 116.63,98.45 114.66,98.45 114.23,98.02 114.23,97.83 114.04,97.64 112.87,97.64 112.44,97.21 109.73,97.21
  IN2 w0.14: v3(192.84,54.47) 191.01,54.47 187.28,58.21 185.48,58.21 184.46,59.22 183.55,59.22 182.53,60.24 175.57,60.24 174.8,59.46 165.87,59.46 165.33,60 161.03,60 156.19,64.84 156.19,69.2 154.93,70.46 152.08,70.46 149.92,72.62 149.92,76.9 149.13,77.69 v3(149.13,81.07)
  BOTTOM w0.076: UC1.R12 v3(103.4,96.53)
EXT_MIC_A: length 3.5
  TOP w0.203: RA14.1 v2(212.81,17.54) 211.23,17.54 210.98,17.8 UA1.30
EXT_MIC_B: length 2.5
  TOP w0.203: UA1.31 212.45,18.99 212.63,18.81 v2(212.88,18.81) 213.26,18.43 RA15.1
EXT_PWR_GATE#: length 36.9
  TOP w0.114: v3(123.09,73.93) 123.68,73.93 124.19,74.44 v4(124.38,74.44) 125.36,74.44 126.42,73.37 TC121.1
  IN3 w0.114: v3(123.09,73.93) 123.09,73.61 121.68,72.2 121.68,70.42 121.29,70.03 120.52,70.03 116.96,73.59 115.37,73.59 113.49,75.47 113.49,76.14 111.28,78.35 111.28,78.98 107.31,82.95 106.09,82.95 104.25,84.79 104.25,87.87 v3(103.82,88.29)
  BOTTOM w0.076: UC1.AM10 104.23,88.7 v3(103.82,88.29)
F1_LED#: length 119.3
  TOP w0.114: v4(130.68,81.32) 130.68,81.23 v3(130.21,80.76) ; JKB.27 173.39,114.16 v3(173.67,113.88)
  IN1 w0.14: v3(130.21,80.76) 130.64,80.33 130.64,75.96 132.25,74.35 136.95,74.35 138.59,72.71 138.59,72 139.03,71.56 147.12,71.56 147.81,72.25 147.81,77.23 147.25,77.79 147.25,79.97 146.01,81.22 146.01,83.02 v3(146.41,83.43)
  IN3 w0.114: v3(168.59,102.58) 168.14,102.58 166.96,101.4 166.96,101.1 161.83,95.98 160.79,95.98 156.85,92.04 156.85,91.1 152.99,87.24 151.14,87.24 148.8,84.9 146.89,84.9 146.41,84.42 v3(146.41,83.43) ; v3(112.22,92.45) 111.79,92.01 111.28,92.01 111.08,92.22 111.08,92.67 111.39,92.98 111.69,92.98 112.02,93.31 115.47,93.31 115.75,93.03 118.28,93.03 118.59,92.72 119.31,92.72 120.84,91.19 122.1,91.19 123.49,89.8 123.49,89.51 126.46,86.54 126.46,84.45 127.15,83.75 127.15,82.01 128.47,80.69 130.14,80.69 v3(130.21,80.76)
  BOTTOM w0.076: UC1.AC2 108.97,92.57 110.72,92.57 111.21,92.09 111.87,92.09 v3(112.22,92.45)
  BOTTOM w0.114: v3(173.67,113.88) 173.67,108.85 168.59,103.77 v3(168.59,102.58)
F4_LED#: length 116.3
  TOP w0.114: v3(174.3,113.93) 173.89,114.34 JKB.28 ; v3(129.29,79.69) 129.29,80.16 v4(129.03,80.43)
  IN1 w0.14: v3(129.29,79.69) 128.83,79.24 128.83,78.04 129.9,76.98 129.9,75.88 131.99,73.79 136.61,73.79 137.32,73.08 137.32,72.13 138.44,71.01 147.43,71.01 148.42,72 148.42,77.46 147.86,78.02 147.86,80.89 147.48,81.27 v3(147.48,83.56)
  IN3 w0.114: v3(129.29,79.69) 127.87,79.69 125.29,82.27 125.29,86.08 122.37,89 122.37,89.33 121.72,89.98 121.28,89.98 119.47,91.79 114.81,91.79 114.36,92.24 112.6,92.24 111.85,91.49 111.72,91.49 v3(111.33,91.1) ; v3(167.87,101.31) 167.85,101.31 162.03,95.49 160.99,95.49 157.36,91.86 157.36,90.92 153.05,86.62 151.24,86.62 148.99,84.37 148.29,84.37 v3(147.48,83.56)
  BOTTOM w0.076: v3(111.33,91.1) 110.71,91.72 109.58,91.72 109.14,91.91 108.65,91.91 UC1.AD3
  BOTTOM w0.114: v3(167.87,101.31) 168.74,101.31 169.04,101.61 169.04,103.89 174.3,109.14 v3(174.3,113.93)
FAN_ID: length 345.3
  TOP w0.114: v3(198.13,54.98) 187.05,54.98 186.94,54.87 UE1.70 ; v3(149.66,41.77) 152.89,41.77 155.07,39.59 167.32,39.59 170.36,42.64 v4(171.43,42.64) 172.37,42.64 v3(172.38,42.65) ; v3(198.89,60.62) 198.82,60.62 198.69,60.75 RPE2.6
  IN1 w0.14: v3(198.13,54.98) 198.89,55.74 v3(198.89,60.62) ; v3(172.38,42.65) 173.97,44.24 173.97,53.74 175.15,54.91 175.15,58.66 173.79,60.01 173.79,61.89 v3(172.65,63.03)
  IN2 w0.14: v3(172.65,63.03) 173.16,63.54 173.67,63.54 174.33,62.88 189.7,62.88 192.82,59.76 194.29,59.76 198.13,55.92 v3(198.13,54.98) ; v3(56.81,113.06) 55.11,113.06 52.93,110.88 52.93,109.23 49.87,106.16 49.87,103.52 40.14,93.79 40.14,85.28 37.85,82.99 37.85,81.85 34.41,78.41 34.41,77.92 32.83,76.34 32.83,74.61 31.02,72.8 31.02,70.91 30.66,70.55 30.66,68.01 32.24,66.44 32.24,64.86 33.06,64.04 33.06,38.84 37.17,34.74 37.17,28.09 49.91,15.34 122.31,15.34 124.02,17.06 124.02,30.22 128.31,34.51 128.31,42.18 129.05,42.92 135.46,42.92 136.1,43.55 137.9,43.55 138.7,42.75 146.63,42.75 147.61,41.77 v3(149.66,41.77)
  BOTTOM w0.114: v3(56.81,113.06) 57.41,113.65 59.37,113.65 61.5,115.79 JFAN.5
FB_1.35V: length 3.8
  BOTTOM w0.254: PR307.1 PR305.2 PC314.2 132.92,41.06 134.07,39.92
FBA0_DBI0#: length 35.8
  TOP w0.14: v3(106.51,129.78) 108.15,128.14 116.35,128.14 118.89,130.68 118.89,132.15 119.54,132.8 119.81,132.8 120.18,132.42 120.45,132.42 120.64,132.61 120.64,132.88 120.27,133.26 120.27,133.52 120.45,133.71 v4(123.7,133.71) 126.49,133.71 v3(127.49,134.71)
  BOTTOM w0.084: v3(127.49,134.71) 128.1,135.32 128.9,135.32 130.14,136.56 UV1.A34
  BOTTOM w0.14: v3(106.51,129.78) 105.92,130.37 105.92,131.38 105.49,131.82 105.49,132.23 105.35,132.37 104.98,132.37 104.75,132.61 104.75,133.92 UV6.D2
FBA0_DBI1#: length 21.9
  IN3 w0.14: v1(113.51,133.96) 113.56,133.91 120.58,133.91 125.55,138.89 v1(126.87,138.89)
  BOTTOM w0.084: UV1.E30 131.51,139.76 131.17,140.1 130.84,140.1 130.81,140.06 130.39,140.06 130.36,140.1 130,140.1 129.64,139.73 128.97,139.73 127.73,138.5 127.26,138.5 v1(126.87,138.89)
  BOTTOM w0.14: UV6.D13 v1(113.51,133.96)
FBA0_DBI2#: length 20.4
  IN3 w0.14: v1(128.19,142.99) 127.78,142.58 117.66,142.58 116.47,143.77 114.45,143.77 113.54,142.86 v1(113.54,142.71)
  BOTTOM w0.084: v1(128.19,142.99) 128.2,143 129.69,143 130,143.31 130.26,143.31 130.28,143.3 130.31,143.3 130.33,143.29 130.38,143.27 130.44,143.25 130.8,143.25 130.88,143.29 130.9,143.31 131.52,143.31 131.8,143.02 UV1.E26
  BOTTOM w0.14: v1(113.54,142.71) 113.19,142.36 UV6.P13
FBA0_DBI3#: length 34.6
  BOTTOM w0.084: UV1.C20 130.66,147.76 130.29,147.39 128.58,147.39 128.3,147.11 127.23,147.11
  BOTTOM w0.14: 127.23,147.11 v4(119.13,147.11) 117.12,147.11 115.62,148.6 105.77,148.6 102.53,145.36 102.53,144.36 103.27,143.62 103.57,143.62 103.96,143.23 103.96,142.92 104.31,142.57 UV6.P2
FBA0_EDC0: length 36.4
  TOP w0.14: v3(128.25,134.66) 128.12,134.66 126.69,133.23 122.12,133.23 v4(120.83,131.94) 120.41,131.53 120.15,131.53 119.88,131.79 119.61,131.79 119.42,131.6 119.42,131.33 119.69,131.07 119.69,130.8 116.55,127.66 107.77,127.66 105.7,129.73 v3(105.7,129.81)
  BOTTOM w0.084: UV1.C34 131,136.56 130.56,136.12 129.94,136.12 128.75,134.93 128.52,134.93 v3(128.25,134.66)
  BOTTOM w0.14: v3(105.7,129.81) 104.43,129.81 103.94,130.29 103.94,132.93 104.31,133.3 UV6.C2
FBA0_EDC1: length 27.4
  IN3 w0.14: v1(115.3,133.29) 115.45,133.14 116.42,133.14 116.61,132.95 116.61,132.21 116.8,132.02 117.07,132.02 117.26,132.21 117.26,132.95 117.45,133.14 117.72,133.14 117.91,132.95 117.91,132.21 118.1,132.02 118.37,132.02 118.56,132.21 118.56,132.95 118.75,133.14 119.02,133.14 119.21,132.95 119.21,132.21 119.39,132.02 119.66,132.02 119.85,132.21 119.85,132.95 120.04,133.14 120.88,133.14 126.07,138.32 127.39,138.32 127.54,138.47 v1(127.54,138.85)
  BOTTOM w0.084: v1(127.54,138.85) 127.85,138.85 128.9,139.9 129.57,139.9 129.93,140.26 130.43,140.26 130.46,140.23 130.74,140.23 130.77,140.26 131.1,140.26 UV1.D29
  BOTTOM w0.14: v1(115.3,133.29) 114.97,132.96 114.41,132.96 114.26,133.11 113.56,133.11 UV6.C13
