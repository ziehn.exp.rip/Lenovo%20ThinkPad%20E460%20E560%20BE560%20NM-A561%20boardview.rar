# Allegro board Lenovo ThinkPad E460 E560 BE560 NM-A561 boardview.brd (continued)
## Nets (continued)
N31397546: PR444.2 PU401.15(ROSC_SAUS)
N31397550: PR446.2 PU401.19(ICCMAX_1A)
N31397552: PR445.2 PU401.18(ICCMAX_2PH)
N31397554: PR447.2 PU401.20(ICCMAX_1B)
N31397556: PR448.2 PU401.21(ADDR_VBOOT)
N31397566: PR408.2 PU401.33(ALERT#)
N31397696: PR433.2 PR434.2 PU401.45(VSP_1B)
N31397710: PR411.2 PU401.32(SDIO)
N31397718: PC423.2 PR433.1
N31398277: PC426.2 PR437.2 PU401.44(VSN_1B)
N31398315: PC420.1 PR429.2
N31398319: PC421.1 PR431.2
N36436059: PC317.2 PR304.1
N36436199: PR303.2 PU301.18(BOOT)
N42212278: JCP.7 RL20.1
N43769362: CE15.2 RE38.1
N48440511: PC702.2 PR702.2 PU701.26(VREF)
N48440559: PR706.2 PU701.20(TRIP)
N48440565: PC703.1 PU701.21(SLEW)
N48440766: PC704.1 PR707.2
N48440774: PC701.1 PR701.2 PU701.28(EN)
N48440814: PC718.1 PR708.1
N50697329: JDIMM1.197(SA0) RC316.2
N50697343: CD2.2 RD4.1
N50697618: JDIMM1.201(SA1) RC315.2
N50697658: CD12.2 RD12.1
N50702365: CD31.2 RD18.1
N50702825: JDIMM2.197(SA0) RC317.2
N54603879: PR702.1 PR703.2 PU701.25(REFIN)
N54887023: JDIMM2.201(SA1) RD19.2
N55632055: PR627.2 PU601.36(COMP_NB) PU601.37(FB_NB) PU601.38(VSEN_NB)
N55632901: PR637.2 PU601.39(ISUMN_NB) PU601.40(ISUMP_NB)
N55634236: PR640.1 PU601.2(IMON_NB)
N55637104: PR638.1 PU601.1(NTC_NB)
N55638710: PR628.1 PU601.32(UGATE_NB) PU601.33(PHASE_NB)
N56243451: PC4.1 PC5.1 PF1.1 PL1.1 PL2.1
N56300303: PR612.2 PU601.6(VDDIO)
N56340374: PR629.1 PU601.34(LGATE_NB)
N56471499: PR705.1 PU701.3(MODE)
N56767462: CV19.1 QV1.2(G) RV11.2 RV13.1
N56767499: RV4.2 UV1.AB35(PCIE_REFCLKP)
N56767500: RV5.2 UV1.AA36(PCIE_REFCLKN)
N56772982: CV77.1 RV27.2 RV28.1
N56786553: RV93.2 RV94.2 UV1.AD28(TESTEN)
N56786719: RV101.1 TPV12.1
N56786731: RV101.2 UV1.AL21(PX_EN)
N56787089: CV209.1 QV4.2(BASE) RV105.2
N56787095: DV4.2 RV102.2 RV103.1 RV104.2 RV105.1
N56799483: CL9.1 CL13.1 TL1.3(TDCT1) TL1.4(TDCT2) TL1.9(TDCT3) TL1.10(TDCT4)
N56839363: CV215.1 CV216.1 CV217.1 LV6.2 UV1.AJ32(TSVDD)
N56839883: RV129.2 RV130.2 UV1.AN13(CLKREQB)
N56881458: RV138.2 UV1.AH20(GPIO_0)
N56882589: RV139.2 UV1.AH18(GPIO_1)
N56882611: RV140.2 UV1.AN16(GPIO_2)
N57615062: T24.1 UL1.34(JTAG_TDO)
N57615075: T23.1 UL1.32(JTAG_TDI)
N57725801: JKB.25 R111.2
N57726117: D6.2 R112.1
N57740748: R3.1 U1.7(THERM#)
N57878197: JCRT.11 T25.1
N57919388: CA29.1 RA14.2
N57919390: CA30.1 RA15.2
N57919402: CA31.1 RA19.2
N57919454: CA32.1 RA24.2
N57919827: CA22.2 CA23.2 DA1.1(ANODE) RA11.1 RA13.1
N57919838: CA24.1 RA11.2
N57996073: CX2.2 UX1.1(CEXT)
N57996075: RX2.2 UX1.27(REXT)
N57996720: TP939.1 UX1.46(PD)
N58098354: JRTC.1 R112.2
N58156905: PQ101.4(G) PR102.1
N59027809: JDCIN1.1 PC2.1 PC3.1 PQ4.1(S1) PR6.1 PR7.1
N59027813: PQ4.6(D1) PR4.1 PR6.2
N59062655: PR641.2 PR643.1 PRT602.2
N59480687: RV145.1 UV1.AC38(VSYNC)
N59480694: RV146.1 UV1.AC36(HSYNC)
N59482294: RV148.1 UV1.AB34(RSET)
N59727618: PD101.1 PQ105.1(D)
N59727917: PQ105.2(G) PR109.2 PR110.2
N59815935: QV19.5(G2) RV166.1 RV183.2
N59815943: QV19.6(D1) RV162.1
N59815947: QV19.2(G1) RV164.2
N59815979: CV228.1 QV6.2(G) RV163.2
N59815990: JV4.1 QV6.1(D)
N60277905: JLCD.4 R21.2
N60939795: PC208.1 PR205.1 PU201.5(LDO)
N60939813: PC209.2 PR204.1
N61210253: DA6.1 RA16.2
N61210291: DA7.1 RA22.2
N61716887: PC212.2 PR207.1
N61905058: JCRT.4 T26.1
N62243754: JRJ452.9(YELLOWLED+) RL16.2
N62244120: JRJ452.11(GREENLED+) RL15.2
N62639755: TC31.1 UC1.BB68(RSVD_TP_BB68)
N62639757: TC32.1 UC1.BB69(RSVD_TP_BB69)
N62639791: TC45.1 UC1.AK13(RSVD_TP_AK13)
N62639793: TC46.1 UC1.AK12(RSVD_TP_AK12)
N62639820: TC37.1 UC1.BB2(RSVD_BB2)
N62639829: TC38.1 UC1.BA3(RSVD_BA3)
N62639863: TC50.1 UC1.AU5(TP5)
N62639865: TC51.1 UC1.AT5(TP6)
N62639899: TC60.1 UC1.B3(RSVD_B3)
N62639901: TC62.1 UC1.A3(RSVD_A3)
N62640032: TC64.1 UC1.AW1(RSVD_AW1)
N62640090: TC55.1 UC1.D4(RSVD_D4)
N62640092: TC56.1 UC1.B2(RSVD_B2)
N62640101: TC58.1 UC1.C2(RSVD_C2)
N62640103: TC53.1 UC1.D5(RSVD_D5)
N62640164: TC65.1 UC1.E1(RSVD_E1)
N62640180: TC66.1 UC1.E2(RSVD_E2)
N62640214: TC68.1 UC1.BA4(RSVD_BA4)
N62640216: TC70.1 UC1.BB4(RSVD_BB4)
N62640259: TC72.1 UC1.A4(RSVD_A4)
N62640261: TC74.1 UC1.C4(RSVD_C4)
N62640281: TC76.1 UC1.BB5(TP4)
N62640313: TC67.1 UC1.AY2(RSVD_AY2)
N62640315: TC69.1 UC1.AY1(RSVD_AY1)
N62640335: TC71.1 UC1.D1(RSVD_D1)
N62640353: TC73.1 UC1.D3(RSVD_D3)
N62640386: TC86.1 UC1.F60(RSVD_F60)
N62640584: TC75.1 UC1.K46(RSVD_K46)
N62640593: TC77.1 UC1.K45(RSVD_K45)
N62640620: TC79.1 UC1.AL25(RSVD_AL25)
N62640629: TC81.1 UC1.AL27(RSVD_AL27)
N62640656: TC82.1 UC1.C71(RSVD_C71)
N62640665: TC83.1 UC1.B70(RSVD_B70)
N62640692: TC88.1 UC1.A52(RSVD_A52)
N62640710: TP92.1 UC1.BA70(RSVD_TP_BA70)
N62640712: TP93.1 UC1.BA68(RSVD_TP_BA68)
N62640746: TC94.1 UC1.J71(RSVD_J71)
N62640748: TC95.1 UC1.J68(RSVD_J68)
N62640782: TC99.1 UC1.F61(RSVD_F61)
N62640818: TC103.1 UC1.AW69(RSVD_AW69)
N62640820: TC102.1 UC1.AW68(RSVD_AW68)
N62640854: TC106.1 UC1.AU56(RSVD_AU56)
N62640856: TC108.1 UC1.AW48(RSVD_AW48)
N62640904: TC110.1 UC1.C7(RSVD_C7)
N62640906: TC112.1 UC1.U12(RSVD_U12)
N62640922: TC114.1 UC1.U11(RSVD_U11)
N62640924: TC116.1 UC1.H11(RSVD_H11)
N62641188: TC104.1 UC1.F6(RSVD_F6)
N62641190: TC105.1 UC1.E3(RSVD_E3)
N62641192: TC107.1 UC1.C11(RSVD_C11)
N62641208: TC109.1 UC1.B11(RSVD_B11)
N62641224: TC111.1 UC1.A11(RSVD_A11)
N62641226: TC113.1 UC1.D12(RSVD_D12)
N62641228: TC115.1 UC1.C12(RSVD_C12)
N62641230: TC117.1 UC1.F52(RSVD_F52)
N62685817: RC121.1 UC1.E32(VCC_SENSE)
N62687376: RC142.1 UC1.E33(VSS_SENSE)
N62693311: RC385.1 UC1.E5(PCIE_RCOMPP)
N62870607: T56.1 UC1.AN11(GPP_B0/CORE_VID0)
N62870645: T57.1 UC1.AN13(GPP_B1/CORE_VID1)
N62959739: RC124.2 UC1.J70(VCCGT_SENSE)
N62959779: RC183.2 UC1.J69(VSSGT_SENSE)
N62960030: RC185.1 UC1.H21(VSSSA_SENSE)
N62960070: RC126.1 UC1.H20(VCCSA_SENSE)
N63158955: T21.1 UC1.AM15(GPD2/LAN_WAKE#)
N63295136: PC203.1 PR202.2
N63299821: PC229.2 PR215.1
N63299840: PR209.2 PR210.2 PR211.2
N63300161: PC226.2 PR214.1
N63300165: PC217.1 PR212.2
N63360063: QV17.2(G) RV150.2
N63360075: QV17.1(D) RV143.1
N63360089: CV229.1 QV9.4(G) RV185.2
N64244043: QV4.1(COLLECTOR) RV110.1
N64344808: RV92.2 RV133.1 RV179.2 RV181.1 UV14.3(2A)
N64344810: RV91.2 RV127.1 RV178.2 RV180.1 UV14.2(1A)
N64344836: CV206.1 CV208.1 RV134.1 UV14.5(DIR)
N64344870: RV96.1 UV14.7(1B)
N64344872: RV97.1 UV14.6(2B)
N67782265: RC378.1 UC1.AB7(SD_RCOMP)
N67912715: RC389.1 UC1.AT1(EMMC_RCOMP)
N68010119: R9484.2 UTPM1.27(SERIRQ)
N68061247: CA16.2 UA1.11(CLASS-D_REF)
N68061309: CA17.2 UA1.19(FLY_P)
N68061311: CA17.1 UA1.20(FLY_N)
N68137601: RC296.1 UC1.AY3(RSVD_AY3)
N68137603: RC295.1 UC1.AY71(VSS_AY71)
N68137613: RC391.2 UC1.C64(PROC_SELECT#)
N68137683: TC78.1 UC1.A69(RSVD_A69)
N68137699: TC80.1 UC1.B69(RSVD_B69)
N68137715: TC84.1 UC1.D71(RSVD_D71)
N68137731: TC85.1 UC1.C70(RSVD_C70)
N68137747: TC87.1 UC1.C54(RSVD_C54)
N68137763: TC89.1 UC1.D54(RSVD_D54)
N68137779: TC91.1 UC1.AY4(TP1)
N68137795: TC93.1 UC1.BB3(TP2)
N68137811: TC96.1 UC1.AR56(ZVM#)
N68137827: TC97.1 UC1.AW71(RSVD_TP_AW71)
N68137843: TC98.1 UC1.AW70(RSVD_TP_AW70)
N68139906: TC100.1 UC1.AP56(MSM#)
N68447222: RC47.2 TC18.1
N68512911: RW11.2 UW1.28(GPIO)
N68512942: RW8.2 UW1.9(RREF)
N68512946: RW20.2 UW1.32(WAKE#)
N68513948: CG1.2 CG2.2 CG4.1 QG1.2(G) RG4.2
N68514036: RG6.1 UGSEN1.8(CS)
N68520625: CW14.1 RW16.2
N68576329: RC48.1 RC348.1 UC3.4(OUT_Y)
N68614825: PD6.2 PR18.1 PR19.2
N68925385: CL17.1 QL2.2(G) RL24.2
N68926087: C75.1 Q26.2(G) R51.2
N69409003: L21.1 UVG2.31(SWOUT)
N69409147: CVG43.2 UVG2.10(RST_N)
N69638631: PQ201.2(G1) PQ201.3(D2) PR216.2
N69643262: TC118.1 UC1.AP13(GPP_A12/BM_BUSY#/ISH_GP6)
N69649315: CV239.1 UV12.6(CT)
N69711319: TC119.1 UC1.D63(CATERR#)
N69867788: RV197.1 UV6.J10(SEN)
N69867866: RV195.1 UV6.J1(MF)
N69867911: RV194.1 UV6.J13(ZQ)
N69916609: RV200.1 UV5.J10(SEN)
N69916637: RV199.1 UV5.J1(MF)
N69916654: RV198.1 UV5.J13(ZQ)
N69928133: RV203.1 UV7.J10(SEN)
N69928161: RV202.1 UV7.J1(MF)
N69928178: RV201.1 UV7.J13(ZQ)
N69934691: RV205.1 UV8.J10(SEN)
N69934709: RV206.1 UV8.J1(MF)
N69934726: RV204.1 UV8.J13(ZQ)
N71613177: QC3.5(G2) QC3.6(D1) RC400.1
N71720577: CV241.1 QV23.2(G1) RV210.1
N71772349: D15.2 R9488.1 U149.2(ON)
N71772380: C747.2 U149.5(CAP)
N71772404: Q6.3(D2) R159.2
N71772436: C8540.1 Q23.4(G) R9487.2
N71772497: Q24.5(G2) Q24.6(D1) R9486.2
N71773388: C71.1 U11.12(CT1)
N71773402: C72.1 U11.10(CT2)
N71773779: JAUF.12 R238.2
N72685536: R9492.2 R9493.2 U148.B1(EN)
N72718653: RC411.2 UC1.AB3(GPP_C11/UART0_CTS#)

Pads without a net: D5 3; D7 3 4; D17 3 4; DT1 4; FD1 1; FD2 1; FD3 1; FD4 1; FD5 1; FD6 1; JCP 3; JCRT 10; JDIMM1 77 122 125 198; JDIMM2 77 122 125 198; JFPB 6; JHDD 20 21 22; JHDMI 13 14; JLCD 23; JTOUCH 7 8 9; JTP 3 4 5 9 10 11 12; JWLBT 6 16 17 19 20 21 22 25 26 27 28 31 32 34 44 46 48 58 59 60 61 62 65 67 68 70 71 73; PU1 4 5 6; PU101 13 14; PU401 17; PU601 35; PU701 2 4 27; PU801 4 7; RPC22 3; RPC200 3 6; RPE1 8; RPE3 3 6; RPE4 2 3 6 7; U1 8; U3 3; U7 3; UA1 35 36 37; UC1 A7 A26 A27 A29 A31 A33 A36 A38 A42 A45 A47 A50 A65 AB4 AB11 AB12 AB13 AB62 AC3 AC63 AD11 AD12 AE62 AE63 AF11 AF12 AF13 AG1 AG2 AG62 AH7 AH8 AH9 AH10 AH12 AJ62 AK6 AK7 AK9 AK10 AK32 AK42 AK43 AK45 AK46 AK48 AK50 AK52 AK53 AK55 AK56 AK58 AK60 AK62 AK70 AL43 AL46 AL50 AL53 AL56 AL60 AL61 AL63 AM1 AM2 AM3 AM4 AM48 AM50 AM52 AM53 AM56 AM58 AN1 AN2 AN3 AN7 AN55 AP1 AP2 AP3 AP4 AP7 AP8 AP43 AP53 AT7 AT52 AU58 AU63 AW7 AW20 AW56 AY5 AY7 AY8 AY9 AY20 AY21 AY56 B7 B26 B27 B29 B31 B33 B36 B38 B42 B45 B47 B50 B52 BA5 BA7 BA8 BA9 BB9 BB57 BB66 C8 C16 C19 C27 C28 C29 C31 C32 C33 C36 C37 C38 C42 C51 D7 D8 D16 D19 D27 D28 D29 D31 D32 D33 D36 D37 D38 D42 D51 E13 E16 E61 F11 F16 F46 G11 G46 G61 H1 H5 H63 J4 J5 K32 L6 M2 M3 M4 N1 N2 N3 N9 N11 N12 P1 P2 P4 P62 U1 U2 U3 U4 U6 V1 V2 V62 W7 W8 W10 W11 W12; UC3 1; UE1 111 120; UGSEN1 2 3; UL1 25; USROM1 1 2; UTPM1 5 7 10 11 12 15 25 26 28 29 31; UV1 A39 AA29 AA31 AA32 AA33 AA34 AC10 AC29 AC31 AC32 AD29 AD30 AD32 AD35 AD37 AD39 AE36 AE38 AF30 AF31 AF32 AF33 AF35 AF37 AG12 AG21 AG28 AG32 AG33 AG36 AG38 AH12 AH24 AH26 AH35 AH37 AJ14 AJ17 AJ19 AJ20 AJ21 AJ24 AJ27 AJ30 AJ31 AJ36 AJ38 AK10 AK14 AK16 AK17 AK19 AK20 AK21 AK27 AK29 AK30 AK35 AK37 AL10 AL16 AL19 AL27 AL29 AL30 AL31 AL36 AM16 AM19 AM20 AM21 AM26 AM27 AM29 AM30 AN7 AN14 AN20 AN21 AN24 AN26 AN36 AP6 AP8 AP10 AP12 AP13 AP14 AP15 AP20 AP21 AP22 AP23 AP24 AP25 AP26 AP34 AP35 AP37 AR1 AR3 AR6 AR8 AR10 AR12 AR14 AR16 AR20 AR22 AR24 AR26 AR30 AR32 AR34 AR35 AR37 AT7 AT9 AT11 AT13 AT15 AT17 AT19 AT21 AT23 AT25 AT27 AT29 AT31 AT33 AU1 AU3 AU5 AU6 AU8 AU10 AU12 AU14 AU16 AU18 AU20 AU22 AU24 AU26 AU28 AU30 AU32 AU35 AU39 AV7 AV9 AV11 AV13 AV15 AV19 AV21 AV23 AV25 AV29 AV31 AW1 AW3 AW5 AW6 AW8 AW10 AW12 AW34 AW35 AW37 AW39 E37 F35 F37 G36 G38 H32 H33 H35 H37 J32 J33 J36 J38 K16 K27 K29 K30 K32 K33 K35 K37 L10 L27 L29 L30 L32 L33 L36 L38 M12 M20 M21 M35 M37 N12 N29 N30 N32 N33 N36 N38 P29 P30 P32 P33 P35 P37 R36 R38 T29 T30 T32 T33 T35 T37 U12 U13 U38 V12 V13 V28 W29 W30 Y31; UV5 A5 U5; UV6 A5 U5; UV7 A5 U5; UV8 A5 U5; UVG2 13 14 29; UW1 13 22 23 24 25 26 31; UX1 11 30 31 33 34; YV1 2 4

## Via types
v1: diameter 0.457, hole 0.203, TOP to BOTTOM, 1252 vias
v2: diameter 0.305, hole 0.152, TOP to BOTTOM, 180 vias
v3: diameter 0.508, hole 0.254, TOP to BOTTOM, 5667 vias
v4: diameter 0.406, hole 0.203, TOP to BOTTOM, 632 vias
v5: diameter 0.508, hole 0.229, TOP to BOTTOM, 274 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.8VSP_LX: length 0.8
  TOP w0.254: v3(181.54,182.67) 181.67,182.79 PR803.2
  vias: v4(182.48,180.48)
3V5V_ON: length 30.3
  TOP w0.254: PC213.2 PR206.2 ; PC213.2 v4(165.97,5.5) 165.97,6.29 v3(166,6.31) ; PC213.2 166.83,4.21 PR208.1 166.86,4.68 167.76,5.58 169.93,5.58 170.63,6.28 v3(172.1,6.28)
  IN1 w0.254: v3(188.45,7.69) 185.63,10.5 176.33,10.5 v3(172.1,6.28)
  BOTTOM w0.254: PQ201.6 v3(172.1,6.28)
+0.95VS_VGA: length 20.7
  TOP w0.114: LV5.1 168.69,162.66 v4(168.69,162.07)
  TOP w0.381: RV6.2 143.41,141.11 RV8.2 142.27,141.11 142.07,140.91 140.49,140.91
  TOP w0.508: v3(167.13,162.22) 167.58,162.22 168.2,162.85 LV5.1
  BOTTOM w0.084: 133.79,139.18 v1(133.81,139.16)
  BOTTOM w0.254: UV1.AN33 UV1.AP32 155.63,138.19 155.63,138.53 UV1.AP31 ; UV1.AN31 154.99,138.36 v1(154.99,138.34) ; v1(155.89,137.66) 155.4,137.17 UV1.AP33
  BOTTOM w0.305: UV1.AL33 153,137.14 v1(153.4,136.74) 153.8,137.15 UV1.AM33 ; UV1.AK33 152.24,137.16 152.58,136.82 152.58,136.77 v1(152.61,136.74) 152.23,136.36 UV1.AK34 ; UV1.AN33 154.6,137.11 v1(154.97,136.74)
  BOTTOM w0.508: 159.92,161.96 161.07,163.11 166.4,163.11 167.13,162.38 v3(167.13,162.22)
  vias: v1(135.3,141.06) v1(137.37,140.53) v1(138.21,141.59) v1(140.14,141.57) v1(155.99,137.07) v3(134.6,140.02) v3(136.2,140.02) v3(138.97,141.62) v3(159.44,141.9) v3(159.44,141.26) v3(159.44,140.63) v3(160.08,141.9) v3(160.08,141.26) v3(160.08,140.63) v3(176.82,131.15) v3(177.48,131.15) v3(178.14,131.18) v3(178.43,127.55) v3(178.75,128.18) v3(178.82,131.18) v3(179.13,127.55)
+0.95VS_VGA_EN#: length 9.1
  TOP w0.381: RV151.2 v4(192.13,132.07) 191.22,132.98 186.77,132.98 186.32,132.53 RV150.1
+0.95VS_VGA_GATE: length 3.5
  TOP w0.114: v4(188.83,126.89) 188.83,127.01 188.22,127.62 187.81,127.62
  TOP w0.254: RV152.2 187.9,127.77 QV18.3
  TOP w0.381: RV185.1 RV152.2 187.81,127.62
+0.675VS: length 198.4
  TOP w0.305: 124.36,26.53 124.63,26.26 127.38,26.26 128.96,27.85 128.96,44.16 132.47,47.66 136,47.66 137.01,46.65 143.12,46.65 144.2,47.73 144.2,51.55 146.77,54.12 150.45,54.12 159.01,62.68 159.01,75.05 161.14,77.18 v3(162.21,77.18) ; R159.1 210.19,138.77 211.94,137.02 v3(212.32,137.02)
  IN2 w0.305: v3(212.32,137.02) 212.86,136.49 212.86,134.27 208.42,129.83 205.82,129.83 205.5,130.15 186.94,130.15 186.57,130.52 186.57,131.12 185.33,132.36 183.53,132.36 181.32,130.15 180.51,130.15 179.86,129.5 175.95,129.5 172.84,126.39 172.84,118.8 168.89,114.85 163.2,114.85 162.05,113.7 162.05,95.84 162.43,95.46 162.43,90.82 163.09,90.16 163.09,78.06 v3(162.21,77.18)
  BOTTOM w0.305: v3(123.22,27.52) 123.22,27.52 JDIMM1.204 ; v3(124.39,42.08) 124.39,41.75 123.75,41.11 123.4,41.11 123.22,41.29 JDIMM2.204
  BOTTOM w0.356: v3(124.77,34.71) 124.39,34.71 122.92,36.18 JDIMM1.203 ; v3(124.44,49.82) 123.28,49.82 122.92,50.18 JDIMM2.203
  vias: v3(131.3,38.24) v3(131.96,38.27) v3(132.62,38.27) v4(124.33,30.77)
+0.675VSP: length 1.9
  BOTTOM w0.203: PU301.2 133.32,37.63 133.05,37.35 133.05,36.69
  vias: v4(133.79,35.45)
+1.8V_LDO: length 5.9
  TOP w0.114: CA6.2 213.56,26.68 CA7.1 212.99,25.49 v2(212.55,25.06) 211.96,24.47 210.97,24.47 210.18,23.67 UA1.3
+1.8VALW: length 231.2
  TOP w1.016: 147.66,95.39 149.32,95.39 150.68,96.75 150.68,97.19 155.1,101.61 155.91,101.61 159.05,104.76 163.58,104.76 164.97,106.15 166.46,106.15 167,106.68 167,107.36 167.61,107.96 172.12,107.96 172.65,108.5 184.4,108.5 186.81,110.91 187.7,110.91 189.99,108.62 191.83,108.62 192.44,109.23 192.44,117.39 194.47,119.42 197.59,119.42 199.13,117.88 200.25,117.88 201.12,118.76 201.12,124.65 199.76,126.02 199.76,127.86 201.4,129.5 201.8,129.5 v3(203.53,131.23) v3(204.36,132.06)
  IN1 w1.016: v3(233.58,178.96) v3(234.78,178.96) 235.23,178.51 235.23,175.52 234.17,174.46 234.17,161.66 233.74,161.23 233.74,157.11 231.76,155.13 231.76,153.48 229.34,151.07 227.41,151.07 v3(226.7,150.36) v3(226.7,148.43) ; v3(203.53,131.23) v3(204.36,132.06) 204.36,135.26 205.42,136.31 205.42,136.84 206.58,138.01 208.18,138.01 209.4,139.23 209.4,144.24 212.5,147.33 214.86,147.33 216.01,148.48 v3(216.01,148.73) 216.69,148.05 v3(216.8,148.05)
  IN2 w1.016: v3(234.78,178.96) v3(233.58,178.96) 231.5,178.96 228.63,181.83 215.91,181.83 215.22,182.51 202.06,182.51 201.34,183.23 198.77,183.23 198.33,182.79 189.74,182.79 184.61,177.66 180.07,177.66 178.19,179.54 177.43,179.54 176.18,178.3 176.18,177.79 175.11,176.72 174.02,176.72
  BOTTOM w1.016: v3(216.01,148.73) 216.11,148.73 v3(216.8,148.05) 217.58,147.26 225.53,147.26 v3(226.7,148.43) v3(226.7,150.36)
  vias: v3(126.7,89.22) v3(127.31,88.99) v3(138.31,90.77) v3(138.31,90.13) v3(146.3,94.27) v3(146.3,93.58) v3(172.62,175.68) v3(173.28,175.68) v3(173.28,175.05)
+1.8VALW_PCH: length 38.8
  TOP w0.381: v3(125.25,91.89) 125.3,91.84 125.3,89.37 125.02,89.09 CC61.1 125.23,88.69 125.23,87.91 RC173.2
  IN1 w0.381: v3(101.25,92.4) 101.25,92.59 101.73,93.07 102.92,93.07 103.19,92.8 111.11,92.8 111.39,93.08 115.73,93.08 v3(116.52,92.29) 119.67,92.29 119.84,92.47 121.67,92.47 122.28,91.86 125.23,91.86 v3(125.25,91.89)
  BOTTOM w0.203: 113.32,93.97 113.09,93.97 112.48,94.58 110.47,94.58 110.06,94.16 UC1.AA1
  BOTTOM w0.254: v3(116.52,92.29) 116.29,92.06 v2(115.88,92.06) 115.83,92.06 113.93,93.97 113.32,93.97 ; UC1.AF16 v3(101.25,92.4)
+1.8VS_VGA: length 85.3
  TOP w0.254: v3(158.04,126.66) 158.76,126.66 RV114.1 ; CV207.1 166.43,155.84 166.43,155.19 166.68,154.94 UV14.8
  TOP w0.381: RV112.1 162.55,129.2 v3(162.93,129.58) ; CV207.1 166.45,156.15 166.81,156.5 v3(166.81,156.63) 166.81,157.32 TPV1.1 ; LV6.1 157.42,127.29 v3(158.04,126.66) ; v3(152.56,153.05) 152.56,152.9 152.1,152.44 RV128.2 ; v3(153.35,141.26) 153.35,141.31 152.89,141.77 RV108.1 ; CV25.1 146.31,138.95 145.85,138.5 v1(145.85,137.83)
  TOP w0.508: LV4.1 163.9,161.2 163.39,161.71 v3(162.49,161.71)
  IN1 w0.381: 147.12,131.41 143.62,131.41 v3(142.65,130.44)
  IN2 w0.305: v3(127.34,129.05) 128.12,128.26 140.75,128.26 142.65,130.16 v3(142.65,130.44)
  IN2 w0.508: 158.68,155.16 158.68,158.79 161.55,161.66 162.44,161.66 v3(162.49,161.71)
  IN3 w0.508: 166.81,159.93 165.03,161.71 v3(162.49,161.71) ; 166.81,159.93 168.51,161.63 168.51,164.99 171.63,168.11 v3(173.11,168.11) ; 166.81,159.93 v3(166.81,156.63)
  BOTTOM w0.203: UV1.AB37 145.6,134.56 145.83,134.33 145.85,134.33 146.23,133.95 v3(146.23,133.8)
  BOTTOM w0.254: v1(153.4,138.37) 153.8,137.97 UV1.AM32 ; v1(145.85,137.83) 145.85,137.71 UV1.AC33 146.61,136.95 146.81,136.95 UV1.AD34
  BOTTOM w0.305: UV1.AM37 153.2,134.76 UV1.AL38 152.8,133.89 v1(153.07,133.62) ; UV1.AF34 UV1.AG34 UV1.AH34 150.6,136.14 v1(150.93,135.8) 151.4,136.27 UV1.AJ34 ; v3(127.34,129.05) 126.75,129.63 LV3.1
  BOTTOM w0.381: UV1.AG11 UV1.AF11 UV1.AF12 148.58,154.16 v1(148.03,153.61) ; UV1.AF15 148.62,152.16 v1(149.12,152.66) ; UV1.AG15 149.6,152.17 v1(149.12,152.66) ; v1(148.03,153.61) 147.6,154.03 UV1.AD12 ; v1(148.03,153.61) 148.1,153.61 148.55,153.16 UV1.AF13 148.61,153.16 v1(149.12,152.66) ; v1(149.12,152.66) 149.6,153.14 UV1.AG13
  BOTTOM w0.508: RV106.1 v3(158.04,126.66)
  vias: v1(148.11,142.53) v1(149.09,142.57) v1(149.92,141.62)
+1.8VSP: length 25.7
  IN2 w0.381: v3(189.29,184.7) 187.38,184.7 186.62,185.46 175.38,185.46 174.72,186.12 173.92,186.12 172.83,185.03 172.83,179.19 v3(173.41,178.6)
  BOTTOM w0.254: PC805.1 PR804.1 v3(189.29,184.7)
  vias: v4(175.42,182.46)
+1.35V: length 204.8
  TOP w0.254: CC234.1 89.21,85.74 v3(89.19,85.75) ; CC229.1 CC227.1 91.62,81.97 v3(91.86,81.73) ; QD1.2 v3(108.9,22.16) ; v3(87.36,88.31) 87.62,88.31 CC256.1 ; v3(95.59,85.75) 95.18,85.34 95.18,84.88 94.9,84.6 CC235.1 95.22,83.22 95.62,83.22 RC293.1 95.81,82.61 v3(97.03,81.39) 96.71,81.07 CC233.1 ; v3(92.85,85.75) 92.85,84.04 CC226.1 ; CC228.1 86.89,81.65 v3(86.89,80.88) ; v3(85.54,85.75) 85.53,85.75 CC94.1
  TOP w0.305: CD15.1 89.02,36.43 v3(88.3,35.7) ; v3(97.38,30.47) 97.46,30.39 CD9.1 ; CD11.1 85.32,35.65 v3(84.69,35.65) ; CRF2.1 CRF1.1 95.71,30.16 v3(95.51,30.37) ; CD43.1 92,43.39 v3(92.28,43.68) ; v3(84.93,43.52) 84.93,43.3 CD46.1 ; v3(99.17,30.33) 99.24,30.26 CD20.1 ; v3(97.12,38.62) 97.08,38.58 CD14.1 ; CD39.1 86.68,43.6 v3(86.66,43.62)
  TOP w0.381: CD42.1 96.09,51.5 v3(96.48,51.88) ; CD13.1 93.65,38.07 93.07,38.65 v3(92.61,38.65) ; CD19.1 99.86,37.85 v3(98.92,38.79) ; CD45.1 83.28,48.67 v3(83.6,48.35) ; CD44.1 86.99,48.9 v3(87.05,48.83) ; CD38.1 92.06,48.76 v3(92.11,48.71) ; v3(80.8,81.76) 80.8,82.09 CC230.1 81.39,82.68 CC231.1 82.78,82.68 CC232.1 83.28,82.18 v3(83.28,81.72) ; CD16.1 92.25,30.14 v3(91.92,30.47) ; CD21.1 86.97,29.57 86.59,29.95 v3(86.59,30.47) ; v3(93.52,48.99) 93.5,49 CD41.1 ; CD8.1 v3(93.77,30.34) ; v3(84.82,27.45) 84.88,27.51 CD10.1 ; CD40.1 90.1,48.81 v3(90.13,48.78) ; v3(94.82,51.83) 94.8,51.81 CD48.1
  TOP w0.508: CRF4.1 CRF3.1 v3(102.24,22.34) ; CD10.1 82.76,28.18 82.02,28.92 ; RD9.1 v3(101.53,23.6) ; 67.57,22.01 67.17,22.01 59.54,29.64 59.54,35.45 58.98,36.01 RD1.1 57.51,36.69 56.24,37.96 56.24,48.78 57.41,49.95 RD15.1
  IN3 w0.254: 85.97,85.45 85.97,84.88 86.29,84.56
  BOTTOM w0.152: UC1.BB41 86.9,81.84
  BOTTOM w0.178: UC1.BB51 80.79,82.6 80.78,82.31 80.78,81.77 v3(80.8,81.76) ; UC1.BB47 83.25,82.14 83.25,81.79 v3(83.28,81.72) ; UC1.BB23 96.84,82.55 96.86,82.51 96.86,81.57 v3(97.03,81.39) ; v3(91.86,81.73) 91.86,82.53 91.85,82.55 UC1.BB32
  BOTTOM w0.254: v3(87.36,88.31) 86.93,88.7 UC1.AM40 ; UC1.AU28 v3(92.85,85.75) ; JDIMM1.124 99.22,28.11 98.61,27.5 ; v3(86.89,80.88) 86.89,81.82 86.9,81.84 ; UC1.AU42 v3(85.54,85.75) ; 85.4,46.93 85.8,46.93 88.42,44.31 JDIMM2.88 ; UC1.AU23 v3(95.59,85.75) ; UC1.AU35 v3(89.19,85.75)
  BOTTOM w0.305: v3(92.28,43.68) 92.02,43.41 JDIMM2.100 92.02,41.14 91.56,40.68 91.56,40.49 ; JDIMM2.111 95.32,51.34 v3(94.82,51.83) ; 86.62,40.37 JDIMM2.82 86.62,43.58 v3(86.66,43.62) ; v3(97.12,38.62) JDIMM1.117 ; v3(87.05,48.83) 87.81,48.83 88.12,49.14 JDIMM2.87 88.12,52.31 88.07,52.36 ; 97.42,40.38 97.87,40.83 98.97,40.83 99.22,41.09 JDIMM2.124 99.22,43.51 v3(99.16,43.57) ; v3(90.22,27.54) JDIMM1.94 ; v3(90.13,48.78) 89.92,48.99 JDIMM2.93 ; JDIMM1.88 88.42,27.3 ; JDIMM2.99 91.72,49.07 92.08,48.71 v3(92.11,48.71) ; JDIMM1.111 95.32,34.85 94.8,34.33 ; v3(91.92,30.47) 92.02,30.37 JDIMM1.100 ; v3(96.48,51.88) 96.79,51.88 97.12,51.55 JDIMM2.117 97.12,49.41 97.85,48.68 ; v3(97.38,43.67) 97.42,43.63 JDIMM2.118 97.42,41.12 96.6,40.3 ; 98.74,53.38 98.92,53.2 JDIMM2.123 ; v3(86.59,30.47) 86.62,30.44 JDIMM1.82 86.62,27.55 86.29,27.22 ; v3(93.52,48.99) JDIMM2.105 ; JDIMM1.99 91.72,35.94 v3(91.88,35.78) ; 95.46,45.71 95.74,45.43 95.74,43.67 v3(95.62,43.55) JDIMM2.112 95.62,40.42 ; JDIMM1.93 89.92,38.07 89.34,38.65 ; 98.91,35.12 98.92,35.12 JDIMM1.123 v3(98.92,38.79) ; v3(88.53,40.24) 88.42,40.35 JDIMM2.88 ; v3(84.93,43.52) 84.82,43.41 JDIMM2.76 84.82,40.31 ; JDIMM1.76 v3(84.82,27.45) ; v3(90.22,43.58) JDIMM2.94 90.22,40.88 90.73,40.36 ; v3(83.6,48.35) 84.52,49.27 JDIMM2.75 ; v3(93.69,43.76) 93.82,43.63 JDIMM2.106 93.82,40.4 ; v3(88.3,35.7) 88.12,35.88 JDIMM1.87
  BOTTOM w0.33: JDIMM2.123 98.92,46.3 v3(98.89,46.27) 98.38,45.76 98.38,44.67 v3(97.38,43.67)
  BOTTOM w0.356: v3(93.77,30.34) 93.82,30.3 JDIMM1.106 93.82,27.87 94.16,27.52 ; v3(92.61,38.65) 93.17,38.65 93.52,38.3 JDIMM1.105 ; JDIMM1.124 99.22,30.28 v3(99.17,30.33) ; v3(84.69,35.65) 84.52,35.82 JDIMM1.75 84.52,38.63 84.54,38.65 ; v3(95.51,30.37) 95.62,30.26 JDIMM1.112 95.62,27.57 95.76,27.42 ; 96.88,27.47 97.42,28.01 JDIMM1.118 97.42,30.43 v3(97.38,30.47) 97.38,30.87 97.75,31.23
  vias: v3(84.72,32.35) v3(84.87,31) v3(88.55,31.36) v3(90.3,31.03) v3(93.61,22.37) v3(94.04,21.71) v3(94.47,22.44) v3(94.9,21.78) v3(95.31,22.42) v3(95.74,21.76) v3(96.07,22.44) v3(96.5,21.78) v3(96.91,22.42) v3(97.34,21.76) v3(97.75,22.44) v3(98.1,21.76) v3(98.53,22.39) v3(98.94,21.71) v3(99.4,22.37) v3(99.75,21.68) v3(103.69,21.66) v3(105.54,22.93) v3(131.4,7.18) v3(131.73,9.13) v3(131.71,7.81) v3(132.04,8.47) v3(132.06,7.18) v3(132.44,9.13) v3(132.42,7.81) v3(132.75,8.47) v3(132.77,7.18) v3(133.13,9.13) v3(133.1,7.81) v3(133.43,8.47) v3(133.46,7.18) v3(133.84,9.13) v3(133.81,7.81) v3(134.14,8.47) v3(134.17,7.18) v3(134.55,9.13) v3(134.52,7.81) v3(134.85,8.47) v3(134.88,7.18) v3(135.24,7.81) v3(135.26,9.13) v3(135.57,8.47) v3(135.59,7.18) v3(136.02,9.13) v3(136,7.81) v3(136.33,8.47) v3(173.41,184.57) v3(173.44,183.91) v3(173.49,183.25) v3(173.97,184.88) v3(174,184.22) v3(174.05,183.58) v3(174.2,185.49) v3(174.5,183.12) v3(174.61,184.85) v3(174.63,184.22) v3(174.89,183.63) v3(175.24,184.8) v3(175.32,184.11) v3(175.49,183.43) v3(175.88,184.75) v3(175.95,184.11) v4(174.95,185.55)
+1.35VP: length 57.5
  IN3 w0.508: v3(130.69,40.96) 130.64,40.91 130.64,35.24 129.6,34.2 129.6,32.46 128.58,31.44 128.58,15.41 132.24,11.75 v3(132.24,11.5)
  IN3 w1.016: 132.54,31.89 131.71,31.06 131.1,31.06 129.95,29.92 129.95,16.6 133.13,13.43 133.13,13.4
  BOTTOM w0.254: 133.53,39.46 132.7,40.3 132.31,40.3 PC314.1 PR305.1
  BOTTOM w0.381: v3(130.69,40.96) 130.79,41.06 PC314.1
  vias: v3(133.03,12.54) v3(133.38,11.98) v3(133.66,32.3) v3(133.69,12.56) v3(134.02,31.74) v3(134.32,32.3) v4(133.97,11.98)
+1.35VS_VGA: length 264.1
  TOP w0.114: v3(163.43,185.97) 163.32,185.85 163.32,185.67 164.78,184.22 v3(165.41,184.22) 166.02,183.61 QV24.3
  TOP w0.254: v3(156.95,185.21) 156.32,185.84 RV206.2
  TOP w0.305: v1(111.13,136.36) 111.25,136.49 CV85.1 ; CV23.1 115.56,140.91 v1(115.06,141.41) ; CV125.1 115.21,163.2 v1(115.06,163.05)
  TOP w0.381: CV140.1 137.37,185.12 v1(137.4,185.09) ; CV96.1 102.96,142.61 v1(102.94,142.58) ; CV169.1 159.37,185.12 v1(159.4,185.09) ; v3(135.87,154.32) 135.87,153.99 136.44,153.42 136.44,152.88 136.3,152.74 CV28.1 ; CV114.1 114.77,155.74 v1(114.55,155.95) ; v1(101.94,161.91) 102.31,161.54 RV199.2 ; v1(144.19,154.69) 144.76,154.12 CV27.1 ; CV152.1 127.29,184.8 v1(127,185.09) ; v1(135.79,182.69) 135.77,182.67 CV150.1 ; CV29.1 141.1,154.69 141.06,154.65 v1(141.03,154.65) ; CV115.1 105.34,164.21 v1(105.53,164.4) ; CV179.1 158.68,182.79 v1(158.63,182.74) ; CV31.1 137.24,146.85 v3(137.09,146.7) ; v1(111.11,162.78) 110.94,162.78 CV117.1 111.11,164.36 v1(111.11,164.38) ; CV124.1 114.64,153.58 v1(114.4,153.81) ; v1(105.46,165.95) 105.41,166 CV112.1 ; v1(104.71,157.97) 105.18,157.97 CV111.1 104.83,158.78 v1(104.71,158.78) ; v1(137.4,175.49) 137.26,175.49 136.73,176.01 CV154.1 ; v1(106.34,136.34) 106.26,136.41 CV100.1 ; v3(148.04,154.65) CV30.1 148.77,154.32 148.77,154.8 149.1,155.13 CV22.1 149.1,155.89 v1(149.36,156.14) ; v1(153,185.09) 152.89,185.2 CV180.1 ; CV132.1 103.4,154.27 v1(103.11,153.98) ; v1(107.42,163.18) 107.32,163.08 CV126.1 ; CV178.1 160.41,180.96 v3(160.41,180.56) ; CV87.1 105.47,144.34 v1(105.46,144.33) ; CV123.1 102.76,164.37 v1(102.94,164.2) ; v1(103.11,157.98) 103.01,157.87 CV121.1 ; CV141.1 134.83,173.83 134.2,173.83 v1(134.2,173.83) ; CV177.1 160.28,182.79 v1(160.18,182.69) ; v1(137.38,177.09) 137.38,177.09 CV137.1 135.8,177.26 v1(135.8,177.09) ; v1(157.79,182.69) 157.77,182.67 CV167.1 ; v1(103.11,165.98) 102.98,165.85 CV113.1 ; v1(111.11,156.38) 111.06,156.32 CV127.1 ; v1(129.4,177.09) 129.34,177.15 CV138.1 ; v1(114.38,165.85) 114.74,166.2 CV122.1 ; CV168.1 160.87,185.22 v1(161,185.09) ; CV170.1 158.88,176.01 v1(159.4,175.49) ; CV116.1 107.2,165.69 v3(107.75,165.14) ; v1(114.38,144.23) 114.67,144.52 CV88.1 ; v3(137.06,150.61) 137.55,150.61 CV26.1 ; CV120.1 110.65,154.32 v1(111.11,154.78) ; v1(126.83,173.8) 126.6,173.57 CV142.1 ; CV139.1 128.76,173.44 v1(128.97,173.65) ; v1(112.71,164.38) 112.19,163.86 CV131.1 ; v1(159.4,177.09) 159.38,177.09 CV165.1 157.8,177.26 v1(157.8,177.09) ; v1(107.37,135.41) 107.9,135.41 CV83.1 ; CV84.1 102.98,144.23 v1(103.11,144.36) ; v1(114.37,139.56) 114.38,139.56 CV97.1
  TOP w0.508: v1(114.31,136.36) 115.57,136.36 115.98,136.76 RV41.2 RV42.1 ; v1(131,173.89) 131,173.21 131.96,172.25 RV67.1 133.13,172.25 RV66.2 ; v3(115.9,158.54) RV54.1 115.93,159.27 RV53.2 ; v1(153,173.89) 153,172.85 153.6,172.25 RV79.1 155.13,172.25 RV78.2
  BOTTOM w0.114: UV7.T12 v1(138.2,175.49)
  BOTTOM w0.254: UV6.L4 105.48,139.53 v1(105.46,139.53) ; UV1.AJ7 150.85,158.36 v1(150.65,158.56) ; v1(104.73,161.96) 104.7,161.96 UV5.L2 ; UV6.L13 v1(112.71,139.56) UV6.K12 ; UV5.D11 111.51,155.93 v1(111.89,155.56) ; UV6.L2 103.92,139.56 v1(103.92,139.51) ; UV5.B3 v1(105.51,154.78) ; RV69.1 146.36,178.09 146.49,178.22 146.49,178.25 v3(146.46,178.25) ; UV8.E10 v1(151.4,177.09) ; UV6.H12 v1(112.71,137.16) UV6.G13 v1(113.51,136.36) UV6.F14 ; UV5.P11 v1(111.91,164.38) ; UV1.G26 133.13,143.23 133.13,143.5 v1(133.12,143.5) ; UV5.F12 UV5.G11 111.51,158.36 v1(111.13,157.97) ; v1(114.55,134.33) 114.54,134.33 114.51,134.36 UV6.D14 ; UV7.M3 135.4,183.09 v1(135.79,182.69) ; v1(104.71,158.78) 104.71,158.78 UV5.H3 UV5.G4 ; v1(105.46,161.15) 105.48,161.15 UV5.L4 ; v1(126.83,173.8) 126.95,173.8 127.4,174.25 UV7.B14 ; UV8.K12 v1(156.2,175.49) UV8.L13 ; UV7.L14 134.6,174.13 134.3,173.83 v1(134.2,173.83) ; UV8.D1 v1(150.6,185.09) ; UV5.P14 114.51,163.98 v3(114.51,163.98) ; UV6.G2 104.67,137.12 v1(104.67,137.19) ; v1(104.71,156.42) 105.11,156.01 UV5.D3 ; UV6.B14 114,132.76 114.59,132.17 v1(114.59,132.04) ; UV6.N5 106.81,141.65 v1(107.31,141.65) ; 157.11,185.36 v3(156.95,185.21) 157.4,184.76 UV8.M1 157.4,184.69 v1(157,184.29) 156.6,183.89 UV8.L2 ; UV7.R10 137.45,177.13 137.45,177.09 v1(137.38,177.09) ; UV6.T1 v1(103.11,144.36) ; UV7.L13 v1(134.2,175.49) UV7.K12 ; UV5.C10 v1(111.11,154.78) ; v1(131.83,183.53) 131.76,183.53 UV7.G2 ; UV6.G4 106.34,136.34 v1(106.34,136.34) ; UV7.P1 v1(137.4,185.09) ; UV8.L11 v1(157,176.29) UV8.M12 ; UV5.F1 v1(103.11,157.98) ; UV7.K3 v1(134.18,183.47) ; UV6.D3 v1(104.71,134.76) 104.14,134.76 103.84,134.46 103.61,134.46 UV6.D1 ; v1(149.78,181.87) 150.16,181.49 UV8.C5 ; UV8.L1 v1(156.2,184.29) ; v1(130.21,182.72) 130.58,183.09 UV7.F3 ; UV8.T14 160.87,174.02 v1(160.87,173.62) ; v1(102.9,162.51) 103.03,162.38 UV5.M1 ; UV8.C10 v1(149.8,177.09) ; UV6.D11 111.51,134.31 v1(111.89,133.94) 112.31,134.36 UV6.D12 ; v1(102.94,142.58) 103.03,142.48 103.39,142.48 UV6.P1 ; v1(114.38,144.23) 114.18,144.23 UV6.T14 ; v1(103.02,131.89) 103.03,131.89 103.03,132.04 103.51,132.53 UV6.B1 ; UV6.G1 103.51,136.73 v1(103.89,136.35) ; 102.98,139.88 103.44,139.88 UV6.L1 ; UV5.L13 v1(112.71,161.18) UV5.K12 ; UV7.L11 v1(135,176.29) UV7.M12 ; v1(152.99,177.08) 153.38,176.69 UV8.G11 ; v1(153.8,183.5) 153.8,183.49 UV8.H3 UV8.G4 ; UV6.P12 v1(112.71,142.76) ; UV7.G11 131.38,176.69 v1(130.99,177.08) ; v1(130.99,184.32) 131.37,184.69 UV7.G1 ; UV1.L7 136.72,158.36 136.42,158.05 v1(136.3,158.05) ; UV8.B12 v1(149,175.49) ; v1(115.06,163.05) 115.06,162.92 114.52,162.38 UV5.M14 ; UV7.N10 v1(135.8,177.09) ; v1(151.44,183.5) 151.03,183.09 UV8.D3 ; v1(105.49,135.57) 105.11,135.94 UV6.F3 ; UV5.M12 v1(111.91,161.98) UV5.L11 ; UV7.P14 v3(137,173.69) ; v1(114.55,155.95) 114.54,155.95 114.51,155.98 UV5.D14 ; v1(105.53,164.4) UV5.P3 ; UV5.F3 105.5,157.19 v1(105.51,157.19) ; UV5.N10 v1(111.11,162.78) ; UV8.G1 153.37,184.69 v1(152.99,184.32) ; v1(102.9,140.89) 103.03,140.76 UV6.M1 ; UV7.T14 138.87,174.02 v1(138.87,173.81) ; v1(152.21,182.69) 152.21,182.71 UV8.F3 ; UV7.C5 127.27,180.56 125.6,180.56 125.29,180.87 124.37,180.87 CV153.1 ; v1(134.2,184.29) UV7.L1 v1(135,185.09) ; UV6.B12 v1(112.71,132.36) ; UV7.P11 v1(137.4,176.29) ; UV5.P1 103.39,164.1 103.03,164.1 v1(102.94,164.2) ; UV7.P3 137,183.04 136.63,182.67 v1(136.61,182.67) ; v1(135,185.09) 135.31,185.4 CV151.1 ; v1(135,185.09) UV7.M1 ; v1(115.06,141.41) 115.06,141.18 114.64,140.76 UV6.M14 ; UV7.B1 v1(127,185.09) ; UV7.H12 v1(131.8,175.49) UV7.G13 v1(131,174.69) UV7.F14 ; UV7.G4 130.98,181.87 v1(130.98,181.87) ; UV8.K3 v1(155.39,183.5) ; UV8.N5 158.29,181.4 v1(158.29,180.89) ; UV5.D1 v1(103.11,155.58) ; UV6.M3 v1(104.7,140.35) ; UV7.N5 136.29,181.4 v1(136.29,180.89) ; UV6.F12 v1(112.71,135.56) ; UV5.E5 106.83,156.78 107.24,156.37 v1(107.27,156.37) ; UV6.T3 105.46,144.31 v1(105.46,144.33) ; UV5.T12 v1(112.71,165.18) ; UV8.F14 v1(153,174.69) UV8.G13 v1(153.8,175.49) UV8.H12 ; UV6.C5 107.09,133.56 107.51,133.14 v3(107.91,133.14) ; UV7.D3 v1(129.4,183.49) ; UV6.M12 v1(111.91,140.36) UV6.L11 ; UV6.R10 v1(111.11,142.76) ; UV5.G1 103.51,158.35 v1(103.87,157.98) ; v1(156.2,173.83) 156.3,173.83 156.6,174.13 UV8.L14 ; v3(109.95,151.44) 109.95,151.47 109.98,151.47 110.11,151.34 RV44.1 ; UV7.M14 135.4,173.81 135.62,173.6 135.62,173.54 135.88,173.27 135.95,173.27 v1(136.07,173.14) ; v1(106.34,154.76) 106.71,155.14 UV5.C5 ; v1(101.94,161.91) 102.34,161.51 103.44,161.51 UV5.L1 ; UV1.P7 138.97,158.36 v1(138.64,158.69) ; UV8.P11 v1(159.4,176.29) ; v1(160.18,182.69) 160.58,183.09 UV8.T3 ; UV6.G11 111.51,136.74 111.13,136.35 v1(111.13,136.36) ; UV6.H3 v1(105.53,137.98) ; UV8.T1 v1(161,185.09) ; UV5.F14 v1(113.51,157.98) UV5.G13 v1(112.71,158.78) UV5.H12 ; UV8.E5 151.54,181.23 v1(151.54,180.93) ; UV7.E10 v1(129.4,177.09) ; UV8.B14 149.4,174.25 148.95,173.8 v1(148.83,173.8) ; UV7.H3 v1(132.62,183.51) ; UV5.M3 105.49,162 v1(105.49,161.94) ; UV7.D14 129,173.69 128.97,173.66 v1(128.97,173.65) ; UV8.G14 v1(153,173.89) ; v1(105.46,165.95) 105.46,165.93 UV5.T3 ; UV8.D14 151,173.69 150.97,173.66 v1(150.97,173.65) 150.97,173.06 150.42,172.51 CV166.1 ; UV8.D12 150.62,176.27 150.62,176.31 v1(150.63,176.32) UV8.D11 ; UV6.N10 111.1,141.18 v1(111.09,141.18) ; UV5.E10 v1(111.11,156.38) ; UV5.B14 113.96,154.38 114.4,153.93 v1(114.4,153.81) ; UV5.G2 104.72,157.97 v1(104.71,157.97) ; UV5.K3 v1(104.71,160.37) ; UV6.L14 114.07,139.96 114.37,139.66 v1(114.37,139.56) ; UV7.L4 134.17,182.72 v1(134.17,182.74) ; UV7.L2 v1(135,184.29) ; v1(114.38,165.85) 114.18,165.85 UV5.T14 ; UV7.D11 128.95,176.69 v1(128.58,176.32) 129,175.9 UV7.D12 ; UV8.F12 v1(152.2,175.49) ; UV8.G2 153.03,183.52 v1(153.03,183.49) ; UV8.M14 157.4,173.81 157.62,173.6 157.62,173.54 157.88,173.27 157.95,173.27 v1(158.07,173.14) ; UV6.P14 v3(114.51,142.36) ; v1(138.97,182.7) 138.97,182.74 138.95,182.74 UV7.T3 ; UV6.C10 v1(111.11,133.16) ; v1(158.63,182.74) 158.65,182.74 UV8.P3 ; UV7.P12 v1(137.4,175.49) ; UV8.L4 156.17,182.72 v1(156.17,182.74) ; UV7.F12 v1(130.2,175.49) ; UV8.N10 v1(157.8,177.09) ; UV8.R10 v1(159.4,177.09) ; UV7.G14 v1(131,173.89) ; UV5.R10 v1(111.11,164.38) ; UV5.G14 v1(114.31,157.98) ; UV7.D1 v1(128.6,185.09) ; UV7.B12 v1(127,175.49) ; UV8.B1 v1(149,185.09) ; UV7.B3 v1(127.8,182.69) ; UV5.P12 v1(112.71,164.38) ; UV5.B12 v1(112.71,153.98) ; UV8.M3 157.4,183.08 v1(157.79,182.69) ; UV8.P1 v1(159.4,185.09) ; UV7.F1 v1(131,185.09) ; UV6.B3 v1(105.51,133.16) ; UV6.K3 v1(104.72,139.55) ; UV8.F1 v1(153,185.09) ; UV8.P12 v1(159.4,175.49) ; UV6.G14 v1(114.31,136.36) ; UV7.T1 v1(139,185.09) ; UV5.B1 v1(103.11,153.98) ; UV8.B3 v1(149.8,182.69) ; UV6.F1 v1(103.11,136.36) ; UV5.T1 v1(103.11,165.98) ; UV6.P11 v1(111.91,142.76) ; UV5.D12 v1(112.71,155.58) ; v1(105.53,142.78) UV6.P3 ; UV8.T12 v1(160.2,175.49) ; UV8.P14 v3(159,173.69) ; UV6.E10 v1(111.11,134.76) ; UV7.C10 v1(127.8,177.09)
  BOTTOM w0.3: UV7.R5 137.8,181.36 137.88,181.28 137.88,181.25 137.89,181.23 137.89,180.72 v3(137.93,180.68) ; v3(160.41,180.56) 160.25,180.71 160.19,180.71 159.89,181.01 159.89,181.23 159.88,181.25 159.88,181.28 159.8,181.36 UV8.R5 ; v3(107.27,143.55) 106.96,143.24 106.92,143.24 106.85,143.16 UV6.R5 ; v3(107.75,165.14) 107.24,165.14 106.96,164.86 106.92,164.86 106.85,164.78 UV5.R5
  BOTTOM w0.305: UV1.G14 133.4,152.92 v1(133.69,153.2) ; UV1.G11 133.71,154.65 v1(133.71,154.42) ; v1(149.36,156.14) 149.54,155.96 UV1.AG10 ; UV1.G23 133.64,145.12 133.64,144.71 v1(133.68,144.66) ; v1(114.37,161.18) 113.97,161.58 UV5.L14 ; UV1.AL9 153,156.8 152.65,157.15 v1(152.6,157.15) 152.2,157.55 UV1.AK8 ; v1(132.8,147.26) 132.9,147.26 UV1.G20 ; UV1.U11 141.57,155.16 141.03,154.62 v1(141.03,154.65) ; UV1.Y7 143.57,158.36 143.47,158.26 v1(143.41,158.26) ; UV1.L26 136.47,143.16 136.05,143.58 v1(136.05,143.63) ; UV1.AF7 149.16,158.72 v1(149.37,158.72) ; v1(145.8,157.82) 146.06,158.09 146.13,158.09 UV1.AC7 ; UV1.N11 UV1.M11 137.6,155.63 v1(137.42,155.81) ; UV1.J7 UV1.K8 v1(135.38,157.14) UV1.J9 ; UV1.H10 v1(134.62,156.38) ; UV6.T12 v1(112.71,143.56)
  BOTTOM w0.33: UV1.N11 UV1.R11
  BOTTOM w0.381: v3(155.61,169.38) 156.06,169.84 RV68.1 ; v3(109.65,130.61) 110.03,130.23 RV31.1 ; v1(103.11,157.98) 103.11,157.97 CV118.1 ; v3(117.88,165.34) 118.3,164.92 RV43.1 ; v3(125.25,178.55) 124.87,178.17 RV56.1 ; v3(133.84,140.04) 133.4,140.48 UV1.G29 ; CV153.1 v3(124.29,179.97) ; UV1.Y11 143.72,155.16 v1(144.19,154.69) ; v1(114.55,155.95) 114.55,155.85 116.1,154.3 CV130.1 ; CV119.1 101.59,162.27 v1(101.94,161.91) ; v3(137.06,150.61) 137.06,150.7 UV1.L16 ; 102.98,139.88 v1(102.67,139.88) 101.89,139.88 101.53,140.25 CV86.1 ; v1(130.05,180.84) 129.8,181.09 UV7.E5 ; v1(103.11,153.98) 102.69,153.98 102.08,153.37 CV128.1 ; RV18.1 129.42,129.53 129.57,129.38 v3(129.57,129.05) ; UV1.AD11 147.6,155.03 147.98,154.65 v3(148.04,154.65) ; v3(137.09,146.7) 136.63,147.16 UV1.L21 ; RV55.1 134.09,169.84 134.37,169.56 v3(134.37,169.43) ; RV23.1 135.72,129.26 v3(135.9,129.09) ; v1(136.06,145.91) 136.07,145.91 136.6,145.39 UV1.L23 ; v1(107.37,135.41) 107.11,135.16 UV6.E5 ; v1(103.11,136.36) 101.1,136.36 CV98.1 ; 157.11,185.36 157.29,185.54 CV181.1 ; UV1.U7 141.93,158.03 v1(142.33,158.03) ; RV22.1 132.06,129.55 v3(132.52,129.1) 133,129.58 RV19.1 ; v1(114.55,134.33) 115.06,134.33 115.63,133.77 CV99.1 ; v1(133.15,149.6) UV1.G17 ; UV5.N5 v1(107.42,163.18) ; v1(103.11,155.58) 102.94,155.4 CV129.1
  BOTTOM w0.508: v3(118.78,139.38) 118.71,139.45 RV30.1
  vias: v3(163.43,186.73) v3(164.06,186.37) v3(164.06,185.71) v3(164.67,186.81) v3(164.7,186.12) v3(164.7,185.49) v3(165.08,184.9) v3(165.33,186.86) v3(165.33,186.17) v3(165.33,185.51) v3(165.79,184.85) v3(165.97,186.86) v3(165.97,186.17) v3(165.97,185.46)
+1.35VS_VGA_EN#:
  vias: v2(162.74,181.08)
+1.65V_LDO: length 5.1
  TOP w0.203: UA1.29 210.58,17.66 210.8,17.44
  TOP w0.254: 211.94,16.6 211.64,16.6 210.8,17.44
  TOP w0.508: 211.94,16.6 v2(211.99,16.55) CA8.1 CA9.1
+1VALW: length 91.3
  TOP w0.254: RC379.2 94.49,107.68 97.43,110.61 97.43,112.83 99.12,114.52 99.12,118.84 99.62,119.34 99.62,121.43 103.18,124.98 104.25,124.98 104.86,124.37 117.74,124.37 120.73,127.36 123.69,127.36 126.4,124.65 126.4,122.81 127.53,121.68 140.18,121.68 140.38,121.88 145.26,121.88 147.28,119.87 v3(147.28,119.5)
  TOP w0.305: v3(127.98,66.52) 127.31,67.2 C749.2 127.67,67.63 127.67,67.47 127.99,67.15 128.54,67.15 128.94,66.75 U149.3
  BOTTOM w0.508: 131.35,71.9 131.27,71.9 130.68,71.3 130.68,69.51 127.98,66.82 v3(127.98,66.52) ; v3(124.69,89.7) 126.12,88.28 129.01,88.28 129.6,88.86 129.6,89.27 131.4,91.07 v3(131.48,91.07)
  vias: v3(131.73,73.22) v3(131.73,72) v3(132.11,72.61) v3(132.42,73.22) v3(132.42,72) v3(132.8,72.61) v3(133.1,73.22) v3(133.1,72) v3(133.48,72.61) v3(133.79,73.22) v3(133.79,72) v3(134.17,72.61) v3(134.47,73.22) v3(134.47,72) v3(134.85,72.61) v3(135.16,73.22) v3(135.16,72) v3(135.54,72.61) v3(135.79,73.22) v3(135.79,72) v3(136.18,72.61) v3(136.48,73.22) v3(136.48,72) v3(136.86,72.61) v3(138.87,86.97) v3(139.31,86.34) v3(139.57,86.97) v3(140.01,86.34) v3(140.26,86.97) v3(186.01,130.55) v3(186.01,129.88) v3(187.1,131.56) v3(187.61,129.58) v3(187.69,131.87) v3(187.66,131.18)
+1VALW_CLK2: length 31.8
  TOP w0.508: LC3.1 109.72,115.39 v4(109.72,114.15) 109.72,113.95 111.55,112.12 112.61,112.12 113.54,111.19 113.54,110.32 113.26,110.05 113.26,107.53 112.1,106.36 111.26,106.36 110.78,105.88 v1(110.78,104.18)
  IN3 w0.203: 100.17,102.29 99.73,101.84 99.73,99.55 v3(99.28,99.11)
  IN3 w0.508: v1(110.78,104.18) 110.78,103.85 110.57,103.65 109.63,103.65 108.95,104.33 108.21,104.33 107.96,104.08 103.66,104.08 102.32,102.73 100.62,102.73 100.17,102.29
  BOTTOM w0.254: UC1.K19 v3(99.28,99.11)
+1VALW_CLK4: length 24.3
  TOP w0.203: 98.94,103.77 98.81,103.65 98.81,100.32 v2(98.43,99.94) 98.43,98.8 97.98,98.34
  TOP w0.254: 97.98,98.34 v3(97.98,97.43) ; 98.94,103.77 101.94,106.77 101.94,108.27 100.87,109.34 100.87,112.28 101.99,113.4 102.52,113.4 104.65,115.53 105.98,115.53 LC4.1
  BOTTOM w0.254: UC1.N20 v3(97.98,97.43)
+1VALW_CLK5: length 24.5
  TOP w0.203: LC5.1 106.79,114.62 104.25,114.62 102.6,112.97 102.06,112.97 101.33,112.23 101.33,109.44 102.34,108.42 102.34,106.21 100.62,104.48 v4(100.62,103.44) 99.7,102.53 99.7,100.37 98.81,99.48 98.81,98.69 98.63,98.51 v3(98.63,98.27)
  BOTTOM w0.254: UC1.L19 v3(98.63,98.27)
+1VALW_PCH: length 188.2
  TOP w0.203: RC354.2 76.35,117.67 75.56,116.88 75.56,116.56 74.99,115.99 RC353.2
  TOP w0.254: v3(99.93,99.11) 100.01,99.18 CC49.1 ; v3(97.97,89.88) 98,89.91 98,90.03 98.35,90.39 100.26,90.39 v3(100.6,90.73) ; v3(99.28,93.24) 99.28,93.4 CC95.1 ; v3(77.98,125.89) 78.29,125.59 78.29,124.5 77.21,123.42 77.21,119.99 76.35,119.13 RC354.2
  TOP w0.508: 109.02,117.45 109.02,113.68 110.17,112.54 110.17,109.84 110.55,109.46 110.55,107.3 108.24,104.99 105.06,104.99 v3(104.43,105.62) ; v3(143.87,94.07) 143.87,98.72 151.09,105.93 151.09,111.85 147.5,115.43 145.09,115.43 141.36,119.16 v3(141.36,119.97) ; v3(105.39,121.96) 105.39,120.97 106.1,120.26 v1(106.1,119.29)
  IN1 w0.508: v3(141.36,119.97) 141.26,120.08 134.37,120.08 133.43,121.03 122.5,121.03 121.84,120.36 118.15,120.36 115.63,117.83 114.04,117.83 113.4,117.2 113.4,115.36 112.92,114.87 110.53,114.87 v1(106.1,119.29)
  IN2 w0.508: v3(105.39,121.96) 104.88,122.47 96.2,122.47 v3(95.71,122.95) ; v3(143.87,94.07) 143.87,93.22 143.34,92.69 138.33,92.69 137.09,91.45 v3(137.09,90.82)
  IN3 w0.305: v3(99.93,94.92) 99.93,94.15 99.93,94.15 99.93,93.54 99.62,93.24 v3(99.28,93.24) v3(98.63,93.24)
  BOTTOM w0.102: UC1.A14 101.88,105.73
  BOTTOM w0.203: v3(104.43,105.62) 104.36,105.59 UC1.A10 ; UC1.T1 109.91,96.81 109.91,96.81 110.33,97.23 112.77,97.23 113.11,97.58 ; v3(99.93,94.92) 99.93,94.82 UC1.Y18 99.62,94.48 99.62,94.3 UC1.AB17 ; 101.88,105.73 101.88,106.51 105.09,109.72 105.09,110.96 105.49,111.37 ; UC1.AK20 98,89.78 98,89.85 v3(97.97,89.88)
  BOTTOM w0.254: UC1.P18 99.53,97.01 99.28,97.27 v3(99.28,97.44) ; 110.32,99.18 110.28,99.21 109.61,99.21 UC1.L1 ; UC1.L21 v3(97.98,99.11) ; UC1.AB20 v3(98.63,93.24) ; v3(77.98,125.89) 77.98,126.3 78.52,126.84 84.27,126.84 85.35,125.76 90.28,125.76 v4(90.49,125.56) 92.51,123.53 95.13,123.53 v3(95.71,122.95) ; UC1.AB19 v3(99.28,93.24) ; UC1.K17 v3(99.93,99.11)
  BOTTOM w0.305: 105.49,111.37 105.49,118.68 v1(106.1,119.29)
  BOTTOM w0.381: 110.32,99.18 110.32,98.97 110.67,98.62 112.38,98.62 113.11,97.88 113.11,97.5 113.98,96.64 113.98,96.56
  BOTTOM w0.508: v3(114.18,95.8) 113.98,96 113.98,96.56
  vias: v3(121.72,95.1) v3(121.72,94.46) v3(122.36,95.1) v3(122.36,94.46) v3(122.99,94.46)
+1VALW_PLL: length 25.4
  TOP w0.127: CC273.1 102.85,94.97 102.55,94.97 101.9,95.62 v3(101.9,95.75)
  IN2 w0.254: v1(121.02,97.7) 121.02,97.64 120.5,97.12 119.64,97.12 118.87,97.89 117.07,97.89 116.53,98.44 116.06,98.44 115.88,98.26 115.88,97.83 115.09,97.04 109.71,97.04 108.72,96.05 102.39,96.05 102.1,95.75 v3(101.9,95.75)
  BOTTOM w0.254: UC1.V15 v3(101.9,95.75)
  BOTTOM w0.508: LC2.2 121.02,96.46 v1(121.02,97.7)
+1VS_VGA:
  vias: v3(181.18,129.28) v3(181.77,129.55) v3(181.77,128.92) v3(182.4,129.55) v3(182.4,128.92) v3(182.91,127.65) v3(183.55,127.65) v3(184.18,127.65) v4(183.72,126.96)
+3V3_AUX: length 1.3
  TOP w0.203: 53.14,30.01 53.14,30.27 52.81,30.6 UW1.27
  vias: v4(54.26,26.56)
+3V_AVDD_HP: length 8.5
  TOP w0.203: v4(208.54,16.96) 208.58,16.99 UA1.24
  TOP w0.254: CA13.1 208.49,15.15 208.08,15.56 208.08,16.5 v4(208.54,16.96)
  TOP w0.508: CA13.1 207.41,14.92 207.24,14.76 RA2.1 RA3.2 204.3,14.76 RA30.1
+3V_DDR: length 93.3
  TOP w0.508: RD23.1 v3(112.45,21.38) ; U7.1 189.79,15.6 C751.1 189.86,14.96 187.64,12.74 v4(183.76,12.74) v3(175.82,12.74)
  IN1 w0.508: v3(112.45,21.38) 112.96,20.87 112.96,17.67 124.29,6.34 135.67,6.34 139.53,10.2 143.59,10.2 147.53,14.14 168.33,14.14 169.73,12.74 v3(175.82,12.74)
+3V_LDO: length 4.7
  TOP w0.203: 209.78,17.22 UA1.27
  TOP w0.254: CA10.1 210.5,15.28 v4(210.5,16.09) 210.5,16.45 210.17,16.78 210.17,16.83 209.78,17.22
  TOP w0.508: CA11.1 211.68,15.1 CA10.1
+3V_PWRGD: length 27.8
  IN1 w0.254: v3(166.58,5.35) 167.06,5.83 170.36,5.83 175.44,10.91 187.84,10.91 v3(188.55,11.62)
  BOTTOM w0.114: v3(166.58,5.35) 166.25,5.02 v4(165.69,5.02)
  BOTTOM w0.254: v3(166.58,5.35) 167.08,5.85 PU201.2 ; PR210.1 v3(188.55,11.62)
+3V_SPI: length 291.8
  TOP w0.508: RC310.2 112.53,120.33 ; v3(133.05,119.65) 132.2,120.5 125.85,120.5 124.71,121.64 124.71,123.92 v3(123.95,124.69) 123.95,125 122.85,126.09 121.08,126.09 118.22,123.23 112.83,123.23 112.17,122.57 ; v3(119.84,111.93) 120.37,111.93 121.82,110.47 121.82,108.58 123.53,106.88 123.53,106.59 123.93,106.19 123.93,101.42 127.19,98.16 129.6,98.16 131.51,96.26 139.41,96.26 140.57,95.09 140.57,93.03 142.02,91.59 v3(142.02,90.79) ; v3(223.15,14.34) 227.26,14.34 227.74,14.82 CC26.1 227.74,16.12 227.23,16.63 UC4M1.8
  IN1 w0.381: v3(101.25,89.89) 102,90.64 102.28,90.64 103.37,91.73 107.63,91.73 107.9,92 109.01,92 109.28,91.73 112.96,91.73 113.28,91.42 113.28,90.84 114.42,89.7 115.04,89.7 116.8,91.45 120.12,91.45 120.28,91.61
  IN1 w0.508: v3(167.04,53.86) 167.04,55.67 158.68,64.02 158.68,66.61 154.01,71.29 154.01,75.02 148.37,80.66 148.37,85.87 145.71,88.53 144.28,88.53 v3(142.02,90.79) 141,91.81 129.37,91.81 128.83,91.28 127.84,91.28 125.94,89.37 125.94,88.37 125.28,87.71 124.16,87.71 122.38,89.49 122.38,90.49 121.27,91.61 120.28,91.61
  IN2 w0.508: v3(207.07,42.94) 206.71,42.58 203.54,42.58 201.22,44.9 196.14,44.9 195.25,45.79 192.51,45.79 191.55,46.75 191.55,48.1 187.23,52.41 182.28,52.41 181.59,53.1 167.8,53.1 v3(167.04,53.86)
  IN3 w0.508: v3(212.65,43.85) 213.72,42.79 213.72,31.41 222.97,22.16 222.97,14.52 v3(223.15,14.34)
  BOTTOM w0.305: UC1.AJ16 100.91,90.23 v3(101.25,89.89)
  BOTTOM w0.356: v3(119.77,119.19) 119.43,119.53 UTPM1.14 ; 113.57,123.33 114.59,123.33 114.92,123 UTPM1.1 ; C8497.1 115.02,116.12 115.92,117.02 UTPM1.22
  BOTTOM w0.508: v3(123.95,124.69) 123.95,125.22 124.29,125.57 124.29,126.46 123.86,126.89 C8498.1 123.04,127.45 Q27.3 ; RC117.1 119.97,111.8 v3(119.84,111.93) ; 113.57,123.33 112.77,123.33 C8499.1 111.63,122.19 v3(110.95,122.19) ; RC118.1 120.38,116.61 118.88,115.12 R9477.2 118.57,114.82 119.12,114.28 v1(119.31,114.28) ; C8497.1 C8496.1 v3(114.13,116.87) ; v3(133.05,119.65) 133.05,122.29 134.25,123.48 134.25,123.79 135.21,124.75 137.9,124.75 CC25.1 138.13,125.54 137.87,125.8 UC8M2.8 ; v3(212.65,43.85) 207.98,43.85 v3(207.07,42.94)
  vias: v4(114.1,120.69)
+3V_VIN: length 0.7
  TOP w0.381: v3(170.44,8.85) 170.44,9.49 PR201.1
  vias: v4(170.9,8.09)
+3V_WLAN:
  vias: v3(218.62,37.17) v3(218.62,36.41) v3(218.62,35.7) v3(246.67,162.5) v3(247.96,162.57) v3(248.72,183.71) v3(249.1,164.61) v3(249.1,163.95) v3(249.41,183.71) v4(218.09,38.11)
+3VALW: length 371.6
  TOP w0.254: R9488.2 129.62,68.9 C8541.1 ; C8541.1 130.54,67.3 129.94,66.71 U149.1 ; C8541.1 130.18,67.98 129.9,67.71 v3(129.9,67.4)
  TOP w0.381: RE53.2 207.84,53.19 v3(206,51.35) 205.7,51.04 RE15.1
  TOP w0.508: QL2.3 53.82,125.99 55.54,125.99 56.29,125.24 58.86,125.24 60.76,123.33 60.76,122.71 RL19.1 61.3,122.59 61.65,122.95 v3(61.65,124.14) 62.74,125.24 v3(65.89,125.24) ; RE52.2 184.35,15.6 U7.5 185.35,15.45 C750.1 186.26,14.47 186.67,14.88 v3(186.67,16.02) ; UC3.5 49.31,108.7 49.31,109.21 49.82,109.72 52,109.72 v3(52.15,109.56) ; v3(190.68,109.87) 188.37,112.18 186.37,112.18 184.03,109.84 176.86,109.84 176.18,110.52 172.61,110.52 171.48,109.39 169.22,109.39 168.65,109.96 164.33,109.96 162.3,107.93 158.11,107.93 147.91,118.12 147.91,120.31 145.83,122.39 140,122.39 139.88,122.28 127.69,122.28 126.9,123.06 126.9,125.08 124.12,127.87 120.47,127.87 117.5,124.89 106.37,124.89 v3(106.23,125.03) v4(104.83,126.43) 100.36,130.9 100.01,130.9 v3(99.55,131.36) 99.24,131.67 R25.1 ; PR16.1 v3(202.49,185.08) ; v3(109.02,122.16) 109.66,121.53 RC310.1 ; v3(203.56,37.3) 203,37.86 RE40.1 ; v1(82.54,130.6) 82.04,130.09 RC400.2 ; v3(112.88,62.44) 112.99,62.55 RC351.1
  IN1 w0.254: v3(202.49,185.08) 202.05,185.52 194.56,185.52 192.72,183.68 191.26,183.68 185.48,177.9 179.57,177.9 179,178.47 177.83,178.47 v1(177.76,178.55)
  IN1 w0.381: v3(109.02,122.16) 109.02,122.24 v3(106.23,125.03)
  IN1 w0.508: v3(202.49,185.08) 212.02,185.08 215.58,181.52 215.58,171.79 v3(216.11,171.26) ; v3(99.55,131.36) 99.27,131.64 99.27,134.13 v3(98.35,135.04)
  IN2 w0.508: v3(52.15,109.56) 52.15,111.62 57.23,116.7 57.23,118.38 59.62,120.77 59.62,122.11 v3(61.65,124.14) ; v3(65.89,125.24) 66.78,126.13 71.54,126.13 72.84,127.42 74.86,127.42 77.21,129.77 81.72,129.77 v1(82.54,130.6) 84.87,130.6 87.41,133.14 89.85,133.14 91.01,134.3 93.25,134.3 93.99,133.57 95.48,133.57 96.96,135.04 v3(98.35,135.04)
  IN3 w0.508: v3(221.14,123.46) 228.02,130.34 v3(228.28,130.34) ; v3(165.06,58.97) 165.06,60.14 164.01,61.18 145.8,61.18 144.86,62.12 141.81,62.12 136.4,67.53 130.03,67.53 v3(129.9,67.4) 127.77,67.4 v3(126.98,66.61)
  BOTTOM w0.203: PR11.1 v3(211.44,133.82)
  BOTTOM w0.254: PR4.2 238.77,162.64 239.11,162.98 v3(239.11,163.03)
  BOTTOM w0.508: v3(186.67,16.02) 186.67,13.1 187.69,12.08 PR209.1 ; PR130.1 177.53,178.78 v1(177.76,178.55) ; R233.1 v3(228.28,130.34) ; v3(127.62,72.02) 127.91,72.02 128.45,71.48 128.45,69.06 126.98,67.59 v3(126.98,66.61) 124.28,63.92 122.89,63.92 122.03,63.06 121.27,63.06 121.14,62.93 119.34,62.93 v3(119.25,62.84) 118.98,62.57 113.01,62.57 v3(112.88,62.44) ; v3(190.68,109.87) 190.68,109.39 191.98,108.09 195.38,108.09 199.32,104.15 v3(199.32,99.35)
  vias: v1(247.14,158.92) v1(247.14,158.28) v3(145.88,9.21) v3(145.88,8.57) v3(145.88,7.91) v3(145.88,7.28) v3(145.88,6.62) v3(145.88,5.93) v3(146.51,9.49) v3(146.51,8.85) v3(146.51,8.19) v3(146.51,7.56) v3(146.51,6.9) v3(146.51,6.21) v3(147.15,9.18) v3(147.15,8.55) v3(147.15,7.89) v3(147.15,7.25) v3(147.15,6.59) v3(147.15,5.91) v3(168.94,28.74) v3(169.25,27.95) v3(169.27,26.66) v3(169.42,29.2) v3(169.58,27.4) v3(169.65,28.54) v3(170.01,27.95) v3(170.14,29) v3(180.52,20.74) v3(180.65,21.38) v3(181.16,21.76) v3(181.16,20.99) v3(181.16,20.36) v3(181.67,19.85) v3(181.79,21.25) v3(181.79,20.49) v3(182.3,20.11) v3(182.43,20.74) v3(187.33,16.02) v3(197.44,65.57) v3(197.44,64.94) v3(198.38,63.36) v3(199.02,63.36) v3(199.4,27.68) v3(199.9,27.19) v3(200.03,27.93) v3(202.88,60.24) v3(202.88,59.6) v3(202.88,58.97) v3(205.74,62.87) v3(206.43,62.87) v3(206.79,12.13) v3(207.5,12.13) v3(218.65,33.03) v3(218.65,32.37) v3(219.21,32.73) v3(219.69,21.4) v3(220.35,21.4) v3(221.01,21.4) v3(239.45,162.46) v4(147.8,5.86) v4(152.18,10.38)
+3VALW_FB: length 2.7
  BOTTOM w0.254: PC212.1 166.86,4.79 v4(167.52,5.45) 167.53,5.46 PU201.3
+3VALW_GS: length 42.2
  TOP w0.254: 201.61,66.71 202.57,66.71 RG7.1 202.75,66.64 202.75,65.52 203,65.27 205.03,65.27 205.28,65.52 UGSEN1.14 ; 208.77,66.21 211.89,66.21 212.15,66.46 QG2.2 ; UGSEN1.1 208.74,66.94 CG6.1 ; CG3.1 200.21,69.89
  TOP w0.381: v3(207.88,72.63) 207.88,73.4 206.61,74.67 v4(205.06,74.67) 204.35,73.95 204.35,73.09 RG6.2 201.05,73.01 200.21,72.18 CG3.1 ; v3(207.88,70.88) 209.91,70.88 210.52,70.27 211.33,70.27 212.15,69.46 QG2.5
  TOP w0.508: CG5.1 202.47,64.43 202.77,64.12 208.16,64.12 208.77,64.73 CG6.1
  IN1 w0.381: v3(207.88,70.88) v3(207.88,72.63)
