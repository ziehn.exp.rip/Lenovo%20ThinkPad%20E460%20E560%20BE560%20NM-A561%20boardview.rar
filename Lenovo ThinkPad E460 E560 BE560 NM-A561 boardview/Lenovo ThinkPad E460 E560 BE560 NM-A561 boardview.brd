# Allegro board Lenovo ThinkPad E460 E560 BE560 NM-A561 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_PCIE_LAN#: length 55.5
  TOP w0.114: v3(57.05,108.85) 56.78,108.85 56.29,109.34 56.29,110.23 v3(56.32,110.25) 56.29,110.28 56.29,110.89 55.68,111.5 55.68,115.64 55.28,116.04 55.28,116.91 53.7,118.48 51.36,118.48 51.29,118.55 UL1.45
  IN1 w0.14: v3(57.05,108.85) 57.05,108.66 57.19,108.52 57.53,108.52 57.97,108.96 57.97,109.49 60.13,111.65 68.61,111.65 68.81,111.85 71.58,111.85 71.89,111.55 74.63,111.55 75.39,112.31 79.58,112.31 79.97,112.69 83.94,112.69 v3(84.14,112.89)
  BOTTOM w0.076: 86.63,106.78 86.63,106.76 86.63,106.76 86.63,106.75 86.62,106.74 86.62,105.34 86.77,105.19 86.77,104.82 86.76,104.79 86.73,104.73 86.73,104.54 86.73,104.54 86.77,104.45 86.77,104.2 86.76,104.18 86.63,103.72 86.63,103.61 86.55,103.34 UC1.D40
  BOTTOM w0.114: 86.63,106.78 86.63,106.99 86.77,107.12 86.77,109.57 85.11,111.23 85.11,112.6 84.82,112.89 v3(84.14,112.89)
CLK_PCIE_VGA: length 79.2
  TOP w0.114: v1(139.38,129.35) 139.07,129.66 139.07,130.09 139.4,130.42 RV4.1
  IN3 w0.114: v1(84.13,110.96) 83.8,110.63 83.68,110.63 83.34,110.97 83.34,115.93 84.41,117 84.41,119.89 90.29,125.77 96.68,125.77 97.8,124.65 103.27,124.65 104.81,126.2 122.34,126.2 124.42,128.28 138.85,128.28 139.1,128.53 139.1,129.09 139.36,129.35 v1(139.38,129.35)
  BOTTOM w0.076: UC1.A40 86.23,105.07 86.23,105.58 85.86,105.96 85.86,106.12 85.88,106.14 85.88,106.16
  BOTTOM w0.114: 85.88,106.16 85.88,106.49 86.01,106.61 86.01,106.94 85.88,107.07 85.88,107.4 86.01,107.53 86.01,107.86 85.88,107.98 85.88,109.38 84.63,110.63 84.46,110.63 v1(84.13,110.96)
CLK_PCIE_VGA#: length 79.3
  TOP w0.114: v1(138.74,129.35) 138.84,129.45 138.84,130.2 138.63,130.42 RV5.1
  IN3 w0.114: v1(138.74,129.35) 138.89,129.2 138.89,128.61 138.77,128.49 124.34,128.49 122.26,126.4 104.73,126.4 103.18,124.86 97.88,124.86 96.76,125.97 90.2,125.97 84.21,119.98 84.21,117.08 83.14,116.02 83.14,110.89 83.6,110.43 84,110.43 v1(84.13,110.3)
  BOTTOM w0.076: UC1.B40 86.07,104.58 86.07,105.52 85.7,105.89 85.7,106.1 85.65,106.14 85.65,106.16
  BOTTOM w0.114: v1(84.13,110.3) 84.23,110.4 84.54,110.4 85.65,109.29 85.65,106.16
CLK_PCIE_WLAN: length 225.1
  IN3 w0.114: v1(84.16,108.4) 84.11,108.4 83.67,108.83 83.32,108.83 82.84,109.31 82.84,109.69 82.4,110.12 82.4,114.97 81.77,115.61 81.77,118.57 89.9,126.71 97.06,126.71 98.15,125.62 102.89,125.62 104.42,127.14 121.97,127.14 124.71,129.88 136.72,129.88 137.38,130.55 141.66,130.55 142.37,129.83 145.14,129.83 145.29,129.68 153.7,129.68 157.36,126.02 162.21,126.02 164.3,123.93 170.61,123.93 172.84,121.71 174.24,121.71 175,122.47 179.32,122.47 180.02,123.17 180.02,125.01 181.01,126 189.46,126 189.67,125.8 207.07,125.8 218.32,137.05 224.08,137.05 236.94,149.9 236.94,152.36 234.98,154.32 234.98,155.84 244.25,165.11 244.25,165.57 244.04,165.78 243.78,165.78 243.57,165.57 v1(243.57,165.39)
  BOTTOM w0.076: 85,106.09 84.99,106.08 84.99,106.07 85.04,106.03 85.04,105.68 85.7,105.03 85.7,104.24 85.77,104.16 UC1.C41
  BOTTOM w0.114: JWLBT.47 242.77,171.9 242.87,171.79 243.38,171.79 244.37,170.81 244.37,165.93 244.12,165.68 243.86,165.68 v1(243.57,165.39) ; v1(84.16,108.4) 84.48,108.72 84.64,108.72 85.02,108.34 85.02,106.11 85,106.09
CLK_PCIE_WLAN#: length 225.1
  IN3 w0.114: v1(243.57,166.2) 243.57,166.2 243.78,165.99 244.13,165.99 244.46,165.66 244.46,165.03 235.18,155.76 235.18,154.4 237.14,152.45 237.14,149.82 224.17,136.84 218.4,136.84 207.15,125.59 189.58,125.59 189.38,125.8 181.09,125.8 180.22,124.92 180.22,123.08 179.4,122.26 175.08,122.26 174.32,121.5 172.76,121.5 170.53,123.73 164.22,123.73 162.13,125.82 157.27,125.82 153.62,129.48 145.21,129.48 145.06,129.63 142.29,129.63 141.58,130.34 137.46,130.34 136.8,129.68 124.8,129.68 122.05,126.94 104.5,126.94 102.98,125.41 98.07,125.41 96.98,126.51 89.99,126.51 81.97,118.49 81.97,115.69 82.61,115.06 82.61,110.21 83.04,109.78 83.04,109.39 83.4,109.03 v1(84.13,109.03)
  BOTTOM w0.076: 85.22,106.09 85.22,106.07 85.21,106.08 85.2,106.08 85.2,105.75 85.86,105.09 85.86,104.32 86.07,104.11 86.07,103.87 85.77,103.58 UC1.D41
  BOTTOM w0.114: 85.22,106.09 85.22,108.42 84.73,108.92 84.24,108.92 v1(84.13,109.03) ; JWLBT.49 242.77,171.4 242.93,171.57 243.29,171.57 244.14,170.72 244.14,166.02 244.02,165.91 243.86,165.91 v1(243.57,166.2)
CLK_REQ_GPU#: length 58.1
  TOP w0.114: v3(159.26,116.91) 159.09,116.91 158.12,117.87 156.65,117.87 156.44,117.67 RV16.2 156.85,117.24 157.13,116.96 157.13,115.13 155.95,113.95 155.95,113.03 RV15.2 154.22,113.82 QV1.3 153.54,113.82 v4(152.51,114.85) 152.01,115.34 RV14.2
  IN2 w0.14: v3(163.76,152.69) 164.12,152.34 164.12,141.5 163.61,140.99 163.61,135.26 164.64,134.23 164.64,130.96 164.12,130.44 164.12,125.59 165.92,123.79 165.92,122.35 161.97,118.39 159.81,118.39 159.26,117.85 v3(159.26,116.91)
  BOTTOM w0.114: RV129.1 163.38,153.07 v3(163.76,152.69)
CLKOUT_ITPXDP_N: length 1.1
  TOP w0.076: v3(84.62,101.83) 84.47,101.83 TC16.1
  BOTTOM w0.076: v3(84.62,101.83) 84.86,101.59 UC1.F43
CLKOUT_ITPXDP_P: length 1.2
  TOP w0.076: TC17.1 84.96,102.47 v3(84.62,102.47)
  BOTTOM w0.076: UC1.E43 84.84,102.24 v3(84.62,102.47)
CLKREQ_PCIE2_WLAN#: length 307.3
  TOP w0.114: v3(216.69,32.04) 215.09,30.44 212.48,30.44 211.38,31.55 v4(206.27,31.55) 204.04,33.77 191.88,33.77 191.17,34.48 174.78,34.48 172.85,36.42 171.69,36.42 168.86,33.59 v3(166.38,33.59) ; v3(126.93,74.59) 126.93,73.6 127.2,73.33 RPC200.8
  IN1 w0.076: v3(104.74,85.75) 105.11,85.38 105.11,84.57 106.58,83.1 107.93,83.1 111.97,79.05
  IN1 w0.14: v3(216.69,32.04) 217.32,32.67 217.32,57.33 219.96,59.97 219.96,66.38 216.09,70.25 216.09,105.8 217.42,107.13 217.42,115.79 224.64,123.02 224.64,134.22 228.91,138.49 228.91,140.04 239.01,150.14 239.01,159.79 242.27,163.05 242.27,166.54 v3(243.39,167.65) ; 111.97,79.05 114.37,79.05 117.13,76.29 117.72,76.29 118.01,75.99 120.9,75.99 122.23,74.67 122.84,74.67 123.07,74.44 123.25,74.44 124.24,73.45 125.28,73.45 126.42,74.59 v3(126.93,74.59) 128.73,72.79 128.73,71.41 130.12,70.02 133.91,70.02 134.61,69.32 144.9,69.32 147.33,66.89 150.98,66.89 161.65,56.22 161.65,38.09 166.15,33.59 v3(166.38,33.59)
  BOTTOM w0.076: UC1.AT8 105.09,86.1 v3(104.74,85.75)
  BOTTOM w0.114: JWLBT.53 242.62,170.4 243.49,169.53 243.49,167.76 v3(243.39,167.65)
CLKREQ_PCIE3_LAN#: length 358.5
  TOP w0.114: UL1.48 51.19,119.75 51.62,120.18 v3(51.62,120.61) ; v3(127.64,72.71) 128.17,72.71 128.5,73.04 128.5,73.65 128.32,73.83 RPC200.7 ; v4(160.33,50.89) v3(160.33,51.6)
  IN1 w0.076: v3(103.84,86.39) 103.86,86.37 103.88,86.37 104.2,86.04 104.2,84.62 106.03,82.79 107.64,82.79 111.96,78.47
  IN1 w0.14: 111.96,78.47 113.07,78.47 116.64,74.91 118.72,74.91 119.27,75.46 120.37,75.46 121.13,74.7 121.13,73.82 122.09,72.86 127.49,72.86 v3(127.64,72.71) 128.15,72.2 128.15,71.11 129.77,69.49 133.5,69.49 134.21,68.78 144.44,68.78 146.95,66.28 150.68,66.28 158.82,58.14 158.82,54.38 160.33,52.87 v3(160.33,51.6)
  IN2 w0.14: v3(159.21,18) 159.09,17.87 150.81,17.87 145.83,12.89 140.9,12.89 138.19,10.18 122.01,10.18 119.34,12.85 49.45,12.85 35.24,27.07 35.24,31.77 34.68,32.33 34.68,34.7 31.27,38.1 31.27,54.8 30.41,55.67 30.41,62.75 29.75,63.41 29.75,65.93 29.37,66.31 28.84,66.31 27.95,67.2 27.95,68.44 27.06,69.33 27.06,72.68 28.1,73.73 29.68,73.73 31.23,75.28 31.23,77.13 32.72,78.63 32.72,78.98 36.25,82.51 36.25,83.66 38.41,85.81 38.41,97.3 48.27,107.16 48.27,110.83 52.33,114.9 52.33,119.9 v3(51.62,120.61)
  BOTTOM w0.076: UC1.AT10 104.14,86.1 103.88,86.37 103.86,86.37 v3(103.84,86.39)
  BOTTOM w0.114: v3(160.33,51.6) 159.72,50.99 159.72,18.51 v3(159.21,18)
CLKREQ_PCIE4_VGA#: length 118.3
  TOP w0.114: v3(154.74,116.75) 155.15,116.35 CV20.1 ; CV20.1 155.53,114.59 QV1.1 ; CV20.1 RV16.1 155.53,118.3 v4(155.89,118.66) ; RC165.2 RC166.2 123.45,77.13 v3(123.45,76.37)
  IN2 w0.14: v3(154.59,69.53) 151.29,69.53 150.63,70.19 144.83,70.19 144.56,70.46 133.17,70.46 132.91,70.72 131.13,70.72 130.33,71.52 127.11,71.52 125.71,72.91 124.83,72.91 124.11,73.63 124.11,74.31 124.31,74.51 124.31,75.81 123.75,76.37 v3(123.45,76.37) 122.92,75.83 117.33,75.83 116.36,76.8 114.44,76.8 106.62,84.62 105.24,84.62 v3(104.74,85.12)
  BOTTOM w0.076: UC1.AU8 105.07,85.45 v3(104.74,85.12)
  BOTTOM w0.114: v3(154.59,69.53) 155.53,70.47 155.53,84.39 153.42,86.5 153.42,89.64 153.09,89.98 153.09,91.5 158.04,96.45 158.04,96.62 158.27,96.85 158.27,111.75 158.04,111.98 158.04,113.28 154.74,116.58 v3(154.74,116.75)
CLKREQ_PCIE5_CR#: length 212.6
  TOP w0.114: UW1.2 51.09,33.91 51.82,34.63 v4(54.77,34.63) 55,34.63 58.83,30.8 58.83,27.78 v3(67.14,19.47) ; v3(123.33,75.2) 123.73,75.6 126.88,75.6 127.65,74.83 RPC200.5
  IN1 w0.076: v3(105.65,85.12) 105.65,84.46 106.71,83.4 108.23,83.4 111.91,79.72
  IN1 w0.14: 111.91,79.72 114.64,79.72 117.43,76.93 117.84,76.93 118.24,76.53 121.12,76.53 122.26,75.38 123.14,75.38 v3(123.33,75.2)
  IN2 w0.14: v3(123.33,75.2) 123.33,74.66 123.55,74.44 123.55,73.81 124.73,72.63 125.58,72.63 126.98,71.24 130.23,71.24 131.02,70.45 132.8,70.45 133.05,70.19 144.45,70.19 144.81,69.84 145.19,69.84 v3(147.55,67.48)
  IN3 w0.114: v3(67.14,19.47) 67.75,20.08 79.89,20.08 81.68,18.29 113.81,18.29 116.67,21.15 120.44,21.15 124.89,25.6 124.89,29.16 128.25,32.53 128.25,35.13 130.1,36.99 130.1,42.18 130.59,42.66 132.49,42.66 133.53,43.7 137.57,43.7 138.64,42.64 147.94,42.64 v3(148.14,42.43)
  BOTTOM w0.076: v3(105.65,85.12) 105.99,85.45 UC1.AU7
  BOTTOM w0.114: v3(148.14,42.43) 150.35,42.43 154.16,46.24 154.16,47.23 154.51,47.59 154.51,54.35 151.57,57.29 151.57,62.37 147.55,66.39 v3(147.55,67.48)
CLKRUN#: length 19.4
  TOP w0.114: v3(108.58,75.83) 107.55,74.81 v4(107.55,72.35) 107.55,71.04 108.38,70.21 108.91,70.21 RC52.1
  BOTTOM w0.076: 106.18,80.71 105.95,80.94 104.4,80.94 103.67,81.67 103.67,82 103.83,82.16 103.83,83.83 103.51,84.14 UC1.AW11
  BOTTOM w0.102: 106.18,80.71 107.52,79.36 107.52,76.89 v3(108.58,75.83)
CP_BYPASS: length 398.8
  TOP w0.114: RC413.1 33.78,103.38 v4(33.79,103.37) 33.51,103.09 v3(33.23,103.09) 32.9,103.09 32.62,103.37 R105.1 ; v1(113.72,98.08) 114.99,96.81 114.99,95.1 114.23,94.34 114.23,93.96 114.61,93.58 117.21,93.58 117.53,93.89 117.53,94.59 118.28,95.34 RC428.1 ; RC431.2 176.08,48.74 v1(173.03,45.7)
  IN1 w0.14: v1(147.95,94.52) 147.47,94.52 146.61,95.37 145.22,95.37 144.18,96.41 126.27,96.41 125.08,97.6 123.53,97.6 122.42,98.71 120.63,98.71 120.36,98.44 116.95,98.44 116.72,98.67 114.5,98.67 113.91,98.08 v1(113.72,98.08)
  IN3 w0.114: v3(155.64,16.77) 155.07,16.21 152.67,16.21 149.05,12.59 141.97,12.59 136.05,6.67 122.96,6.67 117.22,12.41 38.7,12.41 36.79,14.32 33.71,14.32 25.14,22.9 22.4,22.9 16.76,28.54 16.76,37.02 21.47,41.74 21.47,52.72 16.76,57.43 16.76,66.68 18.83,68.75 18.83,84.66 20.57,86.41 20.57,92.07 20.98,92.48 21.78,92.48 22.34,93.04 22.34,94.29 23.79,95.75 25.05,95.75 27.19,97.89 31.15,97.89 32.11,98.86 32.11,101.97 v3(33.23,103.09) ; v1(156.2,46.14) 156.85,45.49 172.83,45.49 v1(173.03,45.7)
  BOTTOM w0.114: v3(155.64,16.77) 155.64,38.93 156.01,39.31 156.01,45.95 v1(156.2,46.14) 156.01,46.33 156.01,59.25 154.69,60.57 154.69,62.45 149.89,67.25 149.89,69.34 149.64,69.59 149.64,72.11 149.15,72.6 149.15,77.36 148.09,78.42 148.09,81.55 149.03,82.49 149.03,84.66 148.55,85.15 148.55,89.32 148.24,89.63 148.24,89.85 147.58,90.51 147.25,90.51 146.58,91.19 146.58,92.35 147.16,92.93 147.16,93.73 v1(147.95,94.52)
CP_BYPASS_EC: length 14.7
  TOP w0.114: RC431.1 176.08,52.49 177.03,53.44 177.03,54.08 177.73,54.78 178.24,54.78 179.57,56.11 v2(179.7,56.11) 179.95,56.36 179.95,56.68 180.71,57.44 181.03,57.44 181.6,58.02 183.44,58.02 184.02,57.44 184.02,56.49 184.44,56.07 UE1.67
CP_BYPASS_R: length 13
  TOP w0.114: v1(118.29,96.18) 118.36,96.18 119.12,95.42 RC428.2
  IN2 w0.14: v3(110.88,93.38) 110.88,94.5 111.5,95.12 112.52,95.12 113.84,96.45 115.46,96.45 115.78,96.76 117.71,96.76 v1(118.29,96.18)
  BOTTOM w0.076: v3(110.88,93.38) 110.48,93.78 109.61,93.78 109.33,93.65 109.33,93.64 109.32,93.64 109.18,93.5 UC1.AB2
CP_CLK: length 304
  TOP w0.114: JCP.9 34.54,99.2 33.54,99.2 32.32,100.42 C44.1 31.8,100.18 31.55,99.94 30.05,99.94 29.75,100.24 29.75,102.33 v3(29.57,102.5) ; v3(157.57,34.47) 158.15,35.04 v4(158.25,35.04) 158.63,35.42 166.96,35.42 170.83,39.3 172.49,39.3 181.07,47.87 182.05,47.87 182.85,48.67 182.85,49.05 RE5.1 183.33,49.25 183.33,48.57 183.14,48.38 183.14,47.84 183.72,47.27 UE1.89
  IN3 w0.114: v3(157.13,15.48) 156.47,14.82 151.97,14.82 148.59,11.45 141.61,11.45 136.21,6.05 122.66,6.05 116.91,11.8 38.54,11.8 37.8,12.54 34.82,12.54 24.99,22.37 22.25,22.37 16.27,28.34 16.27,37.22 20.99,41.94 20.99,52.52 16.27,57.23 16.27,66.01 15.11,67.18 15.11,68.3 18.34,71.54 18.34,84.96 20.07,86.68 20.07,92.71 23.59,96.23 24.85,96.23 29.57,100.95 v3(29.57,102.5)
  BOTTOM w0.114: v3(157.13,15.48) 158.07,16.42 158.07,19.93 156.98,21.02 156.98,33.87 v3(157.57,34.47)
CP_DATA: length 302.4
  TOP w0.114: v5(29.83,103.14) 30.03,102.94 30.03,102.15 30.38,101.79 31.55,101.79 31.8,101.55 C45.1 31.8,101.18 32.21,101.18 32.49,100.9 32.49,100.73 33.52,99.7 34.54,99.7 JCP.10 ; UE1.90 184.78,46.87 184.64,46.73 183.46,46.73 RE6.1 183.2,46.87 182.44,47.63 181.17,47.63 172.6,39.05 171.08,39.05 167.07,35.05 158.9,35.05 v3(157.59,33.75)
  IN3 w0.114: v5(29.83,103.14) 29.52,103.14 29.01,102.63 29.01,100.75 24.8,96.53 23.44,96.53 19.81,92.9 19.81,86.76 18.1,85.06 18.1,71.64 14.87,68.4 14.87,56.43 20.75,50.55 20.75,42.04 16.03,37.32 16.03,28.24 22.15,22.13 24.89,22.13 35.47,11.55 116.82,11.55 122.56,5.81 136.31,5.81 140.95,10.45 147.93,10.45 152.03,14.54 156.9,14.54 v3(157.84,15.48)
  BOTTOM w0.114: v3(157.59,33.75) 157.22,33.38 157.22,21.26 158.48,20 158.48,16.12 v3(157.84,15.48)
CP_RESET#: length 329.2
  TOP w0.114: R67.2 32.57,99.45 v3(32.59,99.48) 33.2,98.87 33.66,98.87 33.83,98.7 34.54,98.7 JCP.8 ; v1(171.63,46.46) 172.14,46.97 173.92,46.97 175.13,48.17 RC430.1 ; v4(156.09,14.8) v3(156.09,15.46) ; v1(148.14,96.31) 147.82,96.62 RC427.2
  IN2 w0.14: v3(32.59,99.48) 33.36,99.48 33.82,99.02 33.82,96.95 32.26,95.39 32.26,93.23 31.07,92.04 31.07,79.31 29.57,77.81 29.57,75.95 29.19,75.58 27.34,75.58 25.03,73.27 25.03,67.02 27.13,64.91 27.13,55.89 29.39,53.62 29.39,37.65 32.67,34.38 32.67,31.31 33.46,30.52 33.46,26.68 33.46,26.46 48.66,11.25 48.66,11.25 48.78,11.14 118.71,11.14 124.24,5.6 136.81,5.6 140.54,9.34 144.96,9.34 150.58,14.95 155.58,14.95 v3(156.09,15.46)
  IN3 w0.114: v1(156.77,46.78) 157.09,46.46 v1(171.63,46.46)
  BOTTOM w0.114: v1(148.14,96.31) 148.14,95.86 149.67,94.33 149.67,88.59 149.36,88.28 149.36,85.36 149.76,84.95 149.76,80.53 149.54,80.3 149.54,78.45 150.81,77.18 150.81,72.51 151.3,72.01 151.3,66.57 155.45,62.42 155.45,60.67 156.62,59.5 156.62,46.93 v1(156.77,46.78) 156.9,46.65 156.9,45.76 156.62,45.48 156.62,38.77 156.22,38.37 156.22,17.62 156.37,17.46 156.37,15.74 v3(156.09,15.46)
CP_RESET#_EC: length 38.2
  TOP w0.114: RC430.2 173.68,51.61 v1(172.4,50.33) ; v1(188.97,55.67) 194.07,55.67 195.53,57.13 198.56,57.13 198.91,57.48 UE1.35
  IN3 w0.114: v1(188.97,55.67) 188.72,55.41 188.72,52.11 185.35,48.74 183.19,48.74 182.3,47.86 176.78,47.86 173.79,50.84 172.9,50.84 v1(172.4,50.33)
CP_RESET#_R: length 42.1
  TOP w0.114: v1(146.55,95.92) 146.55,96.61 RC427.1
  IN1 w0.14: v1(146.55,95.92) 146.55,95.99 145.6,96.94 127.72,96.94 125.08,99.58 123.85,99.58 123.69,99.43 120.56,99.43 120.11,98.98 117.02,98.98 116.02,99.98 114.29,99.98 112.93,98.62 110.78,98.62 v3(110.17,98.01)
  BOTTOM w0.076: UC1.P3 108.58,97.68 108.74,97.68 108.96,97.75 109.09,97.75 109.32,97.69 109.51,97.69 109.83,98.01 v3(110.17,98.01)
CPU_EDP_AUX: length 39.8
  TOP w0.114: C18.1 96.17,128.14 v3(96.69,127.61) 97.44,126.87 97.44,123.99 95,121.55 93.97,121.55 93.79,121.73 93.79,121.91 93.93,122.05 v3(94.03,122.05)
  IN3 w0.076: v3(83.71,101.83) 84.02,102.15 84.08,102.15 84.25,102.32 84.25,102.88 84,103.13 84,103.62 84.4,104.02 84.44,104.02
  IN3 w0.114: 84.44,104.02 84.69,104.02 86.21,105.54 86.21,106.15 86.43,106.37 86.43,115.14 86.88,115.6 88.48,115.6 89.63,116.75 90.16,116.75 90.42,117.01 90.42,117.51 90.15,117.78 89.74,117.78 89.6,117.92 89.6,118.64 89.71,118.75 90.76,118.75 91.19,119.17 91.19,120.18 92.06,121.05 93.26,121.05 93.72,121.51 93.72,121.89 93.88,122.05 v3(94.03,122.05)
  BOTTOM w0.076: v3(83.71,101.83) 83.82,101.94 84.08,101.94 84.16,101.86 UC1.F45
CPU_EDP_AUX#: length 39.8
  TOP w0.114: v3(93.32,122.07) 93.56,121.83 93.56,121.64 93.88,121.32 95.09,121.32 97.67,123.9 v3(97.67,126.05) 97.67,126.96 96.14,128.49 C17.1
  IN3 w0.076: v3(83.71,102.47) 83.86,102.31 84.01,102.31 84.09,102.39 84.09,102.81 83.84,103.06 83.84,103.69 84.37,104.22 84.38,104.22 84.44,104.22
  IN3 w0.114: 84.44,104.22 84.6,104.22 86.01,105.63 86.01,106.24 86.23,106.45 86.23,115.23 86.8,115.8 88.39,115.8 89.55,116.96 90.08,116.96 90.21,117.09 90.21,117.43 90.07,117.58 89.66,117.58 89.4,117.83 89.4,118.72 89.63,118.95 90.68,118.95 90.98,119.26 90.98,120.26 91.97,121.25 93.18,121.25 93.52,121.59 93.52,121.87 v3(93.32,122.07)
  BOTTOM w0.076: UC1.E45 v3(83.71,102.47)
CPU_EDP_AUX#_CON: length 6.4
  TOP w0.114: C17.2 95.05,129.42 94.72,129.75 94.72,130.77 94.48,131.02 v3(94.48,132.02) 94.48,133.88 94.06,134.3 94.06,134.46 JLCD.20
CPU_EDP_AUX_CON: length 6.4
  TOP w0.114: C18.2 94.86,129.29 94.49,129.66 v3(94.49,130.06) 94.49,130.68 94.25,130.93 94.25,133.79 93.88,134.15 93.81,134.15 JLCD.21
CPU_EDP_HPD: length 82.2
  TOP w0.114: JLCD.22 93.66,133.74 93.66,132.5 93.61,132.45 v3(93.61,131.84) ; v3(113.53,119.99) 113.09,119.55 113.09,116.88 115.22,114.75 v4(115.47,114.75) 117.3,114.75 117.76,114.29 117.76,113.02 119.29,111.49 119.65,111.49 121.39,109.75 121.39,108.4 123.09,106.7 123.09,106.41 123.48,106.02 123.48,102.38 v3(123.3,102.2) 123.3,101.43 123.93,100.8 123.93,99.86 123.49,99.42 119.75,99.42 RC159.1
  IN1 w0.076: 108.05,100.01 107.44,100.01 106.5,99.07 105.21,99.07 v3(104.67,98.53)
  IN1 w0.14: 108.05,100.01 109.91,101.87 114.3,101.87 114.87,102.44 116.36,102.44 117.74,101.06 121.47,101.06 121.6,101.18 122.89,101.18 123.3,101.59 v3(123.3,102.2) ; v3(93.61,131.84) 94.88,131.84 96.89,129.82 100.4,129.82 104.99,125.23 104.99,124.14 105.3,123.84 105.3,123.1 108.67,119.72 113.26,119.72 113.26,119.72 v3(113.53,119.99)
  BOTTOM w0.076: UC1.L10 v3(104.67,98.53)
CPU_EDP_TX0+: length 39.4
  TOP w0.114: v3(93.32,124.31) 93.52,124.31 93.71,124.5 93.71,125.42 93.53,125.6 C16.1
  IN3 w0.114: v5(82.11,106.95) 82.4,106.66 83.99,106.66 84.33,107 84.89,107 85.53,107.63 85.53,115.55 86.61,116.63 87.56,116.63 88,117.07 88,117.71 86.53,119.18 86.53,120.3 90.67,124.44 90.97,124.44 91.16,124.25 91.16,123.06 91.27,122.95 91.63,122.95 91.72,123.04 91.72,124.15 91.94,124.37 92.39,124.37 92.58,124.18 92.58,123.1 92.65,123.03 93.55,123.03 93.66,123.14 93.66,124.2 93.54,124.31 v3(93.32,124.31)
  BOTTOM w0.076: UC1.C46 82.61,103.99 82.51,104.08 82.47,104.23 82.47,104.42 82.5,104.51 82.5,104.76 82.47,104.86 82.47,105.17 82.75,105.46 82.75,106.71 82.57,106.89 82.16,106.89 v5(82.11,106.95)
CPU_EDP_TX0+_CON: length 6.5
  TOP w0.114: C16.2 92.32,126.84 92.11,127.05 92.11,127.45 91.85,127.7 v3(91.85,127.93) 91.85,131.58 JLCD.29
CPU_EDP_TX0-: length 39.4
  TOP w0.114: C15.1 93.6,125.85 93.94,125.52 v3(93.94,124.91) 93.94,124.49 v3(94.12,124.31)
  IN3 w0.114: v3(94.12,124.31) 93.86,124.05 93.86,123.05 93.63,122.82 92.57,122.82 92.37,123.02 92.37,124.1 92.3,124.17 92.03,124.17 91.92,124.06 91.92,122.95 91.71,122.75 91.19,122.75 90.95,122.98 90.95,124.17 90.89,124.23 90.76,124.23 86.73,120.21 86.73,119.26 88.21,117.79 88.21,116.99 87.64,116.42 86.69,116.42 85.73,115.46 85.73,107.55 84.98,106.8 84.41,106.8 84.07,106.46 82.27,106.46 v3(82.11,106.3)
  BOTTOM w0.076: v3(82.11,106.3) 82.32,106.3 82.39,106.37 82.39,106.55 82.37,106.57 82.37,106.66 82.44,106.73 82.51,106.73 82.59,106.64 82.59,105.53 82.3,105.24 82.3,104.81 82.31,104.81 82.34,104.73 82.34,104.54 82.3,104.45 82.3,104.2 82.44,103.72 82.5,103.66 UC1.C47
CPU_EDP_TX0-_CON: length 6.5
  TOP w0.114: C15.2 92.6,126.88 92.34,127.14 92.34,127.54 92.08,127.79 v3(92.08,129.45) 92.08,131.69 91.78,131.99 91.78,132.22 JLCD.28
CPU_EDP_TX1+: length 40.2
  TOP w0.114: C14.1 94.3,126.94 94.77,126.94 v3(95.31,126.4) 95.87,125.85 95.87,124.68 v3(95.49,124.31)
  IN3 w0.114: v3(82.1,108.24) 82.36,108.51 82.52,108.51 83.34,107.69 84.47,107.69 85.02,108.24 85.02,116.35 85.86,117.18 85.86,120.33 90.46,124.93 93.47,124.93 93.6,124.8 93.94,124.8 94.07,124.93 95.63,124.93 95.87,124.69 95.87,124.47 95.7,124.31 v3(95.49,124.31)
  BOTTOM w0.076: UC1.C45 83.86,103.61 83.77,103.52 83.54,103.52 83.44,103.61 83.44,103.72 83.72,104 84,104 84.08,104.08 84.13,104.23 84.13,104.42 84.09,104.51 84.09,104.76 84.13,104.87 84.13,105.12 83.88,105.37 83.88,105.92 83.43,106.37 83.43,106.67 83.39,106.7 83.39,106.72
  BOTTOM w0.114: 83.39,106.72 83.39,107 83.22,107.18 83.22,107.48 83.39,107.66 83.39,107.86 83.29,107.97 83.18,108.08 82.95,108.08 82.77,108.26 82.77,108.33 82.77,108.49 82.66,108.6 82.45,108.6 v3(82.1,108.24)
CPU_EDP_TX1+_CON: length 6.3
  TOP w0.114: C14.2 93.59,127.95 v3(93.02,128.51) 93.02,128.51 92.87,128.67 92.87,130.6 92.74,130.72 92.74,132.51 92.42,132.83 92.3,132.83 JLCD.26
CPU_EDP_TX1-: length 40.2
  TOP w0.114: v3(96.29,124.31) 96.09,124.5 v3(96.09,125.26) 96.09,125.94 94.87,127.17 C13.1
  IN3 w0.114: v3(96.29,124.31) 96.07,124.53 96.07,124.78 95.71,125.13 90.38,125.13 85.65,120.41 85.65,117.27 84.82,116.43 84.82,108.32 84.38,107.89 83.43,107.89 82.61,108.71 82.27,108.71 v3(82.1,108.88)
  BOTTOM w0.076: UC1.D46 83.95,103.34 84.12,103.51 84.15,103.59 84.15,103.72 84.29,104.2 84.29,104.45 84.26,104.54 84.26,104.73 84.29,104.83 84.29,105.19 84.04,105.44 84.04,105.99 83.59,106.44 83.59,106.67 83.62,106.7 83.62,106.72
  BOTTOM w0.114: v3(82.1,108.88) 82.15,108.83 82.75,108.83 83.62,107.96 83.62,106.72
CPU_EDP_TX1-_CON: length 6.4
  TOP w0.114: C13.2 93.71,128.15 93.44,128.42 93.1,128.76 v3(93.1,130.3) 93.1,130.69 92.97,130.82 92.97,132.6 92.61,132.96 92.61,133.08 JLCD.25
CSB_1B: length 169.7
  TOP w0.114: v4(65.21,119.86) 65.28,119.79 v3(65.28,119.13)
  TOP w0.254: v3(65.28,119.13) 64.83,118.67 PR460.2
  IN2 w0.254: v3(154.36,91.45) 154.63,91.19 155.97,91.19 158.97,94.18 158.97,107.22 155.64,110.54 155.64,118.31 152.94,121.02 144.67,121.02 143.71,120.05 142.52,120.05 140.93,121.65 139.56,121.65 138.68,122.52 138.68,124.66 136.94,126.4 118.13,126.4 116.77,127.76 102.62,127.76 100.9,129.48 91.33,129.48 90.3,128.45 78.16,128.45 76.03,126.32 74.02,126.32 72.23,124.54 68.98,124.54 67.33,122.89 67.33,120.48 65.98,119.13 v3(65.28,119.13)
  IN3 w0.254: v3(154.36,91.45) 151.31,91.45 147.85,88 142.03,88 141.15,88.88 138.04,88.88 132.26,83.1 131.3,83.1 v3(131.12,83.28)
  BOTTOM w0.203: v3(65.28,119.13) 65.28,119.29 66.7,120.71 PU401.41
  BOTTOM w0.254: PRT405.2 130.59,83.96 131.12,83.43 v3(131.12,83.28) ; PC429.2 PC439.2 65.28,118.73 v3(65.28,119.13)
CSN1: length 2.8
  BOTTOM w0.114: PR456.2 72.62,129.02 71.75,129.9 v2(71.75,130.53)
  BOTTOM w0.254: PR423.2 PR456.2
CSN_1A: length 75.8
  IN2 w0.254: v3(133.13,115.4) 133.13,115.51 132.33,116.31 116.71,116.31 116.13,116.88 116.13,117.64 115.44,118.34 112.77,118.34 111.88,119.23 110.33,119.23 108.04,116.94 100.99,116.94 99.72,115.67 82.13,115.67 80.27,113.82 78.78,113.82 77.27,112.31 75.75,112.31 74.73,113.32 73.15,113.32 72.75,113.72 v3(72.75,114.47)
  BOTTOM w0.203: v2(73.25,114.28) 73.23,114.28 73.23,114.29 72.93,114.29 v3(72.75,114.47) 72.75,115.2 PC440.2 PC405.2 ; PR452.2 73.67,116.17 PC405.2 ; PC405.2 72.85,116.3 71.56,117.59 PU401.28
  BOTTOM w0.254: PRT401.2 133.05,112.36 133.05,115.32 v3(133.13,115.4)
CSP1: length 3.5
  TOP w0.114: v1(73.46,128.06) 73.65,128.25 v4(73.65,128.63)
  TOP w0.254: v1(73.46,128.06) 72.93,127.52 PR426.2
  BOTTOM w0.254: PR422.2 73.67,127.37 73.67,127.85 v1(73.46,128.06) 73.67,128.26 73.67,128.72 PR455.2
DDI1_MUX_TX0+: length 78.9
  TOP w0.114: CX4.1 27.56,69.88 27.56,70.77 v3(28.23,71.44) 28.76,71.97 28.76,72.74 28.9,72.88 v3(29.12,72.88)
  IN3 w0.076: v3(78.22,101.83) 77.99,102.07 77.81,102.07 77.67,102.2 77.67,103.45 76.18,104.94 75.06,104.94 75.04,104.92 75.02,104.92
  IN3 w0.114: v3(29.12,72.88) 28.95,72.88 28.76,73.06 28.76,74.43 39.2,84.87 39.2,90.54 43.17,94.5 45.47,94.5 49.79,98.82 49.79,101.46 53.52,105.2 54.46,105.2 57.77,108.5 61.63,108.5 62.36,107.76 66.95,107.76 67.89,106.82 72.82,106.82 73.39,106.25 73.39,105.54 74.01,104.92 75.02,104.92
  BOTTOM w0.076: UC1.F55 v3(78.22,101.83)
DDI1_MUX_TX0+_R: length 3.3
  TOP w0.114: CX4.2 27.57,68.31 27.57,67.89 27.02,67.35 26.66,67.35 26.38,67.07 26.38,66.96 26.47,66.87 UX1.3
DDI1_MUX_TX0-: length 78.9
  TOP w0.114: CX3.1 27.33,69.88 v3(27.33,70.52) 27.33,70.87 28.53,72.07 28.53,72.67 v3(28.33,72.88)
  IN3 w0.076: v3(78.22,102.47) 77.99,102.23 77.88,102.23 77.84,102.27 77.84,103.52 76.25,105.11 75.06,105.11 75.04,105.13 75.02,105.13
  IN3 w0.114: v3(28.33,72.88) 28.56,73.11 28.56,74.51 39,84.96 39,90.62 43.08,94.71 45.39,94.71 49.59,98.9 49.59,101.55 53.44,105.4 54.38,105.4 57.68,108.7 61.71,108.7 62.45,107.96 67.04,107.96 67.98,107.02 72.9,107.02 73.59,106.34 73.59,105.63 74.09,105.13 75.02,105.13
  BOTTOM w0.076: UC1.E55 v3(78.22,102.47)
DDI1_MUX_TX0-_R: length 3.3
  TOP w0.114: CX3.2 27.34,68.3 27.34,67.98 26.93,67.58 26.57,67.58 26.15,67.16 26.15,66.96 26.07,66.87 UX1.4
DDI1_MUX_TX1+: length 76.5
  TOP w0.114: CX6.1 25.79,69.88 25.79,71.03 v3(27.34,72.58) 30.48,75.72 33.57,75.72 33.98,75.31 v3(33.98,75.16)
  IN3 w0.076: v3(76.39,101.83) 76.16,102.07 75.98,102.07 75.85,102.2 75.85,102.66 75.6,102.91 73.61,102.91 71.48,105.04 70.2,105.04 68.32,103.16 67,103.16 66.99,103.14 66.97,103.14
  IN3 w0.114: v3(33.98,75.16) 34.3,75.48 34.51,75.48 40.72,81.69 40.72,90.1 43.4,92.78 45.72,92.78 51.67,98.72 51.67,100.6 53.68,102.61 56.44,102.61 57.94,101.11 61.56,101.11 62.01,101.56 63.07,101.56 63.35,101.28 64.4,101.28 66.26,103.14 66.97,103.14
  BOTTOM w0.076: UC1.F58 v3(76.39,101.83)
DDI1_MUX_TX1+_R: length 2.8
  TOP w0.114: UX1.6 25.27,66.87 25.18,66.96 25.18,67.36 25.76,67.94 25.76,68.29 CX6.2
DDI1_MUX_TX1-: length 76.5
  TOP w0.114: CX5.1 25.56,69.89 v3(25.56,70.65) 25.56,71.13 30.38,75.95 v3(33.98,75.95)
  IN3 w0.076: v3(76.39,102.47) 76.16,102.23 76.05,102.23 76.01,102.27 76.01,102.73 75.67,103.07 73.68,103.07 71.55,105.2 70.14,105.2 68.26,103.32 67,103.32 66.99,103.34 66.97,103.34
  IN3 w0.114: v3(33.98,75.95) 34.25,75.68 34.42,75.68 40.52,81.78 40.52,90.18 43.31,92.98 45.64,92.98 51.47,98.81 51.47,100.68 53.59,102.81 56.52,102.81 58.02,101.31 61.47,101.31 61.93,101.76 63.15,101.76 63.43,101.49 64.32,101.49 66.17,103.34 66.97,103.34
  BOTTOM w0.076: UC1.E58 v3(76.39,102.47)
DDI1_MUX_TX1-_R: length 2.8
  TOP w0.114: UX1.7 24.87,66.87 24.95,66.96 24.95,67.45 25.53,68.04 25.53,68.33 CX5.2
DDI1_MUX_TX2+: length 86.7
  TOP w0.114: CX8.1 22.99,69.95 22.99,71.16 v3(24.39,72.56) 27.41,75.58 27.87,75.58 28.45,76.16 28.45,76.49 28.61,76.65 v3(28.8,76.65)
  IN3 w0.076: v3(79.13,101.2) 78.9,101.43 78.72,101.43 78.59,101.56 78.59,103.35 75.84,106.1 74.97,106.1 74.44,106.63 74.44,107.13 74.42,107.15 74.42,107.17
  IN3 w0.114: v3(28.8,76.65) 28.6,76.65 28.4,76.85 28.4,77.04 30.8,79.44 32.75,79.44 38.47,85.16 38.47,90.85 42.81,95.19 45.17,95.19 48.93,98.94 48.93,101.61 56.93,109.62 60.59,109.62 60.99,109.21 62.2,109.21 62.89,108.52 67.38,108.52 67.79,108.12 71.74,108.12 72.55,108.93 74.12,108.93 74.42,108.62 74.42,107.17
  BOTTOM w0.076: UC1.G53 v3(79.13,101.2)
DDI1_MUX_TX2+_R: length 2.9
  TOP w0.114: CX8.2 23.09,68.34 23.09,68.05 23.98,67.17 23.98,66.96 24.07,66.87 UX1.9
DDI1_MUX_TX2-: length 86.7
  TOP w0.114: v3(28.01,76.65) 28.23,76.43 28.23,76.26 27.78,75.81 27.32,75.81 22.76,71.25 v3(22.76,70.68) 22.76,69.81 CX7.1
  IN3 w0.076: 74.62,107.17 74.62,107.15 74.61,107.13 74.61,106.69 75.04,106.26 75.91,106.26 78.75,103.42 78.75,101.63 78.79,101.6 78.9,101.6 v3(79.13,101.83)
  IN3 w0.114: v3(28.01,76.65) 28.2,76.85 28.2,77.13 30.71,79.64 32.67,79.64 38.27,85.24 38.27,90.93 42.73,95.39 45.09,95.39 48.72,99.03 48.72,101.7 56.84,109.82 60.67,109.82 61.08,109.41 62.29,109.41 62.97,108.73 67.47,108.73 67.87,108.32 71.65,108.32 72.46,109.13 74.2,109.13 74.62,108.71 74.62,107.17
  BOTTOM w0.076: UC1.F53 v3(79.13,101.83)
DDI1_MUX_TX2-_R: length 3
  TOP w0.114: CX7.2 22.87,68.28 22.87,67.96 v3(23.17,67.65) 23.75,67.07 23.75,66.96 23.67,66.87 UX1.10
DDI1_MUX_TX3+: length 84.7
  TOP w0.114: v3(35.49,77.61) 35.49,77.76 35.08,78.17 27.95,78.17 v3(22.28,72.51) 21.32,71.54 21.32,69.85 CX10.1
  IN3 w0.076: 75.12,104.07 75.14,104.07 75.16,104.09 75.69,104.09 76.76,103.02 76.76,101.62 76.95,101.43 77.07,101.43 v3(77.31,101.2)
  IN3 w0.114: v3(35.49,77.61) 35.77,77.89 36.11,77.89 36.94,78.72 36.94,81.62 39.95,84.63 39.95,90.23 43.24,93.51 45.47,93.51 50.78,98.82 50.78,101.44 53.71,104.37 54.73,104.37 58.07,107.71 61.34,107.71 62.08,106.97 66.7,106.97 67.61,106.06 72.44,106.06 72.57,105.92 72.57,105.15 73.65,104.07 75.12,104.07
  BOTTOM w0.076: UC1.G56 v3(77.31,101.2)
DDI1_MUX_TX3+_R: length 3.6
  TOP w0.114: CX10.2 21.32,68.34 21.32,67.9 21.49,67.73 22.23,67.73 22.78,67.18 22.78,66.96 22.87,66.87 UX1.12
DDI1_MUX_TX3-: length 84.7
  TOP w0.114: v3(35.49,78.4) 27.85,78.4 21.09,71.64 v3(21.09,70.73) 21.09,69.91 CX9.1
  IN3 w0.076: v3(77.31,101.83) 77.07,101.6 77.02,101.6 76.93,101.69 76.93,103.08 75.75,104.26 75.16,104.26 75.14,104.28 75.12,104.28
  IN3 w0.114: 75.12,104.28 73.73,104.28 72.78,105.23 72.78,106.01 72.52,106.26 67.7,106.26 66.78,107.18 62.16,107.18 61.42,107.91 57.99,107.91 54.65,104.57 53.63,104.57 50.58,101.52 50.58,98.9 45.39,93.72 43.15,93.72 39.75,90.31 39.75,84.72 36.73,81.7 36.73,78.81 36.02,78.09 35.79,78.09 v3(35.49,78.4)
  BOTTOM w0.076: UC1.F56 v3(77.31,101.83)
DDI1_MUX_TX3-_R: length 3.6
  TOP w0.114: CX9.2 21.09,68.28 21.09,67.81 21.39,67.5 v3(21.8,67.5) 22.14,67.5 22.55,67.09 22.55,66.96 22.47,66.87 UX1.13
DDI2_VGA_TX0+: length 73.1
  TOP w0.114: v3(43.59,98.87) 43.34,98.62 43.34,97.58 40.32,94.55 40.32,92.17 39.42,91.28 37.24,91.28 v3(35.92,89.96) 35.54,89.57 35.54,88.84 35.29,88.58 35.03,88.58 CVG16.1
  IN3 w0.114: v3(80.31,111.92) 80.16,111.77 77.96,111.77 77.55,112.18 76.08,112.18 75.55,112.71 73.34,112.71 72.98,112.36 65.92,112.36 64.27,114.01 57.56,114.01 57.38,113.83 55.21,113.83 51.12,109.74 51.12,109.34 45.52,103.75 45.52,100.07 43.87,98.41 43.5,98.41 43.39,98.52 43.39,98.67 v3(43.59,98.87)
  BOTTOM w0.076: UC1.D50 81.6,103.34 81.67,103.61 81.67,103.72 81.81,104.2 81.81,104.45 81.78,104.54 81.78,104.73 81.81,104.83 81.81,105.34 81.2,105.95 81.2,106.36 81.24,106.39
  BOTTOM w0.114: 81.24,106.39 81.24,111.46 80.94,111.76 80.47,111.76 v3(80.31,111.92)
DDI2_VGA_TX0-: length 73.1
  TOP w0.114: v5(42.74,98.96) 42.8,98.9 42.86,98.9 43.11,98.64 43.11,97.67 40.09,94.65 40.09,92.27 39.33,91.51 37.15,91.51 35.31,89.67 35.31,88.93 35.19,88.81 35.08,88.81 34.78,89.12 CVG15.1
  IN3 w0.114: v5(42.74,98.96) 42.8,98.9 42.98,98.9 43.19,98.69 43.19,98.44 43.41,98.21 43.95,98.21 45.73,99.99 45.73,103.66 51.32,109.26 51.32,109.66 55.29,113.63 57.47,113.63 57.65,113.81 64.18,113.81 65.83,112.16 73.06,112.16 73.42,112.51 75.46,112.51 75.99,111.98 77.47,111.98 77.88,111.57 80.01,111.57 v3(80.31,111.27)
  BOTTOM w0.076: UC1.C50 81.56,103.97 81.65,104.23 81.65,104.42 81.61,104.51 81.61,104.76 81.65,104.86 81.65,105.27 81.04,105.88 81.04,106.34 81.01,106.37 81.01,106.39
  BOTTOM w0.114: v3(80.31,111.27) 80.57,111.53 80.84,111.53 81.01,111.36 81.01,110.3 80.88,110.18 80.88,109.83 81.01,109.71 81.01,109.36 80.88,109.24 80.88,108.89 81.01,108.77 81.01,108.42 80.88,108.3 80.88,107.95 81.01,107.83 81.01,107.48 80.88,107.36 80.88,107.01 81.01,106.89 81.01,106.39
DDI2_VGA_TX1+: length 67
  TOP w0.114: CVG18.1 34.78,91.13 35.06,91.4 35.69,91.4 v5(35.82,91.27)
  IN3 w0.114: v3(79.22,107.06) 79.38,107.22 79.75,107.22 80.02,107.49 80.02,108.7 77.25,111.47 71.68,111.47 71.53,111.62 63.81,111.62 62.77,112.66 58.83,112.66 58.17,112 54.66,112 54.65,111.99 54.63,111.99 52.9,110.26 52.9,110.25 52.81,110.16 52.81,108.83 46.22,102.24 46.22,99.78 44.07,97.63 40.08,97.63 35.08,92.63 35.08,91.78 35.41,91.45 35.64,91.45 v5(35.82,91.27)
  BOTTOM w0.076: v3(79.22,107.06) 79.48,107.06 79.65,106.89 79.65,106.19 79.98,105.86 79.98,105.34 79.82,105.19 79.82,104.83 79.86,104.73 79.86,104.54 79.82,104.45 79.82,104.2 79.96,103.72 79.96,103.61 80.04,103.34 UC1.D52
DDI2_VGA_TX1-: length 67
  TOP w0.114: CVG17.1 35.17,91.63 35.54,91.63 35.82,91.91 v1(35.82,92.06)
  IN3 w0.114: v3(79.22,107.71) 79.51,107.43 79.67,107.43 79.81,107.57 79.81,108.62 78.19,110.24 78.02,110.24 77.78,110.48 77.78,110.65 77.16,111.27 76.85,111.27 76.72,111.14 76.38,111.14 76.25,111.27 75.91,111.27 75.78,111.14 75.44,111.14 75.31,111.27 74.97,111.27 74.84,111.14 74.5,111.14 74.37,111.27 74.03,111.27 73.9,111.14 73.56,111.14 73.43,111.27 73.09,111.27 72.96,111.14 72.62,111.14 72.49,111.27 71.6,111.27 71.45,111.42 70.08,111.42 69.95,111.29 69.61,111.29 69.48,111.42 69.14,111.42 69.01,111.29 68.67,111.29 68.54,111.42 68.2,111.42 68.07,111.29 67.73,111.29 67.6,111.42 63.73,111.42 62.69,112.46 58.92,112.46 58.26,111.8 54.74,111.8 54.73,111.79 54.72,111.79 53.1,110.18 53.1,110.16 53.02,110.07 53.02,108.75 46.42,102.16 46.42,99.7 44.15,97.42 40.16,97.42 35.29,92.55 35.29,91.86 35.49,91.66 35.59,91.66 35.82,91.89 v1(35.82,92.06)
  BOTTOM w0.076: v3(79.22,107.71) 79.22,107.59 79.84,106.97 79.84,106.22 80.14,105.92 80.14,105.27 79.99,105.12 79.99,104.86 80.05,104.74 80.05,104.59 79.99,104.4 79.99,104.23 80.07,103.97 UC1.C52
DDR3_DRAMRST#: length 177.1
  TOP w0.114: v3(66.15,26.96) 66.22,26.89 CD59.1 66.2,25.92 RD21.2 ; v3(58.86,41.98) 65.07,41.98 v5(67.41,44.31) 67.75,44.31 CD60.1
  IN1 w0.076: 114.23,72.48 114.05,72.65 114.05,72.89 112.76,74.18 110.66,74.18 110.22,74.63 110.22,78.34 106.65,81.9 105.33,81.9 104.54,82.69 104.05,82.69 102.07,84.67 101.83,84.67 101.61,84.9 101.61,85.37 v3(101.99,85.75)
  IN1 w0.14: v3(62.69,24.88) 63.46,24.88 66.27,22.06 79.58,22.06 83.17,25.64 113.39,25.64 116.59,28.85 116.59,36.47 121.24,41.11 122.29,41.11 126.18,45.01 126.18,47.88 125.24,48.82 125.24,55.52 118.69,62.07 118.69,63.68 119.31,64.31 119.31,66.26 118.8,66.77 118.8,68.87 117.82,69.85 117.82,70.49 117.49,70.82 117.26,71.06 115.65,71.06 114.23,72.48
  BOTTOM w0.076: v3(101.99,85.75) 102.34,86.1 UC1.AT13
  BOTTOM w0.114: JDIMM2.30 68.62,43.14 67.44,44.31 v5(67.41,44.31) ; JDIMM1.30 68.62,27.45 68.13,26.96 v3(66.15,26.96) 66.02,26.96 63.94,24.88 v3(62.69,24.88) 62.24,24.88 59.56,27.56 59.56,34.73 58.86,35.43 v3(58.86,41.98)
DDR_A_BS0: length 63.8
  IN3 w0.076: 82.48,72.17 82.73,72.42 82.73,78.39 82.73,80.6 82.03,81.29 82.03,81.92 80.05,83.9 v3(80.05,85.12)
  IN3 w0.165: v5(93.55,34.76) 93.86,34.76 93.98,34.89 93.98,35.96 93.66,36.29 93.66,36.44 93.98,36.77 93.98,40.91 93.71,41.19 93.71,43.07 94.16,43.52 94.16,46.06 93.71,46.52 93.71,46.98 94.16,47.44 94.16,48 93.86,48.3 93.86,48.53 94.16,48.83 94.16,49.57 92.34,51.4 92.34,54.02 81.36,64.99 81.36,65.29 81.64,65.57 81.64,65.95 81.36,66.23 81.36,66.6 81.64,66.87 81.64,67.34 81.36,67.62 81.36,67.99 81.64,68.27 81.64,68.74 81.36,69.02 81.36,69.39 81.64,69.67 81.64,70.14 81.36,70.42 81.36,71.05 82.48,72.17
  BOTTOM w0.076: UC1.AU52 v3(80.05,85.12)
  BOTTOM w0.178: v5(93.55,34.76) 94.44,34.76 94.72,35.04 JDIMM1.109
DDR_A_BS1: length 66.1
  IN3 w0.076: v3(81.88,85.75) 81.45,85.33 81.45,83.86 82.62,82.7 83.11,82.7 83.72,82.09 83.72,79.87 83.64,79.78 83.64,71.71 83.46,71.53
  IN3 w0.165: 83.46,71.53 83,71.08 83,65.24 94.28,53.96 94.28,51.35 95.5,50.14 95.5,45.62 96.25,44.87 96.25,43.22 96.04,43.02 95.54,43.02 95.04,42.52 95.04,41.74 95.32,41.46 95.32,33.61 94.96,33.26 94.96,32.26 95.32,31.91 95.32,31.29 v5(94.52,30.49)
  BOTTOM w0.076: UC1.AT48 v3(81.88,85.75)
  BOTTOM w0.178: v5(94.52,30.49) 94.42,30.39 94.42,28.95 JDIMM1.108
DDR_A_BS2: length 63.6
  IN3 w0.076: 76.71,73.98 76.26,73.52 76,73.52 75.85,73.67
  IN3 w0.084: 76.71,73.98 76.71,76.87 76.87,77.03 76.87,77.2 v3(76.19,77.88)
  IN3 w0.165: 75.85,73.67 75.62,73.67 73.5,71.56 73.5,71.35 73.89,70.96 73.89,70.68 73.5,70.29 73.5,60.4 81.48,52.43 81.48,50.85 81.72,50.61 81.72,50.43 81.48,50.19 81.48,49.96 81.59,49.85 82.02,49.85 82.14,49.73 82.14,43.27 83.41,42 83.41,39.18 85.17,37.43 85.17,33.87 v5(84.89,33.59)
  BOTTOM w0.076: 76.85,78.54 76.85,78.78 77.6,79.53 77.6,79.69 78.87,80.96 78.87,81.91 78.66,82.11 78.66,82.48 78.68,82.51 78.71,82.59 78.71,82.71 78.64,82.93 78.64,83.07 78.7,83.23 78.7,83.41 78.62,83.57 78.33,83.86 UC1.AY55
  BOTTOM w0.102: 76.85,78.54 v3(76.19,77.88)
  BOTTOM w0.178: JDIMM1.79 85.72,34.42 v5(84.89,33.59)
DDR_A_CAS#: length 65.3
  IN3 w0.076: v3(81.88,85.12) 81.88,84.52 81.64,84.28 81.64,83.96 82.57,83.02 83.35,83.02 84.22,82.15 84.22,78.89 84.61,78.5 84.61,74.56 83.99,73.95 83.99,71.55 83.93,71.5
  IN3 w0.165: v5(96.22,33.69) 95.76,34.16 95.76,41.65 95.48,41.92 95.48,42.33 95.73,42.57 96.36,42.57 96.84,43.05 96.84,43.58 96.69,43.73 96.69,44.3 96.84,44.45 96.84,44.93 96.55,45.23 96.55,45.49 96.84,45.79 96.84,48.26 95.94,49.16 95.94,50.33 95.29,50.99 95.29,52.89 94.73,53.45 94.73,54.24 83.46,65.51 83.46,71.02 83.93,71.5
  BOTTOM w0.076: UC1.AU48 v3(81.88,85.12)
  BOTTOM w0.178: v5(96.22,33.69) 96.32,33.69 96.78,34.15 96.78,35.32 96.52,35.58 JDIMM1.115
DDR_A_D0: length 83.8
  IN3 w0.114: v5(60.52,34.99) 60.09,35.43 59.92,35.43 59.61,35.11 59.34,35.11 59.15,35.3 59.15,35.57 59.73,36.14 59.73,36.36 59.62,36.47 58.82,36.47 58.72,36.37 58.72,36.08 58.47,35.83 58.24,35.83 58.07,35.99 58.07,36.39 57.99,36.47 57.6,36.47 54.27,39.81 54.13,39.81 53.81,39.49 53.66,39.49 53.34,39.8 53.34,39.94 53.68,40.27 53.68,40.4 53.35,40.73 53.22,40.73 52.88,40.39 52.75,40.39 52.41,40.73 52.41,40.84 52.66,41.09 52.66,42.3 52.59,42.38 52.07,42.38 51.95,42.49 51.95,42.91 52.07,43.02 52.57,43.02 52.66,43.11 52.66,43.59 52.58,43.67 52.06,43.67 51.94,43.79 51.94,44.21 52.05,44.32 52.57,44.32 52.66,44.42 52.66,44.86 52.55,44.97 52.05,44.97 51.94,45.07 51.94,53.35 53.3,54.71 53.3,59.13 53.16,59.28 53.16,85.58 56.68,89.1 63.3,89.1 v3(64.01,88.38)
  BOTTOM w0.076: UC1.AL71 68.7,89.16 68.68,89.14 67.76,89.14 67.58,88.97 67.06,88.97 66.02,87.92 64.47,87.92 v3(64.01,88.38)
  BOTTOM w0.114: JDIMM1.5 61.12,35.58 60.53,34.99 v5(60.52,34.99)
DDR_A_D1: length 84.6
  IN3 w0.114: v3(60.77,88.4) 60.41,88.76 56.8,88.76 53.49,85.44 53.49,59.41 53.63,59.27 53.63,54.57 52.27,53.21 52.27,46.88 52.39,46.77 52.55,46.77 52.79,46.53 52.79,46.24 52.68,46.12 52.39,46.12 52.27,46.01 52.27,45.59 52.39,45.47 52.89,45.47 53,45.36 53,41.57 57.75,36.82 61.01,36.82 61.62,36.21 61.62,35.9 61.37,35.65 61.37,35.34 61.62,35.09 61.62,34.86 v5(60.46,33.69)
  BOTTOM w0.076: v3(60.77,88.4) 61.99,87.17 64.36,87.17 64.6,87.42 66.38,87.42 66.98,88.02 68.45,88.02 68.69,88.26 69.2,88.26 69.23,88.25 69.31,88.22 69.43,88.22 69.65,88.28 69.79,88.28 69.95,88.23 70.13,88.23 70.29,88.3 70.8,88.3 71.01,88.51 UC1.AL68
  BOTTOM w0.114: v5(60.46,33.69) 61.58,34.82 61.58,36.09 61.72,36.23 JDIMM1.7
DDR_A_D2: length 85.2
  IN3 w0.114: v3(66.27,86.55) 65.53,87.3 57.7,87.3 54.96,84.56 54.96,62.19 55.44,61.71 55.44,61.02 55.33,60.91 55.16,60.91 55.05,60.8 55.05,60.38 55.16,60.26 55.33,60.26 55.44,60.15 55.44,59.36 55.33,59.24 55.2,59.24 55.09,59.13 55.09,58.71 55.2,58.6 55.33,58.6 55.44,58.48 55.44,58.06 55.33,57.95 55.2,57.95 55.09,57.83 55.09,57.41 55.2,57.3 55.33,57.3 55.44,57.19 55.44,56.77 55.33,56.65 55.2,56.65 55.09,56.54 55.09,56.12 55.2,56.01 55.33,56.01 55.44,55.89 55.44,55.47 55.33,55.36 55.2,55.36 55.09,55.24 55.09,54.82 55.2,54.71 55.33,54.71 55.44,54.6 55.44,54.32 53.73,52.6 53.73,52.35 53.84,52.23 54.33,52.23 54.44,52.12 54.44,51.7 54.33,51.59 53.84,51.59 53.73,51.47 53.73,50.22 53.84,50.12 54.33,50.12 54.44,50.01 54.44,49.57 54.34,49.47 53.85,49.47 53.74,49.35 53.74,48.93 53.85,48.82 54.34,48.82 54.45,48.71 54.45,48.29 54.34,48.17 53.85,48.17 53.74,48.06 53.74,47.64 53.85,47.52 54.34,47.52 54.45,47.41 54.45,42.78 54.63,42.59 55.14,42.59 55.44,42.3 55.44,42.13 55.07,41.77 55.07,41.61 57.35,39.33 57.5,39.33 57.88,39.71 58.15,39.71 58.34,39.52 58.34,39.25 57.98,38.89 57.98,38.7 58.4,38.28 60.41,38.28 60.58,38.44 61.43,38.44 63.84,36.03 63.84,35.35 63.61,35.12 v5(63.4,35.12)
  BOTTOM w0.076: v3(66.27,86.55) 66.53,86.55 67.34,87.36 68.72,87.36 68.76,87.4 69.7,87.4 69.93,87.64 70.43,87.64 UC1.AN68
  BOTTOM w0.114: JDIMM1.15 64.12,35.83 v5(63.4,35.12)
DDR_A_D3: length 84.4
  IN3 w0.114: v5(65.33,35.02) 64.83,35.52 64.83,36.44 61.09,40.18 59.12,40.18 55.44,43.86 55.44,52.91 56.43,53.91 56.43,62.53 56.32,62.65 56.08,62.65 55.96,62.76 55.96,63.18 56.08,63.3 56.32,63.3 56.43,63.41 56.43,63.83 56.32,63.94 56.08,63.94 55.96,64.06 55.96,64.48 56.08,64.59 56.32,64.59 56.43,64.71 56.43,65.13 56.32,65.24 56.08,65.24 55.96,65.35 55.96,65.77 56.08,65.89 56.32,65.89 56.43,66 56.43,66.42 56.32,66.54 56.08,66.54 55.96,66.65 55.96,67.07 56.08,67.18 56.32,67.18 56.43,67.3 56.43,67.72 56.32,67.83 56.08,67.83 55.96,67.94 55.96,68.36 56.08,68.48 56.32,68.48 56.43,68.59 56.43,76.89 56.55,77.01 56.77,77.01 56.97,77.2 56.97,77.56 56.88,77.65 56.55,77.65 56.43,77.77 56.43,78.19 56.55,78.3 58.06,78.3 58.31,78.55 58.31,78.8 58.16,78.95 56.55,78.95 56.43,79.06 56.43,79.48 56.55,79.6 57.5,79.6 57.6,79.7 57.6,80.12 57.48,80.24 56.14,80.24 55.95,80.43 55.95,84.02 58.24,86.31 62.63,86.31 63.08,85.86 v3(63.08,85.51)
  BOTTOM w0.076: UC1.AN69 70.25,88.03 70,88.03 69.78,88.11 69.65,88.11 69.42,88.04 69.32,88.04 69.31,88.04 69.16,88.1 68.76,88.1 68.52,87.85 67.08,87.85 66.46,87.24 64.71,87.24 64.38,86.91 64.04,86.91 63.08,85.95 v3(63.08,85.51)
  BOTTOM w0.114: JDIMM1.17 64.72,35.63 v5(65.33,35.02)
DDR_A_D4: length 84.4
  IN3 w0.114: v3(65.94,88.4) 64.58,89.76 56.4,89.76 52.46,85.81 52.46,59.05 52.64,58.86 52.64,54.98 51.28,53.62 51.28,40.59 55.18,36.69 56.3,36.69 56.55,36.44 56.55,36.25 56.26,35.96 56.26,35.8 56.56,35.5 56.72,35.5 57.09,35.87 57.25,35.87 57.54,35.57 57.54,35.41 57.19,35.06 57.19,34.91 57.49,34.62 57.67,34.62 58,34.95 58.16,34.95 59.44,33.67 59.44,31.76 v5(60.25,30.95)
  BOTTOM w0.076: UC1.AL70 69.56,89.16 69.38,89.33 69.26,89.39 69.14,89.43 68.64,89.43 68.52,89.3 67.67,89.3 67.48,89.12 66.66,89.12 v3(65.94,88.4)
  BOTTOM w0.114: JDIMM1.4 60.82,30.38 v5(60.25,30.95)
DDR_A_D5: length 85.1
  IN3 w0.114: v5(60.3,32.22) 59.77,32.75 59.77,33.82 55.51,38.09 55.35,38.09 54.95,37.69 54.68,37.69 54.49,37.88 54.49,38.15 54.82,38.48 54.82,38.75 54.63,38.94 54.36,38.94 53.94,38.52 53.83,38.52 51.61,40.74 51.61,41.15 51.75,41.29 52.21,41.29 52.33,41.4 52.33,41.82 52.21,41.94 51.73,41.94 51.61,42.06 51.61,53.48 52.97,54.84 52.97,59 52.79,59.18 52.79,85.67 56.54,89.43 64.26,89.43 v3(65.29,88.4)
  BOTTOM w0.076: UC1.AL69 70.15,89.16 69.89,89.43 69.72,89.43 69.53,89.5 69.53,89.5 69.4,89.54 69.32,89.55 69.25,89.57 69.19,89.58 69.12,89.61 68.59,89.61 68.45,89.47 67.6,89.47 67.4,89.27 66.16,89.27 v3(65.29,88.4)
  BOTTOM w0.114: JDIMM1.6 61.42,31.1 v5(60.3,32.22)
DDR_A_D6: length 83.3
  IN3 w0.114: v3(65.62,86.55) 65.2,86.97 57.84,86.97 55.29,84.42 55.29,62.34 55.77,61.86 55.77,54.18 54.78,53.19 54.78,43.54 55.94,42.38 55.94,42.11 55.57,41.74 55.57,41.58 55.86,41.28 56.02,41.28 56.41,41.67 56.68,41.67 56.87,41.48 56.87,41.21 56.48,40.82 56.48,40.66 57.01,40.14 58.22,40.14 58.74,39.61 58.74,38.73 58.85,38.61 59.27,38.61 59.39,38.73 59.39,39.4 59.5,39.52 60.82,39.52 64.17,36.17 64.17,34.53 63.98,34.35 63.56,34.35 63.45,34.24 63.45,33.82 63.57,33.7 64.03,33.7 64.17,33.56 64.17,33.26 63.28,32.36 63.28,31.54 v1(63.84,30.98)
  BOTTOM w0.076: UC1.AN70 69.44,87.57 68.7,87.57 68.66,87.52 67.26,87.52 66.67,86.93 66.01,86.93 v3(65.62,86.55)
  BOTTOM w0.114: v1(63.84,30.98) 64.42,30.39 JDIMM1.16
DDR_A_D7: length 82.7
  IN3 w0.114: v3(64.25,86.5) 64.1,86.64 57.98,86.64 55.62,84.29 55.62,80.1 55.71,80.01 55.89,80.01 56.1,79.8 56.1,79.45 56.02,79.36 55.71,79.36 55.63,79.28 55.63,78.8 55.72,78.72 56.02,78.72 56.1,78.63 56.1,78.15 56.02,78.07 55.71,78.07 55.63,77.99 55.63,77.52 55.72,77.42 56.02,77.42 56.1,77.34 56.1,76.86 56.01,76.77 55.72,76.77 55.63,76.68 55.63,76.2 55.7,76.13 56.01,76.13 56.1,76.04 56.1,75.56 56.02,75.48 55.71,75.48 55.63,75.4 55.63,74.92 55.72,74.83 56.03,74.83 56.1,74.75 56.1,74.28 56.01,74.18 55.72,74.18 55.63,74.09 55.63,73.65 55.74,73.54 55.99,73.54 56.1,73.42 56.1,73 55.99,72.89 55.74,72.89 55.63,72.77 55.63,72.35 55.74,72.24 55.99,72.24 56.1,72.13 56.1,71.71 55.99,71.59 55.74,71.59 55.63,71.48 55.63,71.06 55.74,70.94 55.99,70.94 56.1,70.83 56.1,70.41 55.99,70.3 55.74,70.3 55.63,70.18 55.63,69.76 55.89,69.5 55.89,69.15 55.62,68.88 55.62,62.48 56.1,62 56.1,54.04 55.11,53.05 55.11,43.71 58.98,39.85 60.96,39.85 64.5,36.3 64.5,32.9 v5(63.86,32.26)
  BOTTOM w0.076: UC1.AN71 68.73,87.83 68.59,87.69 67.17,87.69 66.57,87.09 64.83,87.09 v3(64.25,86.5)
  BOTTOM w0.114: v5(63.86,32.26) 65.02,31.1 JDIMM1.18
DDR_A_D8: length 73
  IN3 w0.114: v5(65.13,38.75) 64.7,39.18 63.44,39.18 61.49,41.13 60.7,41.13 59.06,42.77 58.9,42.77 58.66,42.54 58.5,42.54 58.21,42.83 58.21,43 58.44,43.23 58.44,43.39 58.14,43.69 57.98,43.69 57.79,43.5 57.63,43.5 57.33,43.79 57.33,43.96 57.52,44.15 57.52,44.31 57.22,44.61 57.06,44.61 56.91,44.46 56.75,44.46 56.47,44.74 56.47,44.93 56.61,45.07 56.61,45.23 56.39,45.44 56.39,49.83 56.53,49.96 57.11,49.96 57.39,50.24 57.39,50.5 57.27,50.61 56.5,50.61 56.39,50.71 56.39,51.13 56.52,51.26 57.27,51.26 57.39,51.37 57.39,51.79 57.27,51.91 56.51,51.91 56.39,52.02 56.39,52.44 56.51,52.56 57.27,52.56 57.39,52.67 57.39,73.98 57.48,74.07 57.83,74.07 58.02,74.26 58.02,74.53 57.83,74.72 57.47,74.72 57.39,74.81 57.39,75.24 57.51,75.37 58.43,75.37 58.55,75.48 58.55,75.9 58.43,76.01 57.58,76.01 57.46,76.14 57.46,76.34 57.78,76.66 58.43,76.66 58.56,76.79 58.56,77.44 59.59,78.48 61.23,78.48 63.02,80.26 63.02,83.51 64.46,84.95 64.81,84.95 65.1,85.24 v3(65.1,85.45)
  BOTTOM w0.076: UC1.AR70 69.56,86.8 69.29,87.07 68.9,87.07 68.86,87.03 67.62,87.03 66.61,86.01 65.66,86.01 v3(65.1,85.45)
  BOTTOM w0.114: JDIMM1.21 65.92,38.27 65.44,38.75 v5(65.13,38.75)
DDR_A_D9: length 74.3
  IN3 w0.114: v5(65.31,33.75) 65.79,34.23 65.79,36.36 65.24,36.91 65.24,37.07 65.67,37.49 65.67,37.76 65.48,37.95 65.21,37.95 64.79,37.53 64.62,37.53 61.35,40.8 59.39,40.8 56.06,44.12 56.06,52.66 57.06,53.65 57.06,76.4 59.46,78.81 61.1,78.81 62.69,80.39 62.69,83.69 v3(64.45,85.45)
  BOTTOM w0.076: v3(64.45,85.45) 65.17,86.18 66.5,86.18 67.52,87.19 68.79,87.19 68.83,87.24 69.7,87.24 69.93,87 70.48,87 UC1.AR68
  BOTTOM w0.114: JDIMM1.23 66.52,34.96 v5(65.31,33.75)
DDR_A_D10: length 71.5
  IN3 w0.114: v3(66.55,83.76) 66.97,83.34 66.97,82.65 66.84,82.52 66.84,82.29 66.97,82.15 66.97,81.86 66.71,81.6 66.08,81.6 65.93,81.45 65.93,78.14 65.82,78.04 65.67,78.04 65.06,78.65 64.9,78.65 64.61,78.35 64.61,78.18 65.31,77.48 65.31,77.31 65.02,77.02 64.85,77.02 64.3,77.57 64.13,77.57 63.96,77.39 63.96,77 64.4,76.56 64.4,76.4 63.65,75.65 63.49,75.65 62.78,76.36 62.61,76.36 62.31,76.07 62.31,75.92 62.87,75.35 63.03,75.19 63.03,75.03 62.73,74.74 62.57,74.74 61.97,75.34 61.82,75.34 61.67,75.19 61.67,74.72 62.11,74.28 62.11,74.12 60.54,72.54 60.54,54.57 61.38,53.73 61.38,53.56 61.27,53.45 60.8,53.45 60.69,53.33 60.69,52.9 60.79,52.8 61.27,52.8 61.38,52.68 61.38,52.26 61.27,52.15 60.79,52.15 60.69,52.05 60.69,51.6 60.79,51.5 61.27,51.5 61.38,51.39 61.38,50.97 61.27,50.85 60.8,50.85 60.69,50.74 60.69,50.3 60.78,50.21 61.29,50.21 61.38,50.11 61.38,48.67 61.82,48.23 62.16,48.23 62.29,48.1 62.29,47.62 62.2,47.52 62.05,47.52 61.97,47.44 61.97,46.96 62.05,46.88 62.21,46.88 62.29,46.8 62.29,46.3 62.22,46.23 62.05,46.23 61.97,46.15 61.97,45.7 62.08,45.58 62.51,45.58 62.59,45.5 62.59,44.17 62.78,43.98 63.05,43.98 63.24,44.17 63.24,44.52 63.36,44.63 64.36,44.63 64.53,44.46 64.53,43.05 68.35,39.23 v5(68.79,39.23)
  BOTTOM w0.076: v3(66.55,83.76) 66.99,84.19 67.24,84.19 68.42,85.37 68.95,85.37 UC1.AU71
  BOTTOM w0.114: JDIMM1.33 69.52,38.5 v5(68.79,39.23)
DDR_A_D11: length 73.3
  IN3 w0.076: 65.57,82.08 65.57,82.16 v3(65.26,82.46)
  IN3 w0.114: 65.57,82.08 65.57,81.86 65.49,81.79 65.34,81.79 65.26,81.71 65.26,81.23 65.34,81.14 65.52,81.14 65.6,81.06 65.6,80.58 65.52,80.49 65.34,80.49 65.26,80.41 65.26,79.93 65.34,79.85 65.52,79.85 65.6,79.76 65.6,79.08 65.51,78.98 64.75,78.98 61.34,75.57 61.34,74.57 61.64,74.28 61.64,74.11 60.21,72.68 60.21,50.3 60.63,49.87 60.94,49.87 61.05,49.76 61.05,48.53 61.63,47.96 61.63,45.56 61.94,45.25 62.14,45.25 62.26,45.13 62.26,43.36 62.98,42.64 63.15,42.64 63.57,43.06 64.11,43.06 64.21,42.95 64.21,42.77 63.6,42.15 63.6,42.01 63.91,41.69 64.06,41.69 64.65,42.28 64.81,42.28 65.1,41.99 65.1,41.83 64.86,41.58 64.86,41.44 64.97,41.34 65.75,41.34 68.21,38.88 68.21,37.34 68.41,37.15 69.17,37.15 69.37,36.95 69.37,35.22 69.12,34.96 v5(68.94,34.96)
  BOTTOM w0.076: v3(65.26,82.46) 64.83,82.89 64.83,84.29 65.61,85.08 67.41,85.08 67.78,85.45 67.78,86.22 68.1,86.53 68.67,86.53 68.83,86.37 69.2,86.37 69.23,86.39 69.31,86.42 69.43,86.42 69.65,86.35 69.79,86.35 69.95,86.41 70.54,86.41 70.56,86.43 70.8,86.43 71.01,86.23 UC1.AU68
  BOTTOM w0.114: JDIMM1.35 70.12,36.14 v5(68.94,34.96)
DDR_A_D12: length 72
  IN3 w0.114: v3(65.75,85.45) 65.75,84.96 65.42,84.63 64.63,84.63 63.42,83.42 63.42,80.2 61.37,78.14 59.73,78.14 58.9,77.31 58.9,75.09 58.79,74.99 58.54,74.99 58.35,74.8 58.35,74.53 58.54,74.34 58.78,74.34 58.88,74.25 58.88,73.95 58.62,73.69 58.62,73.69 57.72,72.79 57.72,50.1 56.72,49.11 56.72,45.58 60.84,41.46 61.63,41.46 63.56,39.53 65.04,39.53 66.12,38.44 66.12,31.72 v5(65.63,31.23)
  BOTTOM w0.076: UC1.AR71 69,86.86 67.72,86.86 66.71,85.85 66.14,85.85 v3(65.75,85.45)
  BOTTOM w0.114: v5(65.63,31.23) 65.74,31.23 66.22,30.75 JDIMM1.22
DDR_A_D13: length 73.1
  IN3 w0.114: v5(67.39,31.28) 66.63,32.03 66.63,38.39 66.45,38.57 66.45,38.58 65.17,39.87 63.69,39.87 61.76,41.79 61,41.79 57.05,45.73 57.05,48.97 58.72,50.64 58.72,61.72 58.05,62.4 58.05,72.65 59.23,73.83 59.23,77.18 59.87,77.81 61.51,77.81 63.8,80.11 63.8,83.31 64.79,84.29 66.27,84.29 67.06,85.08 v3(67.06,85.51)
  BOTTOM w0.076: UC1.AR69 70.25,86.6 70,86.6 69.78,86.53 69.65,86.53 69.42,86.59 69.32,86.59 69.31,86.6 69.3,86.59 69.28,86.59 69.16,86.54 68.9,86.54 68.74,86.7 68,86.7 67.57,86.27 67.57,85.92 67.16,85.51 v3(67.06,85.51)
  BOTTOM w0.114: JDIMM1.24 66.82,30.79 67.31,31.28 v5(67.39,31.28)
DDR_A_D14: length 72
  IN3 w0.114: v5(69.22,31.31) 69.7,31.79 70.43,31.79 70.56,31.92 70.56,32.34 70.46,32.44 69.82,32.44 69.7,32.55 69.7,37.56 69.27,37.99 69.27,39.37 68.97,39.67 68.46,39.67 64.92,43.21 64.92,44.54 64.49,44.97 63.38,44.97 63,45.35 63,46.15 62.63,46.52 62.63,48.24 62.3,48.57 61.96,48.57 61.71,48.81 61.71,49.32 62.29,49.9 62.29,51.05 62.18,51.16 61.99,51.16 61.8,51.35 61.8,51.62 61.99,51.81 63.44,51.81 63.55,51.91 63.55,52.16 63.26,52.46 61.83,52.46 61.71,52.57 61.71,52.99 61.83,53.1 62.13,53.1 62.26,53.23 62.26,53.46 60.87,54.85 60.87,72.4 66.26,77.8 66.26,80.57 67.33,81.64 67.33,83.62 v3(67.19,83.76)
  BOTTOM w0.076: v3(67.19,83.76) 67.19,83.86 68.53,85.2 69.43,85.2 UC1.AU70
  BOTTOM w0.114: v5(69.22,31.31) 69.32,31.31 69.82,30.81 JDIMM1.34
