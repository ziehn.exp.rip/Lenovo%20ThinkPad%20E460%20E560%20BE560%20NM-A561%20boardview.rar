# Allegro board Lenovo ThinkPad E460 E560 BE560 NM-A561 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D15: length 72.3
  IN3 w0.114: v3(67.82,83.78) 67.82,81.62 66.59,80.39 66.59,77.66 61.24,72.31 61.24,54.97 63.94,52.27 63.94,51.46 63.82,51.35 62.74,51.35 62.64,51.25 62.64,50.83 62.77,50.7 63.54,50.7 63.73,50.51 63.73,50.24 63.54,50.05 62.74,50.05 62.64,49.95 62.64,49.53 62.77,49.4 63.82,49.4 63.94,49.29 63.94,48.87 63.82,48.76 63.61,48.76 63.49,48.64 63.49,48.22 63.6,48.11 63.85,48.11 63.94,48.02 63.94,47.56 63.83,47.46 63.61,47.46 63.51,47.36 63.51,46.9 63.6,46.81 63.82,46.81 63.94,46.7 63.94,46.17 64.43,45.67 64.58,45.67 64.95,46.05 65.13,46.05 65.3,45.87 65.3,45.48 64.99,45.17 64.99,44.94 65.26,44.68 65.26,43.34 68.6,40 69.11,40 69.6,39.51 69.6,38.14 70.03,37.71 70.03,33.64 71,32.68 v5(71,31.38)
  BOTTOM w0.076: UC1.AU69 70.15,85.48 69.7,85.03 68.61,85.03 67.82,84.24 v3(67.82,83.78)
  BOTTOM w0.114: JDIMM1.36 70.42,30.09 70.42,30.8 v5(71,31.38)
DDR_A_D16: length 65.1
  IN3 w0.076: 66.47,75.72 67.23,76.49 67.23,77.9 v3(67.61,78.28)
  IN3 w0.114: 66.47,75.72 62.54,71.8 62.54,55.52 65.49,52.57 65.49,51.69 65.72,51.45 66.59,51.45 66.7,51.34 66.7,50.92 66.59,50.8 66.19,50.8 66,50.62 66,50.35 66.19,50.16 66.75,50.16 66.94,49.97 66.94,49.7 66.75,49.51 66.32,49.51 66.2,49.4 66.2,47.17 66.88,46.49 66.88,43.57 69.18,41.28 69.64,41.28 71.57,39.35 71.57,34.7 v5(72.42,33.85)
  BOTTOM w0.076: 67.69,78.36 68.06,78.72 68.06,79.1 68.35,79.39 68.35,80.23 68.7,80.59 71.58,80.59 72.71,81.72 72.71,82.23 UC1.BB65
  BOTTOM w0.089: 67.69,78.36 v3(67.61,78.28)
  BOTTOM w0.114: v5(72.42,33.85) 71.32,34.95 JDIMM1.39
DDR_A_D17: length 67
  IN3 w0.114: v3(67.61,75.03) 66.24,75.03 62.88,71.67 62.88,55.67 67.44,51.11 67.44,50.35 67.56,50.23 67.7,50.23 67.81,50.12 67.81,49.7 67.7,49.58 67.33,49.58 67.14,49.39 67.14,49.13 67.33,48.94 67.7,48.94 67.81,48.82 67.81,48.4 67.7,48.29 67.36,48.29 67.21,48.15 67.21,47.16 67.44,46.93 67.44,46.39 67.6,46.24 67.85,46.24 67.98,46.11 67.98,45.65 67.86,45.54 67.52,45.54 67.41,45.43 67.41,45.01 67.52,44.89 67.86,44.89 67.98,44.78 67.98,43.17 69.54,41.61 69.78,41.61 71.91,39.48 71.91,39.36 72.08,39.19 72.08,38.72 71.91,38.54 71.91,38.07 72.08,37.89 72.08,37.42 71.91,37.24 71.91,36.77 72.08,36.6 72.08,36.12 71.91,35.95 71.91,35.28 72.04,35.14 v5(72.47,35.14)
  BOTTOM w0.076: 67.69,75.1 69,76.42 69,79.72 69.33,80.04 72.33,80.04 73.89,81.6 73.89,81.93 73.71,82.11 73.71,82.48 73.75,82.59 73.75,82.71 73.69,82.93 73.69,83.07 73.74,83.23 73.74,83.41 73.67,83.57 73.67,84.08 73.46,84.29 UC1.AW65
  BOTTOM w0.089: 67.69,75.1 v3(67.61,75.03)
  BOTTOM w0.114: JDIMM1.41 71.92,35.7 v5(72.47,35.14)
DDR_A_D18: length 67.7
  IN3 w0.076: v3(69.46,76.24) 69.2,75.98 69.2,74.69 68.21,73.7 67.89,73.7 67.74,73.55
  IN3 w0.114: v5(76.16,33.72) 75.7,33.72 75.58,33.84 75.58,35.5 75.58,36.05 74.21,37.42 74.21,40.16 71.76,42.6 71.76,44.61 71.65,44.73 71.21,44.73 71.1,44.84 71.1,45.26 71.21,45.37 71.65,45.37 71.76,45.49 71.76,45.82 70.9,46.68 70.9,49.47 71.06,49.64 71.68,49.64 71.9,49.86 71.9,50.09 71.7,50.28 70.49,50.28 70.26,50.51 70.26,51.27 68.78,52.76 68.78,53.21 68.25,53.74 67.82,53.74 64.99,56.58 64.99,70.8 67.74,73.55
  BOTTOM w0.076: UC1.AW63 74.04,84.07 74.35,83.76 74.35,83.21 74.57,82.99 74.57,81.35 72.61,79.38 71.35,79.38 70.23,78.27 70.23,77.02 v3(69.46,76.24)
  BOTTOM w0.114: v5(76.16,33.72) 74.92,34.96 JDIMM1.51
DDR_A_D19: length 66.8
  IN3 w0.076: v3(69.46,79.58) 69.96,79.08 69.96,75.18 68.33,73.55
  IN3 w0.114: v5(76.1,35.04) 76.52,35.04 76.67,35.19 76.67,36.07 74.58,38.17 74.58,40.25 73.16,41.67 73.16,41.77 73.24,41.85 73.24,42.04 72.96,42.32 72.79,42.32 72.7,42.22 72.61,42.22 72.09,42.74 72.09,45.65 72.39,45.95 72.39,46.1 72.32,46.18 71.96,46.18 71.83,46.3 71.83,46.72 71.94,46.82 72.3,46.82 72.39,46.92 72.39,47.39 72.31,47.47 71.94,47.47 71.83,47.59 71.83,48.04 71.9,48.12 72.3,48.12 72.39,48.21 72.39,48.69 72.32,48.77 71.94,48.77 71.85,48.86 71.85,49.34 71.92,49.42 72.31,49.42 72.4,49.51 72.4,50.05 71.52,50.94 71.36,50.94 71.08,50.67 70.77,50.67 70.62,50.81 70.62,51.12 70.9,51.4 70.9,51.56 70.29,52.17 69.84,52.17 69.3,52.7 69.3,53.16 68.38,54.08 67.96,54.08 65.32,56.72 65.32,70.54 68.33,73.55
  BOTTOM w0.076: v3(69.46,79.58) 70.78,79.58 71.08,79.88 72.4,79.88 74.05,81.53 74.05,82 73.87,82.18 73.87,82.44 73.93,82.56 73.93,82.7 73.86,82.93 73.86,83.06 73.94,83.28 73.94,83.54 UC1.AY63
  BOTTOM w0.114: v5(76.1,35.04) 75.52,35.63 JDIMM1.53
DDR_A_D20: length 66.1
  IN3 w0.076: v3(67.61,78.93) 67.06,78.38 67.06,76.78 66.47,76.19
  IN3 w0.114: v5(72.8,32.35) 71.16,33.99 71.16,39.29 69.5,40.95 68.99,40.95 66.55,43.39 66.55,46.17 64.91,47.82 64.91,49.57 65.02,49.68 65.35,49.68 65.46,49.8 65.46,50.22 65.35,50.33 65.02,50.33 64.91,50.44 64.91,52.68 62.21,55.38 62.21,71.93 66.47,76.19
  BOTTOM w0.076: v3(67.61,78.93) 68.18,79.5 68.18,80.3 68.63,80.75 71.46,80.75 72.55,81.84 72.55,82.44 72.66,82.69 72.67,82.69 72.67,82.7 72.81,82.84 UC1.BA65
  BOTTOM w0.114: v5(72.8,32.35) 71.62,31.17 JDIMM1.40
DDR_A_D21: length 66.5
  IN3 w0.076: 66.47,76.66 66.88,77.07 66.88,78.85 v3(67.61,79.58)
  IN3 w0.114: v5(72.93,31.03) 72.22,31.03 71.98,31.27 71.98,32.61 70.66,33.93 70.66,38.02 70.22,38.45 70.22,39.76 69.37,40.62 68.86,40.62 66.22,43.26 66.22,46.03 64.58,47.68 64.58,52.54 61.87,55.25 61.87,72.06 66.47,76.66
  BOTTOM w0.076: v3(67.61,79.58) 68,79.97 68,80.38 68.54,80.92 71.37,80.92 72.38,81.92 72.38,82.48 72.49,82.71 72.49,82.75 72.55,82.88 72.55,83.17 72.81,83.43 UC1.AY65
  BOTTOM w0.114: JDIMM1.42 72.22,30.4 72.84,31.03 v5(72.93,31.03)
DDR_A_D22: length 66.4
  IN3 w0.076: 67.47,73.74 67.6,73.88 68.08,73.88 68.87,74.67 68.87,77.03 v3(69.46,77.63)
  IN3 w0.114: v5(75.8,32.4) 75.11,32.4 74.96,32.55 74.96,32.95 75.25,33.23 75.25,35.91 74.54,36.62 74.15,36.62 73.88,36.89 73.88,40.02 71.43,42.47 71.43,43.83 70.75,44.51 70.75,46.34 69.93,47.16 69.93,49.01 70.05,49.13 70.45,49.13 70.56,49.24 70.56,49.69 70.47,49.77 70.11,49.77 69.93,49.95 69.93,51.14 68.39,52.68 68.39,53.11 68.1,53.4 67.68,53.4 64.66,56.42 64.66,70.93 67.47,73.74
  BOTTOM w0.076: UC1.BA63 74.14,82.77 74.4,82.51 74.4,81.42 72.54,79.55 71.24,79.55 70.02,78.33 70.02,78.19 v3(69.46,77.63)
  BOTTOM w0.114: v5(75.8,32.4) 74.62,31.22 JDIMM1.50
DDR_A_D23: length 65.3
  IN3 w0.076: 67.19,73.93 67.33,74.07 67.91,74.07 68.61,74.77 68.61,77.43 v3(69.46,78.28)
  IN3 w0.114: v5(75.76,31.06) 74.63,32.19 74.63,33.09 74.92,33.37 74.92,35.77 74.4,36.29 74.01,36.29 73.55,36.75 73.55,39.88 70.42,43.01 70.42,44.48 70.31,44.59 69.94,44.59 69.82,44.71 69.82,45.13 69.94,45.24 70.31,45.24 70.42,45.36 70.42,45.78 70.31,45.89 69.94,45.89 69.82,46 69.82,46.35 69.6,46.57 69.6,51 64.33,56.28 64.33,71.07 67.19,73.93
  BOTTOM w0.076: v3(69.46,78.28) 70.11,78.93 70.36,78.93 71.14,79.71 72.47,79.71 74.22,81.46 74.22,82.26 UC1.BB63
  BOTTOM w0.114: JDIMM1.52 75.22,30.53 v5(75.76,31.06)
DDR_A_D24: length 65.6
  IN3 w0.076: v1(71.59,77.69) 70.76,76.86 70.76,75.25 69.28,73.77 69.28,73.55
  IN3 w0.114: 69.28,73.55 69.28,73.15 66.27,70.14 66.27,57.14 67.56,55.84 67.9,55.84 68.15,56.1 68.48,56.1 74.2,50.38 74.2,49.49 74.07,49.37 73.51,49.37 73.36,49.21 73.36,47.08 73.46,46.98 74.09,46.98 74.2,46.86 74.2,46.44 74.09,46.33 73.53,46.33 73.41,46.22 73.41,45.59 73.56,45.44 73.56,44.87 73.41,44.71 73.41,43.26 74.2,42.47 74.2,41.98 75.54,40.64 75.54,38.6 78.21,35.93 78.21,33.95 78.11,33.85 v3(77.73,33.85)
  BOTTOM w0.076: UC1.BA61 75.17,82.76 74.9,82.5 74.9,81.21 72.62,78.93 72.18,78.93 71.98,78.73 71.98,78.08 v1(71.59,77.69)
  BOTTOM w0.114: JDIMM1.57 76.72,34.86 v3(77.73,33.85)
DDR_A_D25: length 66.9
  IN3 w0.076: v3(71.59,78.99) 70.49,77.89 70.49,75.34 68.95,73.81 68.95,73.55
  IN3 w0.114: 68.95,73.55 68.95,73.29 65.94,70.28 65.94,56.99 67.52,55.41 67.94,55.41 68.16,55.64 68.46,55.64 68.84,55.26 68.84,55.1 68.62,54.88 68.62,54.72 68.92,54.42 69.08,54.42 69.3,54.64 69.46,54.64 69.76,54.34 69.76,54.18 69.54,53.96 69.54,53.8 69.84,53.5 70,53.5 70.22,53.72 70.38,53.72 70.67,53.42 70.67,53.26 70.46,53.04 70.46,52.88 70.75,52.59 70.91,52.59 71.13,52.8 71.29,52.8 71.59,52.51 71.59,52.35 71.37,52.13 71.37,51.97 71.67,51.67 71.83,51.67 72.05,51.89 72.21,51.89 72.51,51.59 72.51,51.43 72.29,51.21 72.29,51.05 72.59,50.75 72.75,50.75 72.97,50.97 73.13,50.97 73.87,50.23 73.87,49.85 73.74,49.72 73.15,49.72 73.03,49.6 73.03,46.74 73.08,46.69 73.08,45.43 73.23,45.28 73.23,45 73.08,44.85 73.08,43.12 73.87,42.33 73.87,41.84 75.21,40.5 75.21,38.45 77.3,36.36 77.3,35.32 77.48,35.14 v3(77.73,35.14)
  BOTTOM w0.076: UC1.AW61 75.27,84.1 74.94,83.78 74.94,83.23 74.74,83.02 74.74,81.28 72.58,79.12 71.72,79.12 v3(71.59,78.99)
  BOTTOM w0.114: JDIMM1.59 77.32,36.08 77.22,35.98 77.22,35.65 v3(77.73,35.14)
DDR_A_D26: length 65.6
  IN3 w0.114: v3(73.52,75.93) 73.23,76.21 73.08,76.21 72.95,76.09 72.95,75.15 72.7,74.89 72.7,73.8 72.45,73.55 72.31,73.55 71.76,74.1 71.6,74.1 71.3,73.8 71.3,73.64 71.86,73.08 71.86,72.94 71.71,72.79 71.28,72.79 71.2,72.71 71.2,71.55 71.04,71.39 70.89,71.39 70.69,71.58 70.53,71.58 70.24,71.28 70.24,71.12 70.39,70.97 70.39,70.82 68.82,69.25 68.82,59.27 71.02,57.06 71.71,57.06 76.71,52.06 76.71,49.61 77.3,49.02 77.3,43.96 77.93,43.32 77.93,42.38 78.97,41.34 78.97,40.4 79.14,40.23 79.57,40.23 79.81,39.99 79.81,39.69 79.71,39.58 79.53,39.58 79.43,39.49 79.43,39.03 79.52,38.94 79.75,38.94 79.84,38.85 79.84,37.74 81.22,36.36 81.22,34 81.04,33.82 v3(80.7,33.82)
  BOTTOM w0.076: v3(73.52,75.93) 74.44,76.85 74.44,78.82 76.35,80.73 76.35,81.28 76.59,81.53 76.59,82.23 UC1.BB59
  BOTTOM w0.114: v3(80.7,33.82) 79.72,34.8 JDIMM1.67
DDR_A_D27: length 67.9
  IN3 w0.076: 69.88,71.06 69.88,71.29 70.92,72.33 70.92,73.75 72.68,75.5 72.68,76.39 73.51,77.23
  IN3 w0.114: v3(80.74,35.14) 80.45,35.14 80.32,35.27 80.32,35.98 80.65,36.31 80.65,36.46 79.51,37.61 79.51,38.47 79.1,38.88 79.1,39.46 78.98,39.59 78.05,39.59 77.93,39.7 77.93,40.12 78.05,40.23 78.53,40.23 78.64,40.35 78.64,41.19 78.53,41.3 78.37,41.3 78.17,41.11 78.01,41.11 77.71,41.41 77.71,41.57 77.91,41.76 77.91,41.92 77.61,42.22 77.45,42.22 77.28,42.05 77.15,42.05 76.82,42.37 76.82,42.51 77.45,43.14 77.45,43.32 76.97,43.8 76.97,45.38 76.89,45.46 76.42,45.46 76.33,45.55 76.33,45.99 76.45,46.11 76.86,46.11 76.97,46.22 76.97,46.93 76.88,47.02 76.5,47.02 76.38,47.13 76.38,47.55 76.5,47.66 76.84,47.66 76.97,47.79 76.97,48.88 76.38,49.47 76.38,51.91 75.86,52.43 75.7,52.43 75.53,52.26 75.37,52.26 75.07,52.56 75.07,52.72 75.24,52.89 75.24,53.05 74.95,53.34 74.78,53.34 74.62,53.18 74.45,53.18 74.16,53.47 74.16,53.63 74.33,53.8 74.33,53.96 71.56,56.73 70.87,56.73 68.49,59.11 68.49,69.39 69.88,70.78 69.88,71.06 ; 73.51,77.23 v3(73.52,77.23)
  BOTTOM w0.076: UC1.AW59 75.84,84.29 75.64,84.08 75.64,83.57 75.56,83.47 75.56,83.22 75.61,83.09 75.61,82.87 75.6,82.85 75.6,82.85 75.6,82.85 75.56,82.76 75.56,82.56 75.6,82.47 75.6,82.11 75.4,81.91 75.4,81 73.13,78.73 73.13,77.62 v3(73.52,77.23)
  BOTTOM w0.114: JDIMM1.69 80.32,37.15 80.32,36.11 80.19,35.98 80.19,35.69 v3(80.74,35.14)
DDR_A_D28: length 65.3
  IN3 w0.076: v3(71.59,77.01) 70.97,76.39 70.97,75.09 69.61,73.74 69.61,73.55
  IN3 w0.114: 69.61,73.55 69.61,73.02 66.71,70.11 66.71,58.36 66.83,58.23 66.83,58.07 66.6,57.85 66.6,57.39 66.73,57.27 66.94,57.27 67.29,57.61 67.45,57.61 67.75,57.32 67.75,57.16 67.34,56.75 67.34,56.59 67.63,56.29 67.79,56.29 68.2,56.7 68.37,56.7 74.53,50.54 74.53,42.12 75.87,40.78 75.87,38.74 78.54,36.06 78.54,33.76 77.68,32.9 v5(77.68,32.5)
  BOTTOM w0.076: UC1.BB61 75.07,82.23 75.07,81.14 72.69,78.76 72.45,78.76 72.16,78.47 72.16,77.59 v3(71.59,77.01)
  BOTTOM w0.114: JDIMM1.56 76.42,31.29 77.63,32.5 v5(77.68,32.5)
DDR_A_D29: length 66.6
  IN3 w0.076: v3(71.59,75.66) 71.59,75.41 69.88,73.7 69.88,73.49
  IN3 w0.114: 69.88,73.49 69.88,72.82 67.04,69.97 67.04,58.51 74.88,50.67 74.88,42.24 76.2,40.91 76.2,38.87 78.87,36.2 78.87,33.57 78.39,33.09 78.39,31.54 78.92,31 78.92,30.43 78.78,30.29 78.37,30.29 78.28,30.38 78.28,30.65 v5(77.7,31.23)
  BOTTOM w0.076: UC1.AY61 75.37,83.54 75.37,83.27 75.43,83.09 75.43,82.88 75.4,82.79 75.4,82.54 75.4,82.53 75.43,82.44 75.43,82.18 75.23,81.98 75.23,81.07 72.76,78.6 72.57,78.6 72.34,78.37 72.34,76.4 v3(71.59,75.66)
  BOTTOM w0.114: v5(77.7,31.23) 77.68,31.23 77.02,30.57 JDIMM1.58
DDR_A_D30: length 66.5
  IN3 w0.076: 70.29,70.25 70.29,70.25 71.48,71.44 71.48,72.25 73.11,73.88 73.11,74.87 v3(73.52,75.28)
  IN3 w0.114: v5(81.27,32.4) 80.5,32.4 80.37,32.53 80.37,33.11 80.52,33.26 81.41,33.26 81.55,33.4 81.55,36.5 80.18,37.87 80.18,40.12 79.9,40.4 79.9,40.92 78.26,42.56 78.26,43.47 77.65,44.08 77.65,49.13 77.04,49.74 77.04,52.21 71.75,57.5 71.59,57.5 71.49,57.4 71.33,57.4 71.03,57.69 71.03,57.85 71.13,57.96 71.13,58.12 70.84,58.42 70.68,58.42 70.5,58.24 70.33,58.24 70.04,58.53 70.04,58.69 70.22,58.88 70.22,59.04 69.92,59.33 69.76,59.33 69.63,59.2 69.47,59.2 69.17,59.5 69.17,59.66 69.3,59.79 69.3,59.95 69.15,60.1 69.15,69.11 70.29,70.25
  BOTTOM w0.076: UC1.BA59 76.7,82.58 76.76,82.43 76.76,81.46 76.52,81.22 76.52,80.64 74.63,78.76 74.63,76.39 v3(73.52,75.28)
  BOTTOM w0.114: JDIMM1.68 80.02,30.29 80.33,30.6 80.33,30.76 80.53,30.97 80.53,31.66 v5(81.27,32.4)
DDR_A_D31: length 67.3
  IN3 w0.076: 70.62,70.17 71.68,71.24 71.68,72.1 73.25,73.67 73.25,73.73 v3(73.52,73.99)
  IN3 w0.114: v5(81.25,31.11) 82.29,30.07 82.57,30.07 82.8,30.29 82.8,30.59 81.88,31.51 81.88,36.63 80.51,38.01 80.51,40.3 80.23,40.58 80.23,41.07 78.59,42.71 78.59,43.63 78,44.22 78,49.25 77.37,49.88 77.37,50.19 77.49,50.3 77.77,50.3 77.88,50.42 77.88,50.84 77.77,50.95 77.49,50.95 77.37,51.07 77.37,52.36 69.48,60.25 69.48,68.98 70.62,70.11 70.62,70.17
  BOTTOM w0.076: UC1.AY59 76.49,83.43 76.76,83.17 76.76,82.97 76.89,82.54 76.92,82.47 76.92,81.39 76.68,81.15 76.68,80.56 74.83,78.71 74.83,75.3 73.57,74.05
  BOTTOM w0.089: 73.57,74.05 v3(73.52,73.99)
  BOTTOM w0.114: JDIMM1.70 80.62,30.49 81.24,31.11 v5(81.25,31.11)
DDR_A_D32: length 66.7
  IN3 w0.114: v5(101.91,38.7) 102.72,39.51 102.72,40.07 102.43,40.36 102.43,40.97 104.78,43.31 104.78,45.96 104.22,46.52 104.22,46.85 104.33,46.96 105,46.96 105.11,47.07 105.11,47.49 105,47.61 104.39,47.61 104.27,47.72 104.27,48.14 104.39,48.26 105,48.26 105.11,48.37 105.11,48.79 105,48.9 104.62,48.9 104.5,49.02 104.5,49.44 104.62,49.55 105.2,49.55 105.39,49.74 105.39,50.01 105.2,50.2 104.33,50.2 104.22,50.31 104.22,50.73 104.33,50.85 104.75,50.85 104.86,50.96 104.86,51.38 104.75,51.49 104.33,51.49 104.22,51.61 104.22,52.19 104.33,52.31 104.67,52.31 104.86,52.5 104.86,52.77 104.67,52.96 104.33,52.96 104.22,53.07 104.22,54.42 102.74,55.89 100.22,55.89 88.56,67.55 88.56,70.89 88.25,71.21 v3(88.25,73.78)
  BOTTOM w0.076: v3(88.25,73.78) 87.54,74.49 87.54,75.25 87.04,75.75 87.04,78.37 87.04,80.15 87.31,80.43 87.31,81.02 87.16,81.17 87.16,82.02 87.1,82.08 87.1,82.48 87.17,82.61 87.17,82.63 87.27,82.88 87.27,83.17 87.54,83.43 UC1.AY39
  BOTTOM w0.114: v5(101.91,38.7) 101.43,39.18 101.43,39.66 101.17,39.92 100.79,39.92 100.54,39.66 100.54,38.72 100.72,38.54 JDIMM1.129
DDR_A_D33: length 65
  IN3 w0.076: v3(88.25,79.74) 87.3,78.79 87.3,70.99 87.57,70.72 87.57,70.58
  IN3 w0.114: v5(100.13,35.02) 99.68,35.47 99.68,37.64 100.77,38.72 100.77,40.88 102.8,42.91 102.8,45.7 102.94,45.84 102.94,49.58 103.23,49.87 103.23,53.49 101.84,54.88 99.83,54.88 87.57,67.14 87.57,70.58
  BOTTOM w0.076: UC1.AW39 88.19,84.29 88.45,84.02 88.45,83.45 88.47,83.41 88.47,83.23 88.41,83.07 88.41,82.93 88.48,82.71 88.48,82.59 88.43,82.48 88.43,82.1 88.63,81.9 88.63,80.13 v3(88.25,79.74)
  BOTTOM w0.114: JDIMM1.131 101.32,34.4 100.92,34 100.54,34 100.13,34.41 v5(100.13,35.02)
DDR_A_D34: length 66.6
  IN3 w0.076: 90,70.92 90,71.11 89.13,71.98 89.13,75.62 89.38,75.87 89.38,78.24 89.3,78.32 89.01,78.32 88.83,78.5 88.83,78.75 89.01,78.93 89.3,78.93 89.38,79 89.38,79.78 89.29,79.87 89.03,79.87 v3(88.25,79.09)
  IN3 w0.114: v5(103.46,34.81) 102.7,35.57 102.7,36 102.81,36.11 103.07,36.11 103.26,36.3 103.26,36.57 103.07,36.76 102.81,36.76 102.7,36.88 102.7,37.41 104.34,39.05 104.34,40.7 106.87,43.23 106.87,53.86 103.36,57.37 100.81,57.37 90,68.18 90,70.92
  BOTTOM w0.076: UC1.AY37 88.66,83.54 88.66,83.28 88.59,83.06 88.59,82.93 88.65,82.7 88.65,82.56 88.6,82.44 88.6,82.17 88.8,81.97 88.8,79.64 v3(88.25,79.09)
  BOTTOM w0.114: JDIMM1.141 104.32,35.73 103.66,35.07 103.66,35.01 v5(103.46,34.81)
DDR_A_D35: length 67.4
  IN3 w0.076: 90.33,70.89 90.33,71.13 89.39,72.07 89.39,75.21 v3(90.02,75.84)
  IN3 w0.114: v5(103.45,33.43) 103.99,33.98 103.99,37.86 104.67,38.53 104.67,40.56 107.2,43.1 107.2,49.34 107.31,49.46 107.69,49.46 107.8,49.57 107.8,49.99 107.69,50.1 107.31,50.1 107.2,50.22 107.2,54 103.49,57.7 100.95,57.7 90.33,68.32 90.33,70.89
  BOTTOM w0.076: v3(90.02,75.84) 89.29,76.57 89.29,81.97 89.29,81.97 89.29,82.99 89.07,83.21 89.07,83.76 88.76,84.07 UC1.AW37
  BOTTOM w0.114: JDIMM1.143 104.92,36.07 104.68,35.84 104.68,35.63 104.3,35.24 104.3,34.18 103.54,33.43 v5(103.45,33.43)
DDR_A_D36: length 65.3
  IN3 w0.076: 87.9,70.65 87.9,70.79 87.53,71.16 87.53,75.13 v3(88.25,75.84)
  IN3 w0.114: 87.9,70.65 87.9,67.28 99.97,55.21 102.49,55.21 103.56,54.14 103.56,49.73 103.27,49.44 103.27,46.46 103.82,45.91 103.82,43.46 101.1,40.74 101.1,38.52 100.57,38 100.57,34.14 100.46,34.03 100.25,34.03 100.13,33.91 100.13,33.49 100.25,33.38 100.46,33.38 100.57,33.26 100.57,32.84 100.46,32.73 100.25,32.73 100.13,32.62 100.13,31.51 v5(100.44,31.21)
  BOTTOM w0.076: UC1.BB39 87.5,82.3 87.5,81.3 87.64,81.16 87.64,80.29 87.39,80.04 87.39,76.69 v3(88.25,75.84)
  BOTTOM w0.114: JDIMM1.130 101.02,28.95 101.02,30.62 v5(100.44,31.21)
DDR_A_D37: length 65.8
  IN3 w0.076: 88.23,70.64 88.23,70.87 87.82,71.28 87.82,74.77 v3(88.25,75.19)
  IN3 w0.114: 88.23,70.64 88.23,67.41 100.11,55.54 102.63,55.54 103.89,54.28 103.89,49.6 103.6,49.31 103.6,46.6 104.2,46 104.2,43.2 102.1,41.1 102.1,40.21 101.43,39.54 101.43,38.39 100.9,37.86 100.9,33.3 101.02,33.19 101.21,33.19 101.33,33.07 101.33,31.74 102.06,31.01 v5(102.1,31.01)
  BOTTOM w0.076: UC1.BA39 87.54,82.84 87.4,82.7 87.39,82.69 87.39,82.69 87.27,82.44 87.27,82.15 87.33,82.09 87.33,81.24 87.48,81.09 87.48,80.36 87.21,80.08 87.21,76.23 v3(88.25,75.19)
  BOTTOM w0.114: v5(102.1,31.01) 101.84,31.01 101.62,30.79 101.62,28.95 JDIMM1.132
DDR_A_D38: length 66.4
  IN3 w0.076: v3(90.02,74.41) 89.59,73.98 89.59,72.2 90.67,71.13 90.67,70.88
  IN3 w0.114: v5(103.42,31.12) 103.44,31.12 104.32,32 104.32,37.72 105,38.39 105,40.43 107.56,42.99 107.56,45.88 108.42,46.74 108.42,50.05 107.55,50.92 107.55,54.11 103.63,58.03 101.09,58.03 90.67,68.45 90.67,70.88
  BOTTOM w0.076: UC1.BA37 88.86,82.77 89.13,82.51 89.13,82.04 89.13,82.04 89.13,75.31 v3(90.02,74.41)
  BOTTOM w0.114: v5(103.42,31.12) 103.47,31.12 104.02,30.57 104.02,28.95 JDIMM1.140
DDR_A_D39: length 65.5
  IN3 w0.076: v3(90.02,73.7) 90.4,73.32 90.4,71.72 91.01,71.12 91.01,70.88
  IN3 w0.114: 91.01,70.88 91.01,68.58 101.22,58.36 103.77,58.36 107.88,54.25 107.88,53.02 108.75,52.16 108.75,46.6 107.89,45.75 107.89,42.86 105.33,40.29 105.33,38.25 104.65,37.58 104.65,31.54 104.96,31.23 v5(105.26,31.23)
  BOTTOM w0.076: UC1.BB37 88.86,82.14 88.96,82.04 88.96,74.76 v3(90.02,73.7)
  BOTTOM w0.114: v5(105.26,31.23) 105.24,31.23 104.62,30.61 104.62,28.95 JDIMM1.142
DDR_A_D40: length 68.7
  IN3 w0.076: 91.96,70.86 91.96,71.03 90.76,72.23 90.76,77.92 90.68,77.99 90.23,77.99 v3(90.02,77.79)
  IN3 w0.114: v5(105.52,33.36) 106.19,33.36 106.31,33.48 106.31,36.03 105.64,36.69 105.64,37.22 106.31,37.89 106.31,38.91 109.7,42.3 109.7,53.8 104.19,59.32 101.62,59.32 91.96,68.97 91.96,70.86
  BOTTOM w0.076: v3(90.02,77.79) 90.58,78.35 90.58,79.99 89.95,80.62 89.95,81.66 90.16,81.87 90.16,82.44 90.12,82.53 90.12,82.54 90.12,82.79 90.16,82.88 90.16,83.09 90.13,83.17 90.09,83.27 90.09,83.54 UC1.AY35
  BOTTOM w0.114: JDIMM1.147 106.12,35.5 105.87,35.24 105.24,35.24 105.01,35.02 105.01,33.87 v5(105.52,33.36)
DDR_A_D41: length 69.3
  IN3 w0.076: v3(90.02,76.49) 90.2,76.67 90.45,76.67 90.59,76.53 90.59,76.42 90.4,76.24 90.4,76.09 90.6,75.89 90.6,75.63 90.4,75.43 90.4,75.15 90.6,74.95 90.6,74.74 90.46,74.59 90.46,74.28 90.6,74.14 90.6,72 91.63,70.98 91.63,70.81
  IN3 w0.114: 91.63,70.81 91.63,68.84 101.48,58.99 104.05,58.99 109.37,53.66 109.37,46.35 109.01,45.98 109.01,45.46 109.37,45.1 109.37,42.44 109.22,42.29 109.06,42.29 108.74,42.62 108.58,42.62 108.28,42.32 108.28,42.16 108.6,41.84 108.6,41.67 108.31,41.38 108.15,41.38 107.82,41.7 107.66,41.7 107.36,41.41 107.36,41.25 107.53,41.08 107.53,40.6 107.08,40.15 106.91,40.15 106.6,40.46 106.44,40.46 106.14,40.16 106.14,40 106.46,39.69 106.46,39.53 105.95,39.02 105.95,38 105.29,37.34 105.29,36.58 105.97,35.9 105.97,35.22 v5(105.52,34.76)
  BOTTOM w0.076: v3(90.02,76.49) 89.46,77.06 89.46,81.9 89.46,81.9 89.46,83.02 89.67,83.23 89.67,83.78 89.99,84.1 UC1.AW35
  BOTTOM w0.114: v5(105.52,34.76) 106.15,34.76 106.72,35.33 JDIMM1.149
DDR_A_D42: length 69
  IN3 w0.076: v3(91.8,73.89) 92.21,73.48 92.21,72.98 94.48,70.72 94.48,70.55
  IN3 w0.114: 94.48,70.55 94.48,69.89 102.61,61.76 105.18,61.76 112.32,54.62 112.32,51.92 112.82,51.42 112.82,49.62 113.21,49.22 113.21,42.31 111.11,40.21 111.11,38.32 110.73,37.94 110.46,37.94 110.21,38.19 109.94,38.19 109.75,38 109.75,37.73 110,37.48 110,37.21 109.79,37 109.79,34.44 108.87,33.52 v5(108.59,33.52)
  BOTTOM w0.076: UC1.AY33 91.22,83.43 91.49,83.16 91.49,82.82 91.54,82.71 91.61,82.57 91.65,82.48 91.65,82.11 91.52,81.99 91.47,81.93 91.47,81.57 91.63,81.42 91.63,78.52 92.2,77.96 92.2,77.95 92.31,77.83 92.31,74.4 v3(91.8,73.89)
  BOTTOM w0.114: v5(108.59,33.52) 108.08,34.03 108.08,35.09 108.31,35.32 108.82,35.32 109.12,35.62 JDIMM1.157
DDR_A_D43: length 67.9
  IN3 w0.076: 94.15,70.48 94.15,70.66 91.8,73.01 v3(91.8,73.24)
  IN3 w0.114: v5(108.54,34.84) 109,34.84 109.28,35.12 109.28,36.03 108.99,36.31 108.71,36.31 108.54,36.48 108.54,36.9 108.65,37.01 109.35,37.01 109.46,37.13 109.46,37.4 109.12,37.73 109.12,38.06 110.78,39.72 110.78,40.34 112.88,42.44 112.88,49.09 112.49,49.48 112.49,51.28 111.99,51.78 111.99,54.49 105.05,61.43 102.48,61.43 94.15,69.76 94.15,70.48
  BOTTOM w0.076: UC1.AW33 90.57,84.29 90.36,84.08 90.36,83.57 90.29,83.47 90.29,83.22 90.33,83.09 90.33,82.87 90.33,82.85 90.32,82.85 90.32,82.85 90.29,82.76 90.29,82.56 90.32,82.47 90.32,81.8 90.12,81.6 90.12,80.69 90.75,80.06 90.75,77.58 90.62,77.45 90.62,74.42 v3(91.8,73.24)
  BOTTOM w0.114: JDIMM1.159 109.72,35.69 108.87,34.84 v5(108.54,34.84)
DDR_A_D44: length 67.5
  IN3 w0.076: 92.29,70.83 92.29,71.05 90.91,72.43 90.91,78.83 90.73,79.01 90.59,79.01 v3(90.02,78.44)
  IN3 w0.114: 92.29,70.83 92.29,69.11 101.75,59.65 104.32,59.65 110.03,53.94 110.03,51.86 110.03,51.86 110.03,46.94 110.15,46.82 110.46,46.82 110.65,46.63 110.65,46.37 110.46,46.18 110.15,46.18 110.03,46.06 110.03,42.17 106.66,38.8 106.66,32.78 v5(106.09,32.21)
  BOTTOM w0.076: v3(90.02,78.44) 90.42,78.84 90.42,79.92 89.79,80.55 89.79,81.77 89.79,81.77 89.79,82.23 UC1.BB35
  BOTTOM w0.114: v5(106.09,32.21) 105.9,32.02 105.9,29.03 JDIMM1.146
DDR_A_D45: length 68
  IN3 w0.076: 92.62,70.82 92.62,70.99 91.06,72.55 91.06,79.57 90.89,79.74 v3(90.02,79.74)
  IN3 w0.114: 92.62,70.82 92.62,69.25 101.88,59.99 104.45,59.99 110.37,54.07 110.37,50.94 110.51,50.8 110.76,50.8 110.95,50.61 110.95,50.34 110.76,50.15 110.48,50.15 110.37,50.04 110.37,49.62 110.48,49.5 110.93,49.5 111.05,49.39 111.05,42.65 107.07,38.67 107.07,31.51 v5(106.51,30.95)
  BOTTOM w0.076: v3(90.02,79.74) 89.62,80.14 89.62,81.83 89.62,82.5 89.89,82.76 UC1.BA35
  BOTTOM w0.114: JDIMM1.148 106.42,30.86 v5(106.51,30.95)
DDR_A_D46: length 68.4
  IN3 w0.076: v3(91.8,77.79) 92.41,77.79 92.79,77.41 92.79,73.07 95.21,70.65 95.21,70.49
  IN3 w0.114: v5(110.57,32.45) 109.96,32.45 109.63,32.78 109.63,33.34 110.46,34.17 110.46,36.68 111.77,37.99 111.77,39.93 113.87,42.03 113.87,49.5 113.48,49.89 113.48,51.69 112.98,52.19 112.98,54.9 105.46,62.42 102.91,62.42 95.21,70.13 95.21,70.49
  BOTTOM w0.076: v3(91.8,77.79) 91.45,78.15 91.45,81.37 91.31,81.51 91.31,82 91.48,82.18 91.48,82.44 91.37,82.69 91.36,82.69 91.36,82.7 91.22,82.84 UC1.BA33
  BOTTOM w0.114: JDIMM1.158 109.42,31.3 v5(110.57,32.45)
DDR_A_D47: length 67
  IN3 w0.076: v3(91.8,77.14) 92.3,77.14 92.44,77 92.44,73.12 94.82,70.73 94.82,70.57
  IN3 w0.114: v5(110.62,31.1) 109.3,32.42 109.3,33.48 110.12,34.3 110.12,36.85 111.44,38.17 111.44,40.07 113.54,42.17 113.54,49.36 113.15,49.75 113.15,51.56 112.65,52.06 112.65,54.76 105.32,62.09 102.77,62.09 94.82,70.04 94.82,70.57
  BOTTOM w0.076: UC1.BB33 91.22,82.2 91.14,82.13 91.14,81.45 91.28,81.31 91.28,77.66 v3(91.8,77.14)
  BOTTOM w0.114: JDIMM1.160 110.02,28.95 110.02,30.5 v5(110.62,31.1)
DDR_A_D48: length 73.2
  IN3 w0.076: v3(93.68,73.91) 93.68,73.22
  IN3 w0.084: 96.91,70.32 96.73,70.5 96.4,70.5 93.68,73.22
  IN3 w0.114: 96.91,70.32 103.5,63.73 105.99,63.73 114.26,55.46 114.26,54.56 115.59,53.24 115.59,52.43 115.79,52.23 116.55,52.23 116.74,52.04 116.74,51.77 116.55,51.58 116.12,51.58 115.93,51.39 115.93,51.12 116.12,50.93 116.88,50.93 117,50.82 117,50.4 116.88,50.28 116.65,50.28 116.53,50.17 116.53,49.75 116.65,49.63 116.88,49.63 117,49.52 117,49.1 116.88,48.99 116.65,48.99 116.53,48.87 116.53,48.45 116.65,48.34 116.88,48.34 117,48.23 117,47.81 116.88,47.69 116.65,47.69 116.53,47.58 116.53,47.16 116.65,47.04 116.88,47.04 117,46.93 117,46.51 116.88,46.4 116.65,46.4 116.53,46.28 116.53,44 116.31,43.78 116.31,43.35 116.53,43.13 116.53,42.88 114.81,41.15 114.81,40.3 114.52,40.01 114.52,39.85 115.01,39.36 115.01,39.2 114.71,38.9 114.55,38.9 114.06,39.39 113.9,39.39 113.32,38.82 113.32,38.49 113.62,38.19 113.62,37.94 113.01,37.33 113.01,36.95 112.79,36.73 112.41,36.73 112.25,36.57 112.25,36.29 112.56,35.98 112.56,35.58 111.72,34.74 v5(111.72,34.56)
  BOTTOM w0.076: v3(93.68,73.91) 92.57,75.01 92.57,80.63 92.26,80.94 92.26,81.06 92.26,81.61 92.26,81.61 92.26,81.94 92.09,82.11 92.09,82.48 92.1,82.51 92.25,82.88 92.25,83.17 92.52,83.43 UC1.AY31
  BOTTOM w0.114: v5(111.72,34.56) 111.41,34.56 110.62,35.35 110.62,36.06 110.92,36.35 JDIMM1.163
DDR_A_D49: length 73.9
  IN3 w0.076: v3(93.68,79.74) 93.08,79.14 93.08,73.22 96.09,70.21 96.09,70.17
  IN3 w0.114: v5(111.08,35.68) 111.08,36.42 112.39,37.74 112.39,38.83 112.95,39.38 112.95,39.54 112.7,39.78 112.7,39.94 113,40.24 113.16,40.24 113.4,40 113.57,40 114.15,40.58 114.15,41.43 114.5,41.78 114.5,42.47 114.61,42.59 115.13,42.59 115.32,42.78 115.32,43.05 115.13,43.24 114.61,43.24 114.5,43.35 114.5,43.77 114.61,43.88 114.88,43.88 114.99,44 114.99,44.42 114.88,44.53 114.61,44.53 114.5,44.65 114.5,45.06 114.61,45.18 114.88,45.18 114.99,45.29 114.99,45.71 114.88,45.83 114.61,45.83 114.5,45.94 114.5,46.36 114.61,46.47 114.88,46.47 114.99,46.59 114.99,47.01 114.88,47.12 114.61,47.12 114.5,47.24 114.5,47.66 114.61,47.77 114.88,47.77 114.99,47.88 114.99,48.3 114.88,48.42 114.61,48.42 114.5,48.53 114.5,49.09 114.61,49.2 115.76,49.2 115.87,49.32 115.87,49.74 115.76,49.85 114.42,49.85 114.23,50.04 114.23,50.31 114.42,50.5 115.01,50.5 115.2,50.69 115.2,50.96 115.01,51.15 114.25,51.15 114.1,51.3 114.1,51.95 113.6,52.45 113.6,52.71 113.79,52.9 114.34,52.9 114.53,53.09 114.53,53.36 114.34,53.55 113.79,53.55 113.6,53.74 113.6,55.18 105.71,63.07 103.19,63.07 96.09,70.17
  BOTTOM w0.076: UC1.AW31 93.17,84.29 93.43,84.03 93.43,83.46 93.45,83.41 93.45,83.23 93.39,83.07 93.39,82.93 93.46,82.71 93.46,82.59 93.43,82.51 93.41,82.48 93.41,81.95 93.71,81.66 93.71,79.77 v3(93.68,79.74)
  BOTTOM w0.114: v5(111.08,35.68) 111.08,35.78 111.52,36.22 JDIMM1.165
DDR_A_D50: length 72.9
  IN3 w0.076: 98.39,71.39 98.26,71.52 96.63,71.52 94.73,73.42 94.73,77.63 94.19,78.17 94.19,78.53 94.73,79.06 94.73,79.31 94.6,79.44 94.03,79.44 v3(93.68,79.09)
  IN3 w0.114: 98.39,71.39 99.51,70.27 99.89,70.27 104.64,65.52 106.75,65.52 116.16,56.11 116.16,55.18 117.2,54.14 117.47,54.14 117.62,54.29 117.89,54.29 118.08,54.1 118.08,53.84 117.92,53.68 117.92,53.41 118.11,53.22 118.38,53.22 118.54,53.38 118.8,53.38 118.99,53.19 118.99,52.92 118.84,52.76 118.84,50.03 119.04,49.83 119.04,46.44 119.6,45.89 119.6,43.97 119.33,43.7 118.93,43.7 118.59,43.36 118.59,42.43 116.78,40.62 116.78,38.43 114.99,36.64 114.99,34.13 v5(115.47,33.64)
  BOTTOM w0.076: UC1.AY29 93.64,83.54 93.64,83.28 93.57,83.06 93.57,82.93 93.63,82.7 93.63,82.56 93.58,82.44 93.58,82.02 93.87,81.73 93.87,80.16 94.08,79.96 94.08,79.48 93.68,79.09 v3(93.68,79.09)
  BOTTOM w0.114: JDIMM1.175 114.52,34.52 115.4,33.64 v5(115.47,33.64)
DDR_A_D51: length 73.3
  IN3 w0.076: v3(95.28,75.84) 94.95,75.84 94.88,75.76 94.88,73.67 96.82,71.73 98.51,71.73 98.68,71.56
  IN3 w0.114: 98.68,71.56 99.57,70.68 99.95,70.68 104.78,65.85 106.88,65.85 116.86,55.87 116.86,55.61 116.73,55.47 116.73,55.2 116.92,55.01 117.18,55.01 117.32,55.15 117.59,55.15 119.69,53.04 119.69,52.8 119.24,52.34 119.24,51.66 119.35,51.55 119.45,51.55 119.64,51.36 119.64,51.09 119.45,50.9 119.35,50.9 119.24,50.79 119.24,50.31 119.35,50.2 119.65,50.2 119.82,50.03 119.82,49.62 119.37,49.18 119.37,46.57 119.93,46.02 119.93,42.86 119.81,42.74 119.55,42.74 119.4,42.89 119.13,42.89 118.94,42.7 118.94,42.43 119.09,42.29 119.09,42.02 118.33,41.26 117.89,41.26 117.11,40.48 117.11,40.24 117.3,40.05 117.62,40.05 117.81,39.86 117.81,39.59 117.62,39.4 117.3,39.4 117.11,39.21 117.11,38.29 116.4,37.59 116.4,37.32 116.71,37.01 116.71,36.74 116.52,36.55 116.26,36.55 115.94,36.86 115.68,36.86 115.53,36.71 115.53,36.35 116.08,35.79 116.08,35.12 115.93,34.96 v5(115.47,34.96)
  BOTTOM w0.076: UC1.AW29 93.74,84.07 94.05,83.76 94.05,83.21 94.28,82.99 94.28,82.04 94.37,81.95 94.37,80.38 94.57,80.18 94.57,76.55 v3(95.28,75.84)
  BOTTOM w0.114: v5(115.47,34.96) 115.02,35.42 115.02,35.95 115.12,36.06 JDIMM1.177
DDR_A_D52: length 71.3
  IN3 w0.076: 96.58,70.17 96.42,70.32 96.2,70.32 93.24,73.28 93.24,75.67 93.41,75.84 v3(93.68,75.84)
  IN3 w0.114: v5(112.39,32.54) 111.5,32.54 110.75,33.29 110.75,33.58 111.08,33.91 111.08,34.81 111.08,34.99 111.61,35.52 111.61,36.49 112.73,37.61 112.73,38.7 114.48,40.44 114.48,41.29 115.96,42.77 115.96,44.64 116.07,44.75 116.09,44.75 116.2,44.87 116.2,45.28 116.09,45.4 116.07,45.4 115.96,45.51 115.96,45.93 116.07,46.05 116.09,46.05 116.2,46.16 116.2,46.58 116.09,46.69 116.07,46.69 115.96,46.81 115.96,47.23 116.07,47.34 116.09,47.34 116.2,47.46 116.2,47.86 115.88,48.18 115.88,48.48 116.2,48.8 116.2,50.19 115.56,50.83 115.56,51.08 115.08,51.56 114.62,51.56 114.43,51.75 114.43,52.09 114.32,52.2 114.32,52.41 114.51,52.59 115.02,52.59 115.22,52.8 115.22,53.14 113.93,54.43 113.93,55.32 105.85,63.4 103.35,63.4 96.58,70.17
  BOTTOM w0.076: UC1.BB31 92.59,82.27 92.59,81.47 92.59,81.12 92.9,80.81 92.9,76.62 v3(93.68,75.84)
  BOTTOM w0.114: JDIMM1.164 111.22,28.95 111.22,31.4 112.37,32.54 v5(112.39,32.54)
DDR_A_D53: length 71.9
  IN3 w0.076: 97.1,70.62 96.96,70.75 96.42,70.75 94.11,73.06 94.11,75.36 94.04,75.44 93.93,75.44 v3(93.68,75.19)
  IN3 w0.114: v5(112.37,31.23) 112.85,31.23 112.96,31.35 112.96,32.83 112.58,33.21 112.15,33.21 111.94,33.01 111.5,33.01 111.31,33.19 111.31,33.67 111.72,34.08 112.05,34.08 112.2,34.23 112.2,34.75 112.89,35.44 112.89,36.24 113.39,36.74 113.39,37.09 115.34,39.04 115.34,41.22 116.87,42.74 116.87,45.81 117.35,46.3 117.35,51.94 114.59,54.7 114.59,55.61 106.14,64.06 103.66,64.06 97.1,70.62
  BOTTOM w0.076: UC1.BA31 92.52,82.84 92.38,82.7 92.37,82.69 92.37,82.69 92.25,82.44 92.25,82.18 92.42,82.01 92.42,81.54 92.42,81.13 92.42,81.12 92.42,81.01 92.74,80.7 92.74,76.13 v3(93.68,75.19)
  BOTTOM w0.114: JDIMM1.166 111.82,28.95 111.82,30.69 v5(112.37,31.23)
DDR_A_D54: length 72.1
  IN3 w0.076: v3(95.28,74.47) 95.79,73.97 95.79,73.36 96.97,72.18 99,72.18 99.24,71.94
  IN3 w0.114: 99.24,71.94 99.86,71.32 100.5,71.32 105.3,66.52 107.15,66.52 120.48,53.19 120.48,49.75 121.15,49.07 121.15,46.2 121.47,45.88 121.47,43.47 119.6,41.59 119.6,40.72 118.52,39.65 118.52,38.37 117.51,37.35 117.51,36.56 116.74,35.8 116.74,33.59 114.36,31.21 v3(113.57,31.21)
  BOTTOM w0.076: v3(95.28,74.47) 94.41,75.35 94.41,80.11 94.2,80.31 94.2,81.86 94.11,81.95 94.11,82.49 93.84,82.76 UC1.BA29
  BOTTOM w0.114: v3(113.57,31.21) 114.22,30.55 114.22,28.95 JDIMM1.174
DDR_A_D55: length 71.2
  IN3 w0.076: v3(95.28,73.81) 95.28,73.65 96.94,71.99 98.73,71.99 98.89,71.83
  IN3 w0.114: v3(113.59,32.48) 115.07,32.48 116.41,33.82 116.41,35.94 117.18,36.7 117.18,37.49 117.62,37.93 117.62,38.81 118.19,39.38 118.19,39.87 118.38,40.06 118.38,40.84 120.44,42.9 120.44,46.31 120,46.75 120,49.19 120.15,49.34 120.15,53.05 107.02,66.18 104.91,66.18 100.11,70.98 99.73,70.98 98.89,71.83
  BOTTOM w0.076: v3(95.28,73.81) 94.24,74.86 94.24,80.04 94.04,80.24 94.04,81.79 93.84,81.99 UC1.BB29
  BOTTOM w0.114: JDIMM1.176 114.82,28.95 114.82,31.25 v3(113.59,32.48)
DDR_A_D56: length 83.5
  IN3 w0.076: 102.13,72.3 101.8,72.63 97.01,72.63 96.61,73.04 96.61,76.86 96.53,76.94 95.87,76.94 95.79,77.01 95.79,77.47 95.87,77.55 96.53,77.55 96.61,77.62 96.61,78.24 96.42,78.42 95.91,78.42 v3(95.28,77.79)
  IN3 w0.114: 102.13,72.3 105.77,68.66 107.28,68.66 111.38,64.56 111.38,64.4 111.1,64.12 111.1,63.95 111.39,63.66 111.56,63.66 111.84,63.94 112,63.94 112.3,63.64 112.3,63.48 112.01,63.2 112.01,63.04 112.31,62.74 112.47,62.74 112.75,63.02 112.92,63.02 116.52,59.42 116.52,59.26 116.23,58.96 116.23,58.8 116.52,58.5 116.69,58.5 116.98,58.8 117.14,58.8 117.45,58.49 117.45,58.33 117.25,58.13 117.25,57.77 117.62,57.41 117.8,57.41 118.09,57.69 118.25,57.69 118.53,57.41 118.53,57.25 118.24,56.95 118.24,56.79 118.53,56.49 118.69,56.49 118.99,56.79 119.15,56.79 119.45,56.49 119.45,56.33 119.15,56.04 119.15,55.87 119.45,55.58 119.61,55.58 119.91,55.87 120.07,55.87 120.36,55.58 120.36,55.41 120.07,55.12 120.07,54.96 120.37,54.66 120.53,54.66 120.82,54.96 120.98,54.96 121.28,54.66 121.28,54.5 120.99,54.2 120.99,54.04 121.28,53.74 121.44,53.74 121.74,54.04 121.9,54.04 122.1,53.84 122.1,53.35 121.43,52.68 121.43,50.14 122.1,49.47 122.1,46.6 122.43,46.28 122.43,42.32 121.87,41.77 121.12,41.77 120.55,41.2 120.55,40.33 119.61,39.39 119.61,37.24 118.32,35.95 118.32,34.59 v5(117.44,33.71)
  BOTTOM w0.076: v3(95.28,77.79) 95.84,78.35 95.84,80.23 95.03,81.04 95.03,82.07 95.14,82.18 95.14,82.44 95.1,82.53 95.1,82.54 95.1,82.79 95.14,82.88 95.14,83.09 95.11,83.17 95.07,83.27 95.07,83.54 UC1.AY27
  BOTTOM w0.114: v5(117.44,33.71) 116.32,34.83 JDIMM1.181
DDR_A_D57: length 84.1
  IN3 w0.076: 99.57,72.38 97.01,72.38 96.35,73.04 96.35,73.91 96.28,73.99 96.15,73.99 96.07,74.06 96.07,74.52 96.15,74.6 96.28,74.6 96.35,74.67 96.35,75.13 96.28,75.21 95.89,75.21 95.81,75.28 95.81,75.74 95.89,75.82 96.28,75.82 96.35,75.89 96.35,76.26 96.12,76.49 v3(95.28,76.49)
  IN3 w0.114: 99.57,72.38 100.35,72.38 100.46,72.26 100.46,71.91 100.57,71.79 100.99,71.79 101.11,71.91 101.11,72.26 101.22,72.38 101.58,72.38 102.29,71.68 102.29,71.52 101.82,71.05 101.82,70.89 102.12,70.6 102.28,70.6 102.74,71.06 102.9,71.06 103.2,70.76 103.2,70.6 102.74,70.14 102.74,69.98 103.04,69.68 103.2,69.68 103.66,70.14 103.82,70.14 104.12,69.85 104.12,69.68 103.66,69.22 103.66,69.06 103.95,68.76 104.11,68.76 104.58,69.23 104.74,69.23 105.43,68.53 105.43,67.41 105.54,67.3 106.04,67.3 106.15,67.41 106.15,68.01 106.25,68.11 106.44,68.11 106.61,67.94 106.77,67.94 107.02,68.2 107.18,68.2 107.48,67.9 107.48,67.74 107.23,67.49 107.23,67.32 107.52,67.03 107.68,67.03 107.94,67.28 108.1,67.28 108.4,66.98 108.4,66.82 108.14,66.57 108.14,66.41 109.39,65.16 109.66,65.16 109.77,65.27 110.03,65.27 110.22,65.08 110.22,64.81 110.11,64.7 110.11,64.44 113.26,61.29 113.42,61.29 113.71,61.58 113.87,61.58 114.17,61.29 114.17,61.13 113.88,60.83 113.88,60.67 114.18,60.37 114.34,60.37 114.63,60.67 114.79,60.67 115.09,60.37 115.09,60.21 114.8,59.92 114.8,59.75 115.09,59.46 115.25,59.46 115.5,59.7 115.66,59.7 115.95,59.4 115.95,59.24 115.71,59 115.71,58.84 121.1,53.45 121.1,50.01 121.77,49.33 121.77,46.46 122.1,46.14 122.1,42.68 121.52,42.1 120.99,42.1 120.22,41.33 120.22,40.47 119.28,39.53 119.28,39.26 119.28,37.38 119.05,37.15 118.89,37.15 118.65,37.39 118.49,37.39 118.19,37.1 118.19,36.93 118.43,36.69 118.43,36.53 117.99,36.09 117.99,35.13 117.87,35.02 v5(117.45,35.02)
  BOTTOM w0.076: UC1.AW27 94.97,84.1 94.65,83.78 94.65,83.23 94.44,83.02 94.44,82.11 94.53,82.02 94.53,80.83 94.86,80.5 94.86,76.92 v3(95.28,76.49)
  BOTTOM w0.114: JDIMM1.183 116.92,35.2 117.1,35.02 v5(117.45,35.02)
DDR_A_D58: length 83.3
  IN3 w0.076: 102.34,72.56 102.1,72.8 97.12,72.8 96.82,73.1 96.82,73.45 v3(97.26,73.89)
  IN3 w0.114: v5(118.78,34.91) 119.37,35.51 119.37,36.54 120.08,37.24 120.8,37.24 120.91,37.36 120.91,37.78 120.8,37.89 120.06,37.89 119.94,38.01 119.94,39.26 121.72,41.03 121.88,41.03 122.94,39.97 123.1,39.97 123.4,40.27 123.4,40.43 122.39,41.44 122.39,41.62 122.68,41.91 122.84,41.91 123.65,41.1 123.92,41.1 124.11,41.29 124.11,41.55 122.76,42.91 122.76,45.02 122.93,45.19 123.39,45.19 123.58,45.38 123.58,45.65 123.39,45.84 123,45.84 122.82,46.03 122.82,46.3 123,46.49 123.3,46.49 123.42,46.6 123.42,47.02 123.3,47.14 123.18,47.14 123.07,47.25 123.07,47.67 123.18,47.78 123.3,47.78 123.42,47.9 123.42,48.32 123.3,48.43 123.18,48.43 123.07,48.55 123.07,48.96 123.18,49.08 123.3,49.08 123.42,49.19 123.42,49.48 123.3,49.6 122.55,49.6 122.43,49.71 122.43,50.13 122.55,50.25 123.3,50.25 123.42,50.36 123.42,50.78 123.3,50.89 122.55,50.89 122.43,51.01 122.43,51.43 122.55,51.54 123.3,51.54 123.42,51.65 123.42,52.07 123.3,52.19 122.55,52.19 122.43,52.3 122.43,52.72 122.55,52.84 122.87,52.84 123.06,53.03 123.06,53.35 107.41,68.99 105.9,68.99 102.34,72.56
  BOTTOM w0.076: UC1.AY25 96.2,83.43 96.47,83.16 96.47,82.82 96.52,82.71 96.64,82.46 96.64,80.93 96.85,80.72 96.85,78.98 97.23,78.6 97.23,78.39 97.66,77.96 97.66,74.28 v3(97.26,73.89)
  BOTTOM w0.114: JDIMM1.191 119.32,35.46 v5(118.78,34.91)
DDR_A_D59: length 83.8
  IN3 w0.114: v3(97.26,73.24) 102.12,73.24 106.04,69.32 107.55,69.32 123.75,53.13 123.75,51.14 123.86,51.02 124.12,51.02 124.31,50.83 124.31,50.57 124.12,50.38 123.86,50.38 123.75,50.26 123.75,49.41 123.86,49.3 125.06,49.3 125.18,49.18 125.18,48.76 125.06,48.65 123.86,48.65 123.75,48.54 123.75,48.12 123.86,48 125.06,48 125.18,47.89 125.18,47.47 125.06,47.36 123.86,47.36 123.75,47.24 123.75,46.05 124.4,45.39 125.09,45.39 125.2,45.28 125.2,44.86 125.09,44.74 123.34,44.74 123.15,44.55 123.15,44.28 123.34,44.09 124.99,44.09 125.18,43.9 125.18,43.64 124.99,43.45 123.46,43.45 123.27,43.26 123.27,42.99 123.46,42.8 124.63,42.8 124.87,42.56 124.87,41.28 122.8,39.21 122.64,39.21 121.92,39.93 121.76,39.93 121.46,39.63 121.46,39.47 122.18,38.75 122.18,38.59 121.84,38.24 121.55,38.24 120.58,39.21 v5(120.52,39.21)
  BOTTOM w0.076: v3(97.26,73.24) 95.83,74.67 95.83,77.98 96.01,78.15 96.01,80.3 95.19,81.11 95.19,82 95.3,82.11 95.3,82.47 95.27,82.56 95.27,82.76 95.3,82.85 95.3,82.85 95.31,82.86 95.31,82.87 95.31,83.09 95.27,83.22 95.27,83.47 95.34,83.57 95.34,84.08 95.55,84.29 UC1.AW25
  BOTTOM w0.114: JDIMM1.193 119.92,37.15 119.92,38.63 120.5,39.21 v5(120.52,39.21)
DDR_A_D60: length 81.9
  IN3 w0.114: v5(117.16,32.31) 119.53,29.94 119.89,29.94 120.38,30.42 120.38,30.51 122.96,33.09 123.3,35.42 127.34,39.46 127.34,52.58 124.28,55.65 124.28,56.6 110.46,70.41 109.74,70.41 108.39,71.75 107,71.75 104.24,74.52 104.24,75.37 100.55,79.06 95.9,79.06 v3(95.28,78.44)
  BOTTOM w0.076: UC1.BB27 94.86,82.33 94.86,80.98 95.68,80.16 95.68,78.84 v3(95.28,78.44)
  BOTTOM w0.114: JDIMM1.180 116.02,28.95 116.02,31.19 117.14,32.31 v5(117.16,32.31)
DDR_A_D61: length 82.3
  IN3 w0.114: v5(117.22,30.98) 118.59,29.61 120.72,29.61 123.63,32.52 123.63,35.28 127.67,39.32 127.67,44.8 128.5,45.63 128.5,50.24 128.31,50.42 128.03,50.42 127.84,50.61 127.84,50.88 128.03,51.07 128.31,51.07 128.5,51.26 128.5,51.89 124.92,55.47 124.92,56.42 110.71,70.63 109.96,70.63 108.41,72.18 107.17,72.18 104.7,74.65 104.7,75.42 100.78,79.34 95.69,79.34 v3(95.28,79.74)
  BOTTOM w0.076: v3(95.28,79.74) 95.28,80.32 94.7,80.91 94.7,82.09 94.61,82.18 94.61,82.5 94.87,82.76 UC1.BA27
  BOTTOM w0.114: v5(117.22,30.98) 116.85,30.98 116.62,30.75 116.62,28.95 JDIMM1.182
DDR_A_D62: length 82.1
  IN3 w0.114: v3(97.26,77.79) 98.03,77.79 98.87,78.63 100.39,78.63 100.87,78.15 100.87,76.29 101.47,75.69 103.22,75.69 103.83,75.08 103.83,74.32 106.84,71.31 108.26,71.31 109.4,70.17 110.23,70.17 122.2,58.2 122.2,57.25 122.57,56.89 122.84,56.89 123.01,57.06 123.28,57.06 123.47,56.87 123.47,56.6 123.3,56.43 123.3,56.16 126.98,52.48 126.98,40.88 125.84,39.74 125.84,39.58 126.32,39.11 126.32,38.95 126.02,38.65 125.86,38.65 125.39,39.12 125.22,39.12 124.93,38.83 124.93,38.66 125.4,38.19 125.4,38.03 125.1,37.73 124.94,37.73 124.47,38.21 124.31,38.21 124.01,37.91 124.01,37.75 124.48,37.28 124.48,37.11 124.19,36.82 124.02,36.82 123.55,37.29 123.39,37.29 123.09,36.99 123.09,36.83 123.57,36.36 123.57,36.2 123.27,35.9 123.11,35.9 122.64,36.37 122.47,36.37 121.88,35.78 121.88,32.54 v5(119.73,30.39)
  BOTTOM w0.076: v3(97.26,77.79) 97.05,78.01 97.05,78.52 96.69,78.88 96.69,80.65 96.48,80.86 96.48,82.42 96.35,82.69 96.2,82.84 UC1.BA25
  BOTTOM w0.114: v5(119.73,30.39) 119.62,30.28 119.62,28.95 JDIMM1.192
DDR_A_D63: length 81.2
  IN3 w0.114: v3(97.26,77.14) 98.29,77.14 99.42,78.27 100.2,78.27 100.38,78.09 100.38,76.1 101.18,75.31 103,75.31 103.36,74.95 103.36,74.09 106.74,70.71 108.27,70.71 109.1,69.89 110.05,69.89 117.69,62.25 117.69,62.08 117.43,61.82 117.43,61.56 117.62,61.37 117.89,61.37 118.15,61.62 118.31,61.62 118.61,61.32 118.61,61.16 118.35,60.91 118.35,60.75 118.65,60.45 118.81,60.45 119.06,60.7 119.23,60.7 119.52,60.41 119.52,60.25 119.27,59.99 119.27,59.83 119.57,59.54 119.73,59.54 119.98,59.79 120.14,59.79 120.44,59.49 120.44,59.33 120.21,59.1 120.21,58.83 120.4,58.64 121.19,58.64 121.48,58.35 121.48,57.51 126.65,52.34 126.65,41.01 121.55,35.92 121.55,32.76 121.26,32.47 120.99,32.47 120.79,32.67 120.52,32.67 120.33,32.48 120.33,32.21 120.53,32.01 120.53,31.74 120.1,31.31 v5(118.82,31.31)
  BOTTOM w0.076: v3(97.26,77.14) 96.87,77.54 96.87,78.38 96.52,78.73 96.52,80.58 96.5,80.6 96.31,80.8 96.31,82 96.2,82.11 UC1.BB25
  BOTTOM w0.114: JDIMM1.194 120.22,28.95 120.22,30.78 119.69,31.31 v5(118.82,31.31)
DDR_A_DQS0: length 84.7
  IN3 w0.076: 58.86,87.92 58.88,87.92 58.9,87.94 59.11,87.94 59.31,87.74 62.3,87.74 62.47,87.91 62.47,88.15 v3(62.72,88.4)
  IN3 w0.114: 58.86,87.92 57.18,87.92 54.33,85.07 54.33,59.74 54.46,59.61 54.46,54.21 53.1,52.85 53.1,47.38 53.82,46.67 53.82,41.94 58.12,37.65 61.34,37.65 62.71,36.28 62.71,34.7 61.35,33.34 61.35,32 61.63,31.72 61.8,31.72 v5(62.08,31.99)
  BOTTOM w0.076: UC1.AM69 70.49,88.59 70.45,88.63 70.45,88.77 70.38,88.83 70.18,88.93 69.89,88.93 69.81,88.89 69.6,88.89 69.49,88.95 69.27,88.95 69.16,88.89 68.6,88.89 68.52,88.97 68.04,88.97 68,88.93 68,88.92 67.49,88.41 66.82,88.41 66.16,87.75 62.69,87.75 62.38,88.06 62.38,88.21 62.57,88.4 v3(62.72,88.4)
  BOTTOM w0.127: JDIMM1.12 63.22,30.1 63.22,30.1 62.99,30.33 62.99,30.7 62.99,31.5 62.74,31.74 62.32,31.74 v5(62.08,31.99)
DDR_A_DQS1: length 73
  IN3 w0.076: v3(65.28,83.13) 65.53,83.37 65.53,83.52 65.45,83.6 65.07,83.6 64.7,83.22 64.7,82.19 64.64,82.12 64.64,82.1 64.62,82.08
  IN3 w0.114: v3(67.13,34.28) 67.39,34.54 67.68,34.54 67.95,34.82 67.95,36.13 67.59,36.49 67.59,38.62 65.5,40.71 64,40.71 62.08,42.63 61.7,42.63 60.98,43.35 60.98,47.68 60.42,48.24 60.42,49.2 59.54,50.08 59.54,63.01 59.31,63.24 59.08,63.24 58.97,63.35 58.97,63.77 59.08,63.89 59.31,63.89 59.54,64.12 59.54,64.7 59.31,64.93 59.08,64.93 58.97,65.05 58.97,65.47 59.08,65.58 59.31,65.58 59.54,65.81 59.54,66.39 59.31,66.62 59.08,66.62 58.97,66.74 58.97,67.16 59.08,67.27 59.31,67.27 59.54,67.5 59.54,68.09 59.31,68.32 59.08,68.32 58.97,68.43 58.97,68.85 59.08,68.96 59.31,68.96 59.54,69.19 59.54,69.78 59.31,70.01 59.08,70.01 58.97,70.12 58.97,70.54 59.08,70.65 59.31,70.65 59.54,70.88 59.54,71.47 59.31,71.7 59.08,71.7 58.97,71.81 58.97,72.23 59.08,72.35 59.31,72.35 59.54,72.58 59.54,72.91 60.71,74.08 60.71,75.85 64.62,79.77 64.62,82.08
  BOTTOM w0.076: UC1.AT70 70.24,86.14 70.28,86.1 70.28,85.95 70.27,85.94 70.14,85.87 69.92,85.87 69.84,85.91 69.57,85.91 69.44,85.86 69.33,85.86 69.19,85.91 69.17,85.91 69.16,85.9 68.71,85.9 68.54,85.74 68.28,85.74 67.43,84.88 66.03,84.88 65.51,84.37 65.51,83.29 65.35,83.13 v3(65.28,83.13)
  BOTTOM w0.127: v3(67.13,34.28) 67.39,34.55 67.76,34.55 68.13,34.92 68.13,35.96 68.32,36.15 JDIMM1.29
DDR_A_DQS2: length 66.2
  IN3 w0.076: 66.61,74.23 66.62,74.25 66.62,74.27 66.69,74.35 67.81,74.35 68.31,74.85 68.31,76.51 68.09,76.73 67.86,76.73 v3(67.61,76.98)
  IN3 w0.114: v5(74.29,34.92) 74.01,34.63 73.59,34.63 73.34,34.88 73.34,36.07 72.91,36.51 72.91,39.64 70.12,42.43 69.9,42.43 68.8,43.54 68.8,47.99 68.64,48.15 68.64,51.08 63.7,56.01 63.7,71.33 66.61,74.23
  BOTTOM w0.076: UC1.AY64 73.38,83.77 73.34,83.73 73.22,83.73 73.13,83.64 73.04,83.46 73.04,83.17 73.08,83.09 73.08,82.88 73.03,82.77 73.03,82.55 73.08,82.44 73.08,82.18 72.92,82.02 72.92,81.27 72.84,81.19 72.73,81.19 72.56,81.02 72.56,80.9 72.38,80.73 72.27,80.73 72.1,80.56 72.1,80.45 72.05,80.4 69.04,80.4 68.95,80.3 68.89,80.3 68.84,80.3 68.66,80.13 68.66,80.08 68.66,80.02 68.6,79.95 68.6,79.23 68.51,79.14 68.51,78.89 68.6,78.81 68.6,78.56 68.51,78.48 68.51,78.23 68.6,78.15 68.6,77.9 68.51,77.82 68.51,77.57 68.6,77.49 68.6,77.24 68.4,77.04 68.29,77.04 68.12,76.87 68.12,76.76 68.05,76.69 67.73,76.69 67.61,76.81 v3(67.61,76.98)
  BOTTOM w0.127: v5(74.29,34.92) 74.03,34.65 73.65,34.65 73.51,34.79 73.51,35.82 73.72,36.03 JDIMM1.47
DDR_A_DQS3: length 66.8
  IN3 w0.076: 70.31,72.36 70.44,72.49 70.44,73.87 72.13,75.57 72.13,77.32 73.1,78.29 73.27,78.29 v3(73.52,78.53)
  IN3 w0.114: 70.31,72.36 67.67,69.73 67.67,58.76 75.5,50.94 75.5,42.53 76.82,41.2 76.82,39.13 79.49,36.46 79.49,33.3 79.03,32.84 79.03,31.81 79.32,31.51 79.57,31.51 v3(79.85,31.23)
  BOTTOM w0.076: v3(73.52,78.53) 73.52,78.44 73.7,78.25 73.92,78.25 74.02,78.36 74.02,79.28 76,81.26 76,81.39 76.23,81.62 76.23,81.92 76.06,82.09 76.06,82.46 76.12,82.61 76.12,82.71 76.12,82.73 76.07,82.84 76.06,82.85 76.06,83.12 76.1,83.2 76.1,83.42 76.04,83.55 75.93,83.66 75.86,83.66 75.83,83.62 75.83,83.52 UC1.BA60
  BOTTOM w0.127: JDIMM1.64 78.82,29.89 78.67,30.04 78.67,31.23 79.06,31.63 79.6,31.63 79.85,31.38 v3(79.85,31.23)
DDR_A_DQS4: length 66.1
  IN3 w0.076: 89.18,70.17 89.18,70.19 89.2,70.21 89.2,71.09 88.72,71.57 88.72,76.05 88.95,76.28 88.95,77.11 88.73,77.33 88.44,77.33 v3(88.25,77.14)
  IN3 w0.114: v5(102.25,34.15) 102.04,34.36 101.73,34.36 101.54,34.55 101.54,37.41 103.52,39.39 103.52,41.04 106.05,43.57 106.05,53 105.63,53.42 105.4,53.42 104.99,53.83 104.99,54.58 103.02,56.55 100.44,56.55 89.18,67.81 89.18,70.17
  BOTTOM w0.076: UC1.AY38 87.9,83.7 87.81,83.56 87.77,83.45 87.77,83.17 87.8,83.09 87.8,82.88 87.75,82.77 87.75,82.75 87.75,82.55 87.8,82.44 87.8,82.05 87.67,81.92 87.67,81.43 87.85,81.25 87.85,80.25 87.66,80.05 87.66,77.56 87.88,77.34 88.04,77.34 v3(88.25,77.14)
  BOTTOM w0.127: v5(102.25,34.15) 102.44,34.35 102.69,34.35 102.96,34.62 102.96,35.91 103.12,36.07 JDIMM1.137
DDR_A_DQS5: length 68.6
  IN3 w0.076: 93.44,70.17 93.44,70.19 93.42,70.21 93.42,70.83 91.37,72.88 91.37,75.36 91.52,75.5 91.66,75.5 91.8,75.36 v3(91.8,75.19)
  IN3 w0.114: 93.44,70.17 93.44,69.59 102.22,60.81 104.79,60.81 111.37,54.23 111.37,51.52 111.87,51.02 111.87,42.31 110.16,40.6 110.16,39.98 107.91,37.72 107.91,31.55 v5(108.32,31.13)
  BOTTOM w0.076: v3(91.8,75.19) 91.63,75.37 91.31,75.37 90.92,75.76 90.92,81.21 90.79,81.35 90.79,82.48 90.84,82.59 90.84,82.72 90.79,82.85 90.79,83.12 90.82,83.2 90.82,83.42 90.79,83.48 90.74,83.56 90.7,83.58 90.62,83.58 90.55,83.52 90.55,83.31 UC1.BA34
  BOTTOM w0.127: JDIMM1.154 108.22,28.95 108.22,30.03 108.07,30.18 108.07,30.88 v5(108.32,31.13)
DDR_A_DQS6: length 72.5
  IN3 w0.076: v3(93.68,77.14) 93.68,77.31 93.82,77.45 94.02,77.45 94.33,77.14 94.33,73.23 96.53,71.03 97.59,71.03 98.42,70.21 98.42,70.18 98.43,70.17
  IN3 w0.114: 98.43,70.17 99.22,69.38 99.6,69.38 99.95,69.03 99.95,68.65 100.61,67.99 100.99,67.99 101.2,67.78 101.2,67.39 101.5,67.1 101.88,67.1 102.12,66.86 102.12,66.48 102.46,66.14 102.86,66.14 103.06,65.94 103.06,65.54 103.92,64.68 106.42,64.68 115.29,55.81 115.29,54.88 118.02,52.16 118.02,49.69 118.22,49.49 118.22,45.95 117.77,45.49 117.77,44.94 118.3,44.41 118.3,44.24 117.77,43.71 117.77,42.77 115.96,40.96 115.96,38.78 114.13,36.95 114.13,36.57 113.8,36.24 113.8,35.83 114.17,35.46 114.17,33.76 113.88,33.47 113.49,33.47 113.23,33.73 113.23,34.45 113.36,34.58 v5(113.54,34.58)
  BOTTOM w0.076: v3(93.68,77.14) 93.68,77.28 93.48,77.48 93.28,77.48 93.1,77.67 93.1,80.92 92.75,81.26 92.75,81.4 92.75,81.4 92.75,81.8 92.78,81.83 92.78,82.44 92.73,82.55 92.73,82.77 92.78,82.88 92.78,83.09 92.75,83.17 92.75,83.45 92.79,83.56 92.88,83.7 UC1.AY30
  BOTTOM w0.127: v5(113.54,34.58) 113.38,34.58 113.18,34.78 113.18,35.33 112.96,35.55 112.96,36.01 113.32,36.37 JDIMM1.171
DDR_A_DQS7: length 83.1
  IN3 w0.114: v3(118.97,32) 118.97,32.18 118.8,32.35 118.3,32.35 118.1,32.55 118.1,33.02 119.74,34.65 120.47,34.65 120.73,34.92 120.73,36.26 125.83,41.35 125.83,50.16 125.64,50.35 125.26,50.35 124.95,50.65 124.95,51.08 125.26,51.39 125.64,51.39 125.83,51.58 125.83,51.97 116.18,61.61 116.18,61.93 116.43,62.17 116.43,62.33 116.13,62.63 115.97,62.63 115.72,62.39 115.4,62.39 113.79,64 113.79,64.32 114.03,64.57 114.03,64.73 113.73,65.03 113.57,65.03 113.33,64.78 113,64.78 112.59,65.19 112.59,65.52 112.83,65.76 112.83,65.93 112.54,66.22 112.37,66.22 112.13,65.98 111.8,65.98 111.39,66.39 111.39,66.72 111.56,66.89 111.56,67.05 111.27,67.35 111.11,67.35 110.93,67.18 110.61,67.18 109.73,68.05 109.73,68.38 109.95,68.6 109.95,68.76 109.65,69.06 109.49,69.06 109.27,68.84 108.94,68.84 107.79,70 106.55,70 102.94,73.61 99.33,73.61 98.92,74.02 98.92,75.22 98.63,75.51 97.58,75.51 v3(97.26,75.19)
  BOTTOM w0.076: UC1.BA26 95.53,83.31 95.53,83.52 95.6,83.58 95.68,83.58 95.73,83.56 95.78,83.48 95.8,83.42 95.8,83.2 95.77,83.12 95.77,82.85 95.82,82.72 95.82,82.61 95.77,82.47 95.77,82.08 95.98,81.86 95.98,80.66 96.18,80.46 96.18,75.95 96.77,75.36 97.09,75.36 v3(97.26,75.19)
  BOTTOM w0.127: JDIMM1.188 118.42,28.95 118.42,30.22 118.25,30.38 118.25,32.03 118.55,32.32 118.85,32.32 118.97,32.2 v3(118.97,32)
DDR_A_DQS#0: length 84.7
  IN3 w0.076: v5(62.07,88.4) 62.31,88.15 62.31,87.97 62.23,87.9 59.38,87.9 59.17,88.1 58.9,88.1 58.88,88.12 58.86,88.12
  IN3 w0.114: v3(62.08,31.23) 61.79,31.52 61.54,31.52 61.15,31.91 61.15,33.42 62.52,34.79 62.52,36.19 61.26,37.45 58.03,37.45 53.62,41.86 53.62,46.58 52.9,47.3 52.9,52.94 54.26,54.29 54.26,59.53 54.13,59.66 54.13,85.16 57.1,88.12 58.86,88.12
  BOTTOM w0.076: v5(62.07,88.4) 62.22,88.24 62.22,88 62.63,87.59 63.29,87.59 63.37,87.51 63.62,87.51 63.69,87.59 63.94,87.59 64.02,87.51 64.26,87.51 64.34,87.59 66.22,87.59 66.88,88.25 67.55,88.25 68.11,88.81 68.45,88.81 68.53,88.73 69.19,88.73 69.33,88.78 69.44,88.78 69.57,88.73 69.84,88.73 69.92,88.76 70.14,88.76 70.28,88.69 70.28,88.58 70.2,88.49 UC1.AM70
  BOTTOM w0.127: JDIMM1.10 62.62,30.01 62.62,30.01 62.62,30.11 62.75,30.23 62.75,31.4 62.64,31.5 62.34,31.5 62.08,31.24 v3(62.08,31.23)
