# Allegro board Lenovo ThinkPad E460 E560 BE560 NM-A561 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SD_CMD_MS_DATA2_R: length 2.7
  TOP w0.114: RW23.2 50.48,27.42 50.21,27.69 50.03,27.69 49.84,27.88 v2(49.84,27.95) 49.84,28.13 49.49,28.48 UW1.19
SD_DATA0_MS_DATA1: length 44.5
  IN3 w0.114: v5(22.92,32.55) 23.23,32.24 23.23,32.08 22.75,31.59 22.75,31.43 23.02,31.15 23.19,31.15 23.67,31.64 23.84,31.64 24.11,31.36 24.11,31.2 23.63,30.71 23.63,30.55 23.9,30.27 24.07,30.27 24.55,30.76 24.72,30.76 24.99,30.48 24.99,30.32 24.51,29.83 24.51,29.67 24.79,29.39 24.95,29.39 25.43,29.88 25.6,29.88 25.92,29.55 25.92,29.39 25.66,29.13 25.66,28.94 25.81,28.8 25.97,28.8 26.24,29.07 26.4,29.07 26.78,28.69 36.46,28.69 42.5,22.65 48.84,22.65 v3(49.35,23.15)
  BOTTOM w0.114: v5(22.92,32.55) JREAD2.7 ; v3(49.35,23.15) 49.35,24.65 50.36,25.67 50.36,28.23 50.11,28.49 RW21.1
SD_DATA0_MS_DATA1_R: length 3.2
  TOP w0.114: v3(47.94,28.64) 47.94,29.74 UW1.16
  BOTTOM w0.114: v3(47.94,28.64) 47.71,28.64 47.48,28.41 47.48,28.26 v4(47.55,28.18) 48.32,28.18 RW21.2
SD_DATA1: length 43.8
  IN3 w0.114: v3(21.05,32.6) 26.46,27.19 37.61,27.19 42.4,22.4 49.35,22.4 v3(50.09,23.15)
  BOTTOM w0.114: v3(21.05,32.6) JREAD2.8 ; RW4.1 49.97,29.38 v4(50.6,28.74) 50.6,25.57 49.59,24.55 49.59,23.66 v3(50.09,23.15)
SD_DATA1_R: length 2.5
  TOP w0.114: UW1.15 47.43,30.2 46.82,29.58 v1(46.82,29.48)
  BOTTOM w0.114: RW4.2 46.92,29.38 v1(46.82,29.48)
SD_DATA2_MS_CLK: length 43
  TOP w0.114: v5(53.09,24.68) 52.25,25.52 RW25.1
  IN3 w0.114: v5(53.09,24.68) 53.09,27.57 52.79,27.88 52.47,27.88 52.36,27.99 52.36,30.66 52.24,30.77 51.85,30.77 51.74,30.66 51.74,27.99 51.62,27.88 51.23,27.88 51.11,27.99 51.11,29.75 51,29.86 50.61,29.86 50.49,29.75 50.49,27.99 50.38,27.88 49.98,27.88 49.87,27.99 49.87,29.75 49.75,29.86 49.36,29.86 49.25,29.75 49.25,27.99 49.13,27.88 48.74,27.88 48.62,27.99 48.62,29.75 48.51,29.86 48.12,29.86 48,29.75 48,29.44 47.56,29 46.87,29 46.76,28.88 46.76,27.99 46.64,27.88 46.25,27.88 46.13,27.99 46.13,29.75 46.02,29.86 45.63,29.86 45.51,29.75 45.51,27.99 45.4,27.88 42.88,27.88 39.6,31.15 v3(39.6,32.65)
  BOTTOM w0.114: v3(39.6,32.65) 40.28,31.98 JREAD2.9
SD_DATA2_MS_CLK_R: length 4.1
  TOP w0.114: RW25.2 52.25,27.37 52.43,27.55 v2(52.43,28.01) 52.08,28.36 50.45,28.36 50.29,28.52 UW1.21
SD_MS_DATA3: length 43.9
  TOP w0.114: RW24.1 51.36,25.11 v3(51.8,24.68)
  IN3 w0.114: v3(51.8,24.68) 52.61,25.49 52.61,27.28 52.5,27.4 51.98,27.4 51.87,27.28 51.87,25.55 51.75,25.44 51.36,25.44 51.25,25.55 51.25,27.28 51.13,27.4 50.66,27.4 50.55,27.28 50.55,25.53 50.43,25.41 50.04,25.41 49.93,25.53 49.93,27.28 49.81,27.4 49.42,27.4 49.3,27.28 49.3,25.53 49.19,25.41 48.1,25.41 47.98,25.53 47.98,26.98 47.87,27.09 47.48,27.09 47.36,26.98 47.36,26.18 47.21,26.02 46.88,26.02 46.74,26.16 46.74,27.28 46.62,27.4 46.23,27.4 46.12,27.28 46.12,25.53 46,25.41 45.61,25.41 45.49,25.53 45.49,27.28 45.38,27.4 44.99,27.4 44.87,27.28 44.87,25.53 44.76,25.41 44.35,25.41 43.8,25.97 43.8,26.13 44.14,26.48 44.14,26.64 43.86,26.92 43.7,26.92 43.36,26.57 43.19,26.57 37.78,31.99 v5(37.78,32.58)
  BOTTOM w0.114: JREAD2.1 v5(37.78,32.58)
SD_MS_DATA3_R: length 3.2
  TOP w0.114: RW24.2 51.36,27.73 v2(51.14,27.95) 51.09,28.01 50.4,28.01 49.89,28.51 UW1.20
SD_WP: length 2.3
  TOP w0.114: RW15.1 53.46,31.39 UW1.29
SD_WP_R: length 44.3
  TOP w0.114: v5(57.23,30.09) 56.6,30.09 RW12.2 55.1,30.72 RW15.2
  IN3 w0.114: v3(19,32.78) 19,32.9 19.51,33.42 50.5,33.42 51.09,32.83 53.19,32.83 55.94,30.09 v5(57.23,30.09)
  BOTTOM w0.114: v3(19,32.78) JREAD2.10
SERIRQ: length 164.4
  TOP w0.114: RPC22.1 115.56,63.48 116.01,63.03 116.01,61.63 116.14,61.5 118.68,61.5 120.49,63.31 120.88,63.31 121.16,63.59 121.16,64.12 121.4,64.36 121.4,67.01 120.99,67.42 v3(120.85,67.42) 120.38,67.9 R9478.1 120.12,68.37 v4(119.36,68.37) ; UE1.5 202.26,46.07 203.23,45.1 204.68,45.1 205.64,46.06 212.22,46.06 v3(212.35,45.94)
  IN2 w0.14: v3(120.85,67.42) 121.11,67.42 121.68,66.85 123.39,66.85 123.69,67.16 125.22,67.16 125.3,67.07 128.08,67.07 129.09,66.05 130.16,66.05 130.61,66.51 131.65,66.51 133.84,64.32 139.17,64.32 142.73,60.76 153.23,60.76 160.08,53.91 161.55,53.91 165.99,49.47 168.08,49.47 168.31,49.7 170.92,49.7 172.17,50.94 174.12,50.94 177.02,48.05 182.03,48.05 183.66,49.67 186.78,49.67 189.08,47.37 189.08,45.1 191.7,42.48 201.18,42.48 202.66,41 208.65,41 211.84,44.19 211.84,45.43 v3(212.35,45.94)
  BOTTOM w0.076: UC1.AY11 103.24,83.18 103.13,83.07 103.13,81.45 104.35,80.23
  BOTTOM w0.102: 106.01,77.29 106.01,78.57 104.35,80.23
  BOTTOM w0.114: v3(120.85,67.42) 120.85,67.49 117.23,71.11 112.76,71.11 111.74,72.13 108.64,72.13 106.01,74.76 106.01,77.29
SERIRQ_R: length 151
  TOP w0.114: v1(122.76,67.88) 122.54,68.11 R9478.2
  IN1 w0.14: v1(118.57,117.01) 118.75,117.01 119.26,117.51 120.38,117.51 121.05,118.19 121.35,118.19 121.76,118.59 122.04,118.59 122.36,118.91 122.36,119.61 122.99,120.25 127.22,120.25 128.87,118.59 129.87,118.59 130.04,118.77 136.28,118.77 138.44,116.61 151.31,116.61 154.26,113.65 154.26,109.68 158.25,105.69 158.25,96.51 156.29,94.55 156.29,92.88 v3(155.86,92.45)
  IN3 w0.114: v1(122.76,67.88) 123.86,67.88 125.76,65.98 131.86,65.98 132.67,65.17 138.08,65.17 141.74,61.51 144.74,61.51 145.62,60.62 155.12,60.62 156.24,59.5 v3(164.27,59.5)
  BOTTOM w0.114: v3(164.27,59.5) 163.91,59.5 160.05,63.36 160.05,66.71 156.54,70.23 156.54,85.03 154.49,87.09 154.49,90.18 155.33,91.02 155.33,92.17 155.61,92.45 v3(155.86,92.45) ; UTPM1.18 117.92,117.31 117.92,117.3 118.22,117.01 v1(118.57,117.01) R9477.1
SM_DIMM_VREFCA: length 133.8
  TOP w0.254: v3(50.45,52.67) 50.6,52.52 52.38,52.52 54.67,54.81 58.99,54.81 63.99,49.8 63.99,48.4 65.06,47.33 65.06,46.06 63.92,44.92 63.78,44.92 62.59,43.74 62.59,43.38 61.84,42.64 58.76,42.64 58.2,42.08 58.2,41.29 59.94,39.55 61.16,39.55 62.72,37.99 v4(62.72,29.22) 62.72,27.68 v3(63.18,27.22)
  TOP w0.381: v3(103.82,24.04) 104.2,24.42 CD12.1 RD10.2
  IN3 w0.254: v3(63.18,27.22) 65.97,24.42 103.43,24.42 v3(103.82,24.04)
  BOTTOM w0.076: UC1.AY67 71.72,83.39 71.72,83.17 71.75,83.09 71.75,82.88 71.7,82.77 71.7,82.55 71.75,82.44 71.75,82.2 71.58,82.02 71.45,82.02 71.11,81.68 71.11,81.38 70.98,81.26 68.45,81.26 68.05,80.86 67.38,80.86 66.63,80.11 66.63,77.41 66.47,77.24
  BOTTOM w0.114: 66.47,77.24 55.7,66.47 55.7,56.05 52.32,52.67 v3(50.45,52.67)
SM_PG_CTRL: length 41.8
  TOP w0.114: QD1.1 110.01,21.76 RD23.2 110.39,20.51 RD25.1 111.05,19.85 v4(112.64,19.85) 113.44,19.85 v3(115.4,21.81)
  IN3 w0.114: v3(132.47,43.68) 131.73,42.94 130.49,42.94 129.86,42.32 129.86,37.09 128.01,35.23 128.01,32.63 124.64,29.26 124.64,25.7 120.76,21.81 v3(115.4,21.81)
  BOTTOM w0.254: PR310.2 132.57,43.58 v3(132.47,43.68)
SM_RCOMP0: length 5.1
  TOP w0.114: RC8.1 98.86,82.48 98.86,86.15 99.11,86.39 v3(99.25,86.39)
  BOTTOM w0.114: v3(99.25,86.39) 99.69,86.73 UC1.AR18
SM_RCOMP1: length 4.9
  TOP w0.114: v3(99.25,85.75) 99.38,85.75 99.69,85.45 99.69,84.75 100.01,84.43 100.01,83.11 RC9.1
  BOTTOM w0.114: v3(99.25,85.75) 99.69,86.08 UC1.AT18
SM_RCOMP2: length 3.8
  TOP w0.114: RC10.1 100.01,82.59 99.69,82.91 99.69,84.3 99.25,84.74 v3(99.25,85.12)
  BOTTOM w0.114: v3(99.25,85.12) 99.69,85.44 UC1.AU18
SMBCLK: length 15.1
  TOP w0.114: RV144.1 161.41,142.94 161.97,143.5 162.37,143.5 162.47,143.61 QV5.1 ; RV144.1 161.04,142.94 160.53,143.45 159.06,143.45 v2(158.9,143.61) 158.53,143.98 153.37,143.98 v3(152.58,144.77) ; RV144.1 161.17,142.71 161.17,141.95 161.45,141.67 162.13,141.67 RV98.2
  BOTTOM w0.102: v3(152.58,144.77) 152.1,144.77 151.51,145.36 UV1.AJ23
SMBDAT: length 20.8
  TOP w0.114: v1(151.76,143.67) 152.34,143.09 160.12,143.09 160.93,142.28 160.93,141.85 161.35,141.43 163.3,141.43 RV99.2 164.24,141.46 RV142.1 164.88,142.09 v2(164.88,143.52) 164.88,144.49 163.87,145.49 QV5.4
  BOTTOM w0.102: UV1.AH23 151.02,145.16 151.83,144.35 151.83,143.74 v1(151.76,143.67)
SPI_CLK: length 99.2
  IN1 w0.14: v3(117.23,114.16) 117.23,112.41 117.1,112.28 116.79,112.28 116.67,112.4 116.67,113.51 116.53,113.65 116.25,113.65 116.11,113.51 116.11,112.88 115.97,112.74 114.08,112.74 113.87,112.54 113.87,111.99 113.66,111.77 113.46,111.77 113.3,111.93 113.3,112.93 112.81,113.43 110.67,113.43 110.47,113.22 110.47,112.98 110.61,112.84 112.64,112.84 112.78,112.7 112.78,112.42 112.64,112.28 110.61,112.28 110.47,112.14 110.47,111.01 110.7,110.78 111.19,110.78 111.33,110.92 111.33,111.69 111.47,111.83 111.75,111.83 111.89,111.69 111.89,110.92 112.03,110.78 112.27,110.78 112.43,110.94 112.43,111.32 112.58,111.47 113.06,111.47 113.67,110.86 114.2,110.86 114.34,111 114.34,112.04 114.48,112.18 114.76,112.18 114.9,112.04 114.9,111 115.04,110.86 115.27,110.86 116.16,111.75 117.02,111.75 v3(117.71,111.06)
  BOTTOM w0.114: RC380.1 127.54,90.72 128.12,91.3 128.43,91.3 128.99,90.73 129.16,90.73 129.4,90.98 129.4,91.14 129.05,91.48 129.05,91.65 129.29,91.89 129.46,91.89 129.8,91.54 129.96,91.54 130.21,91.78 130.21,91.95 129.86,92.29 129.86,92.45 130.1,92.7 130.26,92.7 130.61,92.35 130.77,92.35 131.01,92.59 131.01,92.75 130.33,93.44 130.33,93.87 v4(130.71,94.25) 131.02,94.55 131.02,95.29 130.79,95.52 129.89,95.52 129.77,95.63 129.77,95.98 129.89,96.09 130.9,96.09 131.02,96.2 131.02,96.55 130.9,96.66 129.66,96.66 129.55,96.78 129.55,97.12 129.66,97.23 130.6,97.23 130.71,97.35 130.71,97.53 129.9,98.34 129.31,98.34 129.2,98.22 129.2,97.99 129.08,97.88 128.74,97.88 128.62,97.99 128.62,98.22 128.51,98.34 127.43,98.34 124.1,101.66 124.1,102.26 123.47,102.9 123.47,106.44 121.46,108.45 120.94,108.45 120.28,109.11 119.18,109.11 119.02,109.11 118.62,108.71 118.46,108.71 118.22,108.95 118.22,109.11 118.62,109.51 118.62,109.67 118.37,109.92 118.21,109.92 117.62,109.33 117.46,109.33 117.06,109.73 116.12,109.73 116.01,109.84 116.01,110.25 116.21,110.45 117.58,110.45 117.71,110.58 v3(117.71,111.06) 117.71,111.83 117.81,111.93 118.86,111.93 119.56,112.62 120.51,112.62 121.1,113.21 121.1,115.76 121.82,116.48 121.82,116.84 121.82,117.25 122.84,118.26 123.81,118.26 125.02,119.48 125.02,119.74 125.03,119.74 RPC23.7 125.03,120.12 125.34,120.44 126.49,120.44 129.08,117.84 RPC24.7 ; v3(117.23,114.16) 117.53,113.85 117.78,113.85 117.91,113.98 117.91,114.49 117.68,114.72 R9483.1
SPI_CLK_4MB: length 179.9
  TOP w0.114: UC4M1.6 224.69,16.4 224.26,15.97 v4(223.55,15.97) 223.48,15.97 222.68,16.77 222.68,19.05 222.26,19.47 v3(222.08,19.47)
  IN2 w0.14: v3(151.26,85.97) 151.26,85.99 150.61,86.65 150.61,94.76 152.1,96.26 152.1,101.59 152.36,101.84 v3(152.36,103.7)
  BOTTOM w0.114: v3(152.36,103.7) 152.33,103.72 152.33,113.2 148.42,117.1 147.73,117.1 145.92,118.91 145.92,119.86 145.66,120.12 144.58,120.12 144.2,119.74 144.2,118.98 141.38,116.16 135.93,116.16 135.21,116.88 131.82,116.88 130.17,115.23 130.17,114.91 129.79,114.53 129.22,114.53 129.08,114.66 RPC24.2 ; v3(222.08,19.47) 221.47,20.08 221.47,23.38 215.85,29 208.57,29 205.39,32.17 190.46,32.17 186.57,36.06 179.63,36.06 171.84,43.85 170.99,43.85 161.88,52.96 161.88,57.72 157.36,62.24 157.36,62.83 155.23,64.96 155.23,65.42 153.17,67.47 153.17,70.56 154.07,71.45 154.07,81.84 151.54,84.37 151.54,85.69 v3(151.26,85.97)
SPI_CLK_8MB: length 14.9
  BOTTOM w0.114: UC8M2.6 132.49,126.23 131.98,126.74 128.07,126.74 127.94,126.6 127.94,126.44 128.02,126.36 128.02,126.2 127.84,126.02 127.66,126.02 127.59,126.09 127.43,126.09 127.24,125.9 127.24,125.74 127.59,125.39 127.59,125.23 127.4,125.04 127.24,125.04 126.89,125.39 126.73,125.39 126.54,125.2 126.54,125.04 126.89,124.69 126.89,124.53 126.7,124.34 126.54,124.34 126.19,124.69 126.03,124.69 125.89,124.55 RC314.2 125.75,123.89 124.92,123.06 v2(124.92,122.67) 124.92,121.55 125.03,121.45 RPC23.2
SPI_CLK_L: length 2
  BOTTOM w0.114: R9483.2 117.68,116.55 117.42,116.82 UTPM1.19
SPI_CLK_R: length 39.8
  BOTTOM w0.076: 110.54,85.11 108.99,85.11 UC1.AV2
  BOTTOM w0.102: 118.19,91.25 117.48,91.96 117.02,91.96 116.59,91.53 116.59,90.92 116.39,90.72 115.98,90.72 114.88,91.82 114.7,91.82 114.51,91.63 114.51,91.31 116.1,89.73 116.1,89.05 116,88.95 115.96,88.95 115.86,88.85 115.86,88.57 115.96,88.46 116,88.46 116.1,88.36 116.1,88.08 116,87.98 115.96,87.98 115.86,87.88 115.86,87.6 115.96,87.5 116,87.5 116.1,87.4 116.1,86.18 115.92,86.01 115.77,86.01 115.56,86.22 115.42,86.22 115.27,86.07 115.27,85.93 115.49,85.72 115.49,85.57 115.34,85.43 115.2,85.43 114.99,85.64 114.84,85.64 114.7,85.5 114.7,85.35 114.91,85.14 114.91,85 114.71,84.8 114.71,83.27 113.68,82.23 113.42,82.23 113.21,82.44 113.21,82.59 113.6,82.98 113.6,83.12 113.4,83.32 113.26,83.32 112.87,82.93 112.72,82.93 110.54,85.11
  BOTTOM w0.114: 118.19,91.25 119.72,91.25 119.83,91.14 119.83,91.01 119.95,90.9 120.21,90.9 120.33,91.01 120.33,91.11 120.44,91.23 120.71,91.23 120.82,91.11 120.82,91.01 120.94,90.9 121.2,90.9 121.32,91.01 121.32,91.16 121.43,91.28 121.7,91.28 121.81,91.16 121.81,91.01 121.93,90.9 122.19,90.9 122.31,91.01 122.31,91.21 122.42,91.33 122.69,91.33 122.8,91.21 122.8,91.01 122.92,90.9 123.18,90.9 123.3,91.01 123.3,91.21 123.51,91.43 125.41,91.43 125.56,91.28 125.56,91.05 125.43,90.92 124.97,90.92 124.77,90.72 124.77,90.54 124.9,90.41 125.02,90.41 v2(125.25,90.18) 125.91,89.52 126.27,89.52 126.63,89.88 RC380.2
SPI_CS0#_8MB: length 135.7
  TOP w0.114: v3(146.91,84.27) 147.68,84.27 v4(148.11,83.83) 152.69,83.83 v3(153.8,84.95)
  IN1 w0.14: v3(153.8,84.95) 153.8,85.52 155.67,87.39 155.67,89.79 157.14,91.26 157.14,94.23 159.19,96.27 159.19,106.01 157.37,107.82 157.37,111.08 155.44,113.01 155.44,114.99 152.5,117.93 141.08,117.93 140.76,118.25 138.84,118.25 v3(138.13,118.96)
  IN2 w0.14: v3(112.55,85.81) 111.08,84.34 111.08,80.63 113.54,78.17 115.42,78.17 116.69,76.9 123.65,76.9 124.58,75.97 124.58,74.4 124.38,74.2 124.38,73.74 124.94,73.18 129.71,73.18 130.61,72.28 130.61,71.7 131.32,70.98 133.02,70.98 133.28,70.73 146.18,70.73 147.73,72.28 147.73,75.96 147.28,76.41 147.28,82.52 146.91,82.89 v3(146.91,84.27)
  BOTTOM w0.076: v3(112.55,85.81) 110.1,85.81 109.94,85.97 109.55,85.97 109.14,85.81 108.85,85.81 108.59,85.54 UC1.AU3
  BOTTOM w0.114: v3(138.13,118.96) 138.13,119.72 137.88,119.98 137.01,119.98 136.66,119.62 136.66,118.33 136.9,118.09 137.92,118.09 138.03,117.97 RC311.2 138.03,117.44 137.79,117.2 136.14,117.2 135.03,118.3 UC8M2.1
SPI_CS1#_4MB: length 188.7
  TOP w0.114: UC4M1.1 227.23,23.71 227.72,23.23 v1(229.47,23.23) ; v3(146.95,75.96) 151.29,75.96 156.77,70.47 156.77,65.95 v3(157.38,65.34)
  IN2 w0.14: v3(112.55,85.16) 111.33,83.94 111.33,80.76 111.58,80.52 111.78,80.52 112.54,81.28 112.74,81.28 112.91,81.11 112.91,80.92 112.15,80.15 112.15,79.95 112.32,79.78 112.51,79.78 114.37,81.64 114.62,81.64 114.78,81.49 114.78,81.31 112.88,79.41 112.88,79.21 113.05,79.04 113.25,79.04 115.16,80.95 115.38,80.95 115.55,80.79 115.55,80.61 113.99,79.05 113.99,78.69 114.23,78.45 115.52,78.45 115.89,78.82 115.89,79.55 116.06,79.72 116.44,79.72 116.54,79.62 116.54,77.43 116.8,77.17 117.14,77.17 117.28,77.31 117.28,78.64 117.47,78.83 117.67,78.83 117.8,78.7 117.8,77.31 117.94,77.17 118.18,77.17 118.32,77.31 118.32,77.47 118.46,77.61 118.7,77.61 118.84,77.47 118.84,77.31 118.98,77.17 119.22,77.17 119.36,77.31 119.36,77.47 119.5,77.61 119.74,77.61 119.88,77.47 119.88,77.31 120.02,77.17 120.26,77.17 120.4,77.31 120.4,77.47 120.54,77.61 120.78,77.61 120.92,77.47 120.92,77.31 121.06,77.17 123.76,77.17 124.85,76.08 124.85,74.82 126.22,73.45 129.82,73.45 130.87,72.39 130.87,71.81 131.42,71.26 133.15,71.26 133.42,70.99 145.94,70.99 147.4,72.46 147.4,75.5 v3(146.95,75.96)
  BOTTOM w0.076: UC1.AU2 109.18,85.54 109.32,85.68 109.33,85.69 109.33,85.69 109.58,85.81 109.87,85.81 110.05,85.63 112.08,85.63 v3(112.55,85.16)
  BOTTOM w0.114: v1(229.47,23.23) 225.08,23.23 217.79,30.52 209.38,30.52 206.18,33.72 192.46,33.72 190.18,36.01 189.21,36.01 187.66,37.56 180.09,37.56 172.29,45.35 171.22,45.35 169.06,47.51 163.29,53.28 163.29,58.37 158.86,62.8 158.86,63.87 v3(157.38,65.34)
SPI_CS2#_TPM: length 179.7
  IN1 w0.14: v3(116.54,114.16) 116.54,114.57 117.96,115.99 119.26,115.99 121.19,117.92 121.46,117.92 121.87,118.33 122.15,118.33 122.62,118.8 122.62,119.43 123.17,119.98 127.11,119.98 128.76,118.33 129.98,118.33 130.15,118.51 136.1,118.51 138.28,116.32 151.19,116.32 153.98,113.53 153.98,109.51 157.95,105.55 157.95,96.59 155.35,93.99 155.35,92.17 155.71,91.81 v3(155.84,91.81)
  IN2 w0.14: v3(145.1,84.61) 144.23,83.73 144.23,82.16 146.49,79.9 146.49,72.89 144.88,71.29 133.5,71.29 133.25,71.54 131.53,71.54 131.15,71.92 131.15,72.5 129.93,73.71 126.33,73.71 125.11,74.93 125.11,76.19 124.73,76.58 124.73,78.11 124.59,78.25 122.61,78.25 122.48,78.38 122.48,78.6 122.65,78.77 125.33,78.77 125.47,78.91 125.47,79.15 125.33,79.29 122.17,79.29 122.03,79.43 122.03,79.67 122.17,79.81 125.36,79.81 125.48,79.94 125.48,80.2 125.36,80.33 123.95,80.33 123.81,80.47 123.81,80.71 123.95,80.85 125.82,80.85 125.95,80.98 125.95,81.21 125.79,81.37 123.64,81.37 123.5,81.51 123.5,81.75 123.64,81.89 125.22,81.89 125.34,82.02 125.34,82.25 125.18,82.41 123.95,82.41 123.81,82.55 123.81,82.8 123.95,82.94 125.72,82.94 125.85,83.06 125.85,83.27 125.66,83.46 123.95,83.46 123.81,83.6 123.81,83.84 123.95,83.98 125.23,83.98 125.53,84.28 125.53,84.56 125.13,84.96 123.36,84.96 122.73,84.33 122.73,81.23 120.68,79.19 117.71,79.19 114.59,82.31 113.37,82.31 112.05,83.63 112.05,84.01 v3(112.55,84.52)
  IN3 w0.114: v3(155.84,91.81) 155.84,90.76 152.92,87.85 151.01,87.85 148.72,85.56 146.79,85.56 145.84,84.61 v3(145.1,84.61)
  BOTTOM w0.076: v3(112.55,84.52) 111.62,85.45 109.77,85.45 UC1.AU1
  BOTTOM w0.114: v3(116.54,114.16) 116.54,114.31 116.8,114.56 R9482.1
SPI_CS2_R: length 20.6
  IN1 w0.14: v3(116.87,117.01) 117,117.01 118.73,118.73 120.83,118.73 v3(121.19,119.09)
  BOTTOM w0.114: R9482.2 116.8,116.8 116.87,116.87 v3(116.87,117.01) 116.92,117.05 UTPM1.20 ; v3(121.19,119.09) 121.19,119.14 122.84,120.79 v4(122.84,121.25) 122.84,124.04 122.43,124.45 120.66,124.45 120.3,124.8 118.04,124.8 117,125.85 116.44,125.85 116.16,126.13 R9491.2
SPI_FMISO: length 231.3
  TOP w0.114: v3(178.2,40.53) 178.2,39.69 178.31,39.58 178.99,39.58 179.1,39.46 179.1,39.23 178.99,39.12 177.84,39.12 177.73,39.23 177.73,41.2 177.61,41.31 177.39,41.31 177.27,41.2 177.27,39.23 177.16,39.12 176.93,39.12 176.81,39.23 176.81,41.2 176.7,41.31 175.58,41.31 175.47,41.2 175.47,40.94 175.58,40.83 176.27,40.83 176.38,40.71 176.38,40.48 176.27,40.37 174.77,40.37 174.66,40.25 174.66,40.03 174.77,39.91 176.27,39.91 176.38,39.8 176.38,39.57 176.27,39.45 175.05,39.45 174.94,39.34 174.94,38.78 175.05,38.66 178.99,38.66 179.1,38.55 179.1,38.32 178.99,38.21 176.4,38.21 176.28,38.09 176.28,37.82 176.55,37.56 179.41,37.56 179.53,37.67 179.53,40.24 179.64,40.35 179.87,40.35 179.98,40.24 179.98,37.67 180.1,37.56 180.33,37.56 180.44,37.67 180.44,40.34 180.56,40.45 180.78,40.45 180.9,40.34 180.9,39.81 181.01,39.69 181.43,39.69 181.54,39.58 181.54,39.35 181.43,39.24 181.01,39.24 180.9,39.12 180.9,38.89 181.01,38.78 181.43,38.78 181.54,38.67 181.54,38.44 181.43,38.32 181.01,38.32 180.9,38.21 180.9,37.67 181.01,37.56 v4(181.39,37.56) 181.51,37.43 181.78,37.43 181.9,37.54 181.9,39.04 182.01,39.16 182.24,39.16 182.35,39.04 182.35,37.54 182.47,37.43 182.7,37.43 182.81,37.54 182.81,38.1 182.93,38.22 183.15,38.22 183.27,38.1 183.27,37.54 183.38,37.43 183.61,37.43 183.73,37.54 183.73,38.1 183.84,38.22 184.07,38.22 184.18,38.1 184.18,37.54 184.3,37.43 184.53,37.43 184.64,37.54 184.64,38.1 184.75,38.22 184.98,38.22 185.1,38.1 185.1,37.54 185.21,37.43 186.42,37.43 187.66,38.67 188.65,38.67 189.24,39.26 189.24,41.4 189.71,41.87 UE1.103
  IN1 w0.14: v3(138.84,118.96) 139.27,118.53 140.93,118.53 141.26,118.2 152.61,118.2 152.79,118.02 152.99,118.02 153.16,118.19 153.36,118.19 153.56,117.99 153.56,117.79 153.39,117.62 153.39,117.42 153.58,117.23 153.78,117.23 153.95,117.4 154.15,117.4 154.35,117.2 154.35,117 154.18,116.83 154.18,116.63 155.76,115.05 155.76,113.07 157.64,111.19 157.64,107.96 159.89,105.71 159.89,105.53 159.75,105.39 159.61,105.39 159.47,105.25 159.47,104.97 159.61,104.83 159.75,104.83 159.89,104.7 159.89,104.42 159.75,104.28 159.61,104.28 159.47,104.14 159.47,103.86 159.61,103.72 159.75,103.72 159.89,103.58 159.89,103.3 159.75,103.16 159.61,103.16 159.47,103.02 159.47,102.74 159.61,102.6 159.75,102.6 159.89,102.46 159.89,102.18 159.75,102.04 159.61,102.04 159.47,101.9 159.47,101.62 159.61,101.48 159.75,101.48 159.89,101.34 159.89,101.06 159.75,100.92 159.61,100.92 159.47,100.78 159.47,100.5 159.61,100.36 159.75,100.36 159.89,100.22 159.89,99.95 159.75,99.81 159.61,99.81 159.47,99.67 159.47,99.39 159.61,99.25 159.75,99.25 159.89,99.11 159.89,98.83 159.75,98.69 159.61,98.69 159.47,98.55 159.47,98.27 159.61,98.13 159.75,98.13 159.89,97.99 159.89,96.59 157.41,94.12 157.41,91.15 155.94,89.68 155.94,88.94 156.08,88.8 156.91,88.8 157.05,88.66 157.05,85.45 156.91,85.31 156.64,85.31 156.5,85.45 156.5,88.1 156.36,88.24 156.08,88.24 155.94,88.1 155.94,87.27 155.81,87.15 155.81,86.95 156.07,86.68 156.07,86.49 155.88,86.29 155.68,86.29 155.41,86.55 155.22,86.55 154.69,86.03 154.69,85.81 154.83,85.67 155.9,85.67 156.04,85.53 156.04,85.25 155.9,85.11 154.53,85.11 154.39,84.97 154.39,84.69 154.53,84.55 155.54,84.55 155.68,84.41 155.68,84.13 155.54,83.99 154.83,83.99 154.69,83.85 154.69,81.07 154.55,80.93 154.32,80.93 154.18,81.07 154.18,84.33 154.04,84.47 153.79,84.47 153.65,84.33 153.65,80.87 157.79,76.73 157.79,74.36 160.77,71.38 162.42,71.38 162.76,71.04 162.76,70.84 162.35,70.43 162.35,70.23 162.55,70.03 162.75,70.03 163.16,70.45 163.36,70.45 163.55,70.25 163.55,70.05 163.14,69.64 163.14,69.44 163.34,69.24 163.54,69.24 163.95,69.65 164.15,69.65 164.34,69.46 164.34,69.26 163.93,68.85 163.93,68.65 164.13,68.45 164.33,68.45 164.74,68.86 164.94,68.86 165.14,68.67 165.14,68.47 164.72,68.06 164.72,67.86 164.92,67.66 165.12,67.66 165.53,68.07 165.73,68.07 165.93,67.88 165.93,67.68 165.51,67.27 165.51,67.07 165.71,66.87 165.91,66.87 166.32,67.28 166.52,67.28 166.72,67.09 166.72,66.89 166.3,66.48 166.3,66.28 166.5,66.08 166.7,66.08 167.11,66.49 167.31,66.49 168,65.8 168,64.66 168.76,63.9 168.96,63.9 169.27,64.21 169.47,64.21 169.67,64.01 169.67,63.81 169.36,63.5 169.36,63.3 169.55,63.11 169.75,63.11 170.06,63.42 170.26,63.42 170.46,63.22 170.46,63.02 170.15,62.71 170.15,62.51 171.62,61.04 171.62,58.32 171.76,58.18 172.28,58.18 172.42,58.04 172.42,57.76 172.28,57.62 171.76,57.62 171.62,57.48 171.62,56.92 171.9,56.64 172.1,56.64 172.58,57.12 172.77,57.12 172.97,56.92 172.97,56.72 172.5,56.25 172.5,56.05 173.31,55.23 v3(173.31,54.9) ; v1(179.06,54.52) 179.13,54.46 179.13,54.14 179.81,53.46 179.81,51.51 179.67,51.37 178.48,51.37 178.34,51.24 178.34,50.96 178.48,50.82 179.67,50.82 179.81,50.68 179.81,50.48 178.2,48.87 178.2,47.4 178.34,47.26 178.96,47.26 179.1,47.12 179.1,46.84 178.96,46.7 178.34,46.7 178.2,46.56 178.2,46.29 178.34,46.15 178.96,46.15 179.1,46.01 179.1,45.73 178.96,45.59 178.34,45.59 178.2,45.45 178.2,45.17 178.34,45.03 178.96,45.03 179.1,44.89 179.1,44.61 178.96,44.47 178.34,44.47 178.2,44.33 178.2,44.05 178.34,43.91 178.96,43.91 179.1,43.77 179.1,43.49 178.96,43.35 178.34,43.35 178.2,43.21 178.2,42.93 178.34,42.79 178.96,42.79 179.1,42.65 179.1,42.37 178.96,42.23 178.34,42.23 178.2,42.09 178.2,41.81 178.34,41.68 178.96,41.68 179.1,41.54 179.1,41.26 178.96,41.12 178.34,41.12 178.2,40.98 v3(178.2,40.53)
  IN2 w0.14: v3(173.31,54.9) 173.51,55.11 177.27,55.11 177.86,54.52 v1(179.06,54.52)
  BOTTOM w0.114: v3(138.84,118.96) 139.07,119.19 RC313.1
SPI_FMOSI#: length 222.9
  TOP w0.114: UE1.102 189.31,43.75 192.06,46.5 192.39,46.5 v3(192.97,47.08) ; v4(174.5,54.83) v3(174.5,56.05)
  IN1 w0.14: v3(174.5,56.05) 174.88,56.42 174.88,58.29 173.46,59.7 173.46,61.58 172.2,62.84 172.2,64.7 163.38,73.52 162.21,73.52 160.53,75.2 160.53,76.1 160.67,76.24 161.21,76.24 161.35,76.38 161.35,76.66 161.21,76.8 160.67,76.8 160.53,76.94 160.53,77.22 160.67,77.36 161.21,77.36 161.35,77.5 161.35,77.78 161.21,77.92 160.67,77.92 160.53,78.06 160.53,78.34 160.67,78.48 161.21,78.48 161.35,78.62 161.35,78.9 161.21,79.04 160.67,79.04 160.53,79.18 160.53,79.46 160.67,79.6 161.21,79.6 161.35,79.74 161.35,80.02 161.21,80.16 160.67,80.16 160.53,80.29 160.53,80.57 160.67,80.71 161.21,80.71 161.35,80.85 161.35,81.13 161.21,81.27 160.67,81.27 160.53,81.41 160.53,81.69 160.67,81.83 161.21,81.83 161.35,81.97 161.35,82.25 161.21,82.39 160.67,82.39 160.53,82.53 160.53,82.81 160.67,82.95 161.21,82.95 161.35,83.09 161.35,83.37 161.21,83.51 160.67,83.51 160.53,83.65 160.53,83.93 160.67,84.07 161.21,84.07 161.35,84.21 161.35,84.49 161.21,84.63 160.67,84.63 160.53,84.77 160.53,85.04 160.67,85.18 161.21,85.18 161.35,85.32 161.35,85.6 161.21,85.74 160.67,85.74 160.53,85.88 160.53,89.65 159.33,90.86 159.33,93.04 160.58,94.29 160.58,95.3 161.7,96.42 161.7,96.8 162.82,97.92 162.82,111.83 161.7,112.94 160.99,112.94 160.61,112.56 160.61,112.12 160.75,111.98 162.07,111.98 162.21,111.84 162.21,111.56 162.07,111.42 160.75,111.42 160.61,111.28 160.61,111 160.75,110.86 162.07,110.86 162.21,110.72 162.21,110.44 162.07,110.3 160.75,110.3 160.61,110.16 160.61,109.77 160.81,109.56 162.12,109.56 162.26,109.42 162.26,98.22 162.12,98.08 161.84,98.08 161.7,98.22 161.7,106.29 161.54,106.46 161.54,106.65 161.91,107.03 161.91,107.22 161.71,107.42 161.51,107.42 161.14,107.05 160.94,107.05 160.74,107.25 160.74,107.44 161.89,108.59 161.89,108.79 161.7,108.99 161.5,108.99 160.35,107.84 160.15,107.84 159.42,108.57 159.42,112.71 157.97,114.16 157.97,116.42 152.58,121.81 134.8,121.81 134.25,122.35 128.5,122.35 v1(127.88,122.98)
  IN2 w0.14: v3(192.97,47.08) 192.97,48.8 187.73,54.04 186.79,54.04 186.65,54.18 186.65,57.62 186.51,57.76 186.23,57.76 186.09,57.62 186.09,54.18 185.95,54.04 185.68,54.04 185.54,54.18 185.54,57.66 185.4,57.8 185.12,57.8 184.98,57.66 184.98,54.18 184.84,54.04 184.56,54.04 184.42,54.18 184.42,55.73 184.28,55.87 184,55.87 183.86,55.73 183.86,54.18 183.72,54.04 183.27,54.04 182.88,54.43 182.88,54.63 183.4,55.16 183.4,55.35 183.2,55.55 183.01,55.55 182.48,55.02 182.28,55.02 182.09,55.22 182.09,55.48 183.32,56.72 183.32,56.92 183.13,57.12 182.93,57.12 181.63,55.81 181.25,55.81 180.96,56.11 180.96,57.69 180.82,57.82 180.54,57.82 180.4,57.69 180.4,56.11 180.26,55.97 177.81,55.97 177.67,56.11 177.67,56.52 177.53,56.66 177.25,56.66 177.11,56.52 177.11,56.11 176.97,55.97 176.69,55.97 176.56,56.11 176.56,56.52 176.42,56.66 176.14,56.66 176,56.52 176,56.11 175.86,55.97 175.58,55.97 175.44,56.11 175.44,58.17 175.3,58.31 175.02,58.31 174.88,58.17 174.88,56.11 174.74,55.97 174.58,55.97 v3(174.5,56.05)
  BOTTOM w0.114: RC312.1 v1(127.88,122.98)
SPI_FSCK: length 224.4
  TOP w0.114: v3(174.52,37.84) 174.52,37.18 v4(174.73,36.97) 174.92,36.79 182.55,36.79 182.67,36.67 182.67,36.44 182.55,36.33 176.75,36.33 176.64,36.22 176.64,35.99 176.75,35.87 182.78,35.87 183.69,36.79 186.79,36.79 187.92,37.91 188.77,37.91 189.85,39 189.85,41.05 190.51,41.71 UE1.105
  IN1 w0.14: v3(125.43,121.99) 126.45,121.99 126.47,121.96 134.09,121.96 134.63,121.41 144.55,121.41 144.69,121.27 144.69,120.6 144.83,120.46 145.11,120.46 145.24,120.6 145.24,121.27 145.38,121.41 145.66,121.41 145.8,121.27 145.8,120.6 145.94,120.46 146.22,120.46 146.36,120.6 146.36,121.27 146.5,121.41 146.78,121.41 146.92,121.27 146.92,120.6 147.06,120.46 147.34,120.46 147.48,120.6 147.48,121.27 147.62,121.41 147.9,121.41 148.04,121.27 148.04,120.6 148.18,120.46 148.46,120.46 148.6,120.6 148.6,121.27 148.74,121.41 149.02,121.41 149.16,121.27 149.16,120.6 149.3,120.46 149.58,120.46 149.72,120.6 149.72,121.27 149.85,121.41 150.13,121.41 150.27,121.27 150.27,120.6 150.41,120.46 150.69,120.46 150.83,120.6 150.83,121.27 150.97,121.41 151.25,121.41 151.39,121.27 151.39,120.6 151.53,120.46 151.81,120.46 151.95,120.6 151.95,121.27 152.09,121.41 152.4,121.41 157.57,116.24 157.57,113.97 159.01,112.54 159.01,108.35 161.3,106.06 161.3,96.57 159.71,94.98 159.71,94.78 160,94.49 160,94.29 159.8,94.1 159.6,94.1 159.31,94.39 159.11,94.39 158.94,94.21 158.94,90.69 159.31,90.32 159.31,90.13 158.85,89.67 158.85,89.48 159.05,89.28 159.25,89.28 159.7,89.73 159.9,89.73 160.13,89.5 160.13,89.18 159.99,89.04 159.53,89.04 159.39,88.9 159.39,88.62 159.53,88.48 159.99,88.48 160.13,88.34 160.13,88.06 159.99,87.92 159.53,87.92 159.39,87.78 159.39,87.5 159.53,87.36 159.99,87.36 160.13,87.23 160.13,86.85 159.99,86.71 159.15,86.71 159.01,86.57 159.01,76.56 159.15,76.42 159.43,76.42 159.57,76.56 159.57,86.01 159.71,86.15 159.99,86.15 160.13,86.01 160.13,75.02 162.08,73.06 163.28,73.06 171.81,64.54 171.81,62.68 173.07,61.42 173.07,59.49 174.49,58.07 174.49,56.76 174.05,56.33 174.05,55.76 174.28,55.54 174.28,54.6 173.49,53.81 173.49,49.69 173.35,49.55 172.66,49.55 172.52,49.41 172.52,49.13 172.66,48.99 173.35,48.99 173.49,48.85 173.49,48.57 173.35,48.43 172.66,48.43 172.52,48.29 172.52,48.01 172.66,47.87 173.35,47.87 173.49,47.73 173.49,47.45 173.35,47.31 172.66,47.31 172.52,47.17 172.52,46.89 172.66,46.75 173.35,46.75 173.49,46.61 173.49,44.77 173.29,44.57 173.1,44.57 171.96,45.71 171.76,45.71 171.56,45.51 171.56,45.31 172.7,44.18 172.7,43.98 172.5,43.78 172.3,43.78 171.17,44.92 170.97,44.92 170.72,44.67 170.72,38.51 170.86,38.37 171.14,38.37 171.28,38.51 171.28,43.41 171.42,43.55 171.7,43.55 171.84,43.41 171.84,39.03 172.14,38.73 173.27,38.73 174.47,39.93 174.67,39.93 174.87,39.73 174.87,39.53 173.67,38.33 173.67,38.14 173.97,37.84 v3(174.52,37.84)
  BOTTOM w0.114: RC314.1 125.89,122.44 v3(125.43,121.99)
SPI_IO2: length 147.1
  TOP w0.114: v3(145.88,86.78) 149.35,86.78 150.87,85.26 v3(152.1,85.26)
  IN1 w0.14: v3(152.1,85.26) 152.28,85.26 154.81,87.79 154.81,90.06 155.08,90.33 155.08,94.16 157.66,96.74 157.66,104.77 153.7,108.73 153.7,112.46 151,115.17 139.06,115.17 135.99,118.24 130.26,118.24 130.09,118.06 128.65,118.06 127,119.71 125.38,119.71 122.96,117.29 121.3,117.29 118.81,114.79 118.81,111.76 118.95,111.62 118.95,111.16 v1(119.02,111.09) ; v3(145.88,86.78) 144.85,87.81 141.45,87.81 140.51,88.75 134.36,88.75 133.46,87.85 129.24,87.85 128.65,87.26 124.48,87.26 123.4,86.17 123.4,82.07 120.93,79.61 118.11,79.61 115.57,82.15 112.79,82.15 v3(112.34,81.7)
  BOTTOM w0.076: UC1.AW2 109.16,84.39 109.81,84.39 110.11,84.08 110.75,84.08 112.34,82.5 v3(112.34,81.7)
  BOTTOM w0.114: 126.03,118.49 125.3,117.77 123.04,117.77 122.32,117.04 122.32,116.27 121.6,115.55 121.6,111.23 120.75,110.38 RC117.2 119.73,110.38 v1(119.02,111.09) ; 126.03,118.49 126.9,118.49 128.09,117.31 RPC24.5 ; 126.03,118.49 RPC23.5
SPI_IO2_4MB: length 183.6
  TOP w0.114: v3(222,21.12) 221.93,21.2 v4(221.93,21.86) 222.54,22.47 223.81,22.47 224.69,23.36 UC4M1.3
  IN2 w0.14: v3(149.28,119.52) 148.7,120.11 145.99,120.11 v3(145.39,119.5)
  BOTTOM w0.114: v3(149.28,119.52) 149.28,119.39 157.44,111.23 157.44,97.13 154.96,94.65 153.77,94.65 152.25,93.14 152.25,89.37 152.63,88.99 152.63,84.28 154.57,82.35 154.57,71.16 153.67,70.26 153.67,67.76 155.96,65.47 155.96,64.96 157.93,62.99 157.93,62.48 162.45,57.96 162.45,53.09 171.08,44.46 171.99,44.46 179.81,36.64 186.78,36.64 190.69,32.74 205.62,32.74 208.8,29.56 215.99,29.56 222,23.55 v3(222,21.12) ; RPC24.4 128.09,114.62 128.91,113.79 130.09,113.79 130.9,114.61 130.9,114.92 132.12,116.14 134.91,116.14 135.63,115.42 142.11,115.42 145.39,118.7 v3(145.39,119.5)
SPI_IO2_8MB: length 8.5
  BOTTOM w0.114: RPC23.4 126.03,121.31 126.23,121.52 130.09,121.52 132.49,119.12 UC8M2.3
SPI_IO3: length 155.8
  TOP w0.114: v1(128.9,119.17) 128.26,118.53 124.01,118.53 v1(123.37,119.17) ; v3(145.22,85.26) 145.68,85.71 146.69,85.71 148.14,84.27 v4(150.78,84.27) 151.8,84.27 v3(152.08,84.55)
  IN1 w0.14: v1(128.9,119.17) 128.95,119.12 136.38,119.12 138.39,117.11 151.26,117.11 154.57,113.81 154.57,109.75 158.6,105.72 158.6,96.44 156.61,94.45 156.61,91.48 155.14,90.01 155.14,87.61 v3(152.08,84.55)
  IN2 w0.14: v3(112.55,83.86) 113.82,82.59 114.89,82.59 117.96,79.52 120.63,79.52 122.46,81.35 122.46,84.44 123.25,85.23 125.36,85.23 126.35,84.24 126.35,79.21 125,77.87 125,76.69 125.38,76.3 125.38,75.4 126.8,73.98 130.23,73.98 130.51,73.7 136.64,73.7 137.39,72.94 137.39,72.3 138.03,71.67 144.89,71.67 146.11,72.89 146.11,79.75 143.82,82.03 143.82,84.11 144.96,85.26 v3(145.22,85.26)
  BOTTOM w0.076: v3(112.55,83.86) 111.14,85.28 108,85.28 UC1.AU4
  BOTTOM w0.114: RC118.2 RC394.1 121.62,118.09 122.7,119.17 v1(123.37,119.17) 123.81,119.6 124.44,119.6 124.53,119.69 RPC23.8 ; v1(128.9,119.17) 129.58,118.48 RPC24.8
SPI_IO3_4MB: length 187.3
  TOP w0.114: v3(222.1,18.71) 222.1,16.5 223.3,15.31 v4(225.46,15.31) 225.61,15.31 225.96,15.66 UC4M1.7
  IN2 w0.14: v3(143.76,119.5) 143.76,119.65 144.77,120.66 149.51,120.66 v3(150.65,119.52)
  BOTTOM w0.114: v3(150.65,119.52) 150.65,118.73 157.95,111.44 157.95,96.92 155.17,94.15 153.98,94.15 152.76,92.93 152.76,89.8 153.14,89.42 153.14,84.49 155.21,82.42 155.21,70.87 154.15,69.81 154.15,68.04 156.5,65.69 156.5,65.19 158.49,63.2 158.49,62.71 163.01,58.19 163.01,53.22 171.15,45.07 172.22,45.07 180.09,37.2 187.39,37.2 191.25,33.35 205.88,33.35 209.05,30.17 216.06,30.17 222.68,23.55 222.68,19.29 v3(222.1,18.71) ; v3(143.76,119.5) 140.91,116.65 136.14,116.65 135.42,117.37 131.61,117.37 129.91,115.67 129.79,115.67 129.58,115.47 RPC24.1
SPI_IO3_8MB: length 15.1
  BOTTOM w0.114: RPC23.1 124.53,121.25 124.39,121.39 124.39,123.42 124.97,124 124.97,125.03 v2(125.13,125.19) 127.17,127.23 133.17,127.23 133.76,126.63 UC8M2.7
SPI_SI: length 141.4
  TOP w0.114: v3(145.09,86.83) 145.55,87.29 150.58,87.29 v3(151.9,85.97) ; v3(115.91,114.16) 117.93,112.14 118.03,112.14 v4(118.19,111.98) 118.38,111.79 v3(118.38,111.11)
  IN1 w0.14: v3(118.38,111.11) 118.38,110.95 118.79,110.54 119.12,110.54 119.49,110.91 119.49,111.52 119.21,111.79 119.21,112.38 119.92,113.09 119.92,115.52 121.42,117.02 123.39,117.02 v1(125.47,119.1) v1(126.8,119.1) 128.2,117.7 130.11,117.7 130.38,117.97 135.88,117.97 138.95,114.9 150.88,114.9 153.42,112.36 153.42,108.64 157.4,104.66 157.4,96.86 154.81,94.27 154.81,90.44 151.9,87.52 v3(151.9,85.97) ; v3(112.99,81.75) 113.12,81.89 115.32,81.89 117.92,79.29 121.09,79.29 123.75,81.95 123.75,86.12 124.54,86.91 128.99,86.91 129.55,87.47 133.86,87.47 134.88,88.48 140.4,88.48 141.34,87.54 144.38,87.54 v3(145.09,86.83)
  BOTTOM w0.076: v3(112.99,81.75) 112.99,82.11 110.8,84.29 110.14,84.29 109.87,84.56 108.35,84.56 UC1.AV3
  BOTTOM w0.114: v1(125.47,119.1) 125.53,119.16 RPC23.6 ; RC298.1 113.53,113.26 114.8,114.53 115.54,114.53 v3(115.91,114.16) R9479.1 ; v1(126.8,119.1) 128.58,117.32 RPC24.6
SPI_SI_4MB: length 183.6
  TOP w0.114: v1(221.9,20.28) 222.69,20.28 223.42,19.55 UC4M1.5
  IN2 w0.14: v3(144.72,119.5) 144.72,119.7 145.42,120.4 149.07,120.4 v3(149.94,119.52)
  BOTTOM w0.114: v3(144.72,119.5) 144.72,118.73 141.65,115.66 135.73,115.66 135.01,116.38 132.02,116.38 130.66,115.02 130.66,114.71 129.99,114.04 129.01,114.04 128.59,114.46 128.59,114.97 128.58,114.97 RPC24.3 ; v3(149.94,119.52) 149.94,119.09 157.7,111.33 157.7,97.03 155.07,94.4 153.88,94.4 152.51,93.03 152.51,89.57 152.89,89.19 152.89,84.39 154.96,82.32 154.96,71.05 153.91,70 153.91,67.9 156.23,65.58 156.23,65.07 158.24,63.07 158.24,62.61 162.76,58.09 162.76,53.13 171.12,44.77 172.12,44.77 179.94,36.95 187.29,36.95 191.14,33.09 205.77,33.09 208.95,29.92 215.97,29.92 222.44,23.45 222.44,20.82 v1(221.9,20.28)
SPI_SI_8MB: length 9
  BOTTOM w0.114: RPC23.3 125.53,121.32 126.42,122.21 126.42,123.48 126.83,123.89 RC312.2 127.21,123.89 128.14,124.82 130.87,124.82 131.22,125.17 UC8M2.5
SPI_SI_R: length 2.1
  BOTTOM w0.114: UTPM1.21 116.42,116.55 R9479.2
SPI_SO: length 214.9
  TOP w0.114: v3(173.34,57.42) 172.99,57.42 RC102.2 ; v3(110.57,83.43) 111.37,82.63 111.37,80.88 v1(114.67,77.57) 114.99,77.26 RC308.1
  IN1 w0.14: v3(121.82,119.09) 121.82,119.04 121.24,118.45 119.21,118.45 115.45,114.7 115.45,113.91 115.12,113.58 113.52,113.58 v3(112.93,114.16) ; v3(139.68,118.99) 141,118.99 141.52,118.47 153.76,118.47 155.76,116.47 155.76,115.61 156.08,115.29 156.08,113.13 157.91,111.3 157.91,108.07 160.15,105.82 160.15,96.48 157.77,94.09 157.77,85.56 154.96,82.75 154.96,79.94 158.06,76.84 158.06,74.5 160.85,71.71 162.6,71.71 170.77,63.54 170.77,62.3 171.89,61.18 171.89,58.99 173.34,57.54 v3(173.34,57.42) ; v3(120.95,70.72) 121.15,70.72 121.93,69.94 125.84,69.94 128.96,66.82 136.48,66.82 140.44,62.85 147.66,62.85 150.96,59.55 151.77,59.55 154.01,57.32 v1(154.55,57.32)
  IN3 w0.114: v3(120.95,70.72) 120.95,73.38 120.61,73.72 120.61,73.73 120.25,74.09 119.61,74.09 118.8,74.91 116.84,74.91 114.67,77.08 v1(114.67,77.57) ; v1(154.55,57.32) 154.68,57.19 169.65,57.19 170.03,57.57 173.18,57.57 v3(173.34,57.42)
  BOTTOM w0.076: v3(110.57,83.43) 110.47,83.53 110.04,83.53 109.81,83.75 109.33,83.75 109.18,83.91 108.79,83.91 UC1.AW3
  BOTTOM w0.114: v3(139.68,118.99) 139.68,121.88 RC103.2 139.07,125.49 137.09,127.47 125.08,127.47 v2(124.8,127.19) 124.8,125.39 124.57,125.16 124.57,124.49 123.37,123.29 123.37,120.69 121.82,119.14 v3(121.82,119.09) ; R9481.1 113.24,114.77 112.93,114.47 v3(112.93,114.16)
SPI_SO_4MB: length 76.3
  TOP w0.114: v1(223.83,26.48) 224.11,26.2 225.66,26.2 225.96,25.9 UC4M1.2 ; RC102.1 171.94,55.45 171.94,50.61 171.51,50.18 170.54,50.18 v3(170.47,50.26)
  BOTTOM w0.114: v1(223.83,26.48) 223.45,26.86 222.08,26.86 218.04,30.9 209.61,30.9 206.37,34.14 198.75,34.14 197.22,35.66 194.15,35.66 192.41,37.4 191.22,37.4 190.73,37.89 180.19,37.89 172.47,45.61 171.41,45.61 169.68,47.33 169.68,49.47 v3(170.47,50.26)
SPI_SO_8MB: length 17.8
  BOTTOM w0.114: UC8M2.2 133.76,119.37 135,120.61 135,121.91 135.2,122.11 135.43,122.11 135.61,121.93 135.61,120.58 135.73,120.46 135.95,120.46 136.07,120.58 136.07,122.15 136.18,122.26 136.41,122.26 136.53,122.15 136.53,120.58 136.64,120.46 136.87,120.46 136.98,120.58 136.98,122.46 137.1,122.57 137.33,122.57 137.44,122.46 137.44,120.58 137.55,120.46 137.78,120.46 138.16,120.84 RC313.2 RC103.1
SPI_SO_R: length 3
  BOTTOM w0.114: R9481.2 v4(113.24,116.98) 113.24,117.03 114.14,117.93 UTPM1.24
SPK_L1-: length 2.6
  TOP w0.305: 204.48,22.32 204.76,22.32 205.68,21.39 UA1.14
  vias: v4(202.72,22.34)
SPK_L1-_CON: length 175.2
  TOP w0.508: v3(230.64,183.25) 230.21,183.25 v4(229.93,182.97)
  IN1 w0.762: 200.21,23.48 201.25,24.53 201.25,25.85 202.65,27.24 202.65,34.4 204.32,36.07 204.32,37.27 205.21,38.15 205.21,46.45 206.38,47.61 207.02,47.61 209.73,50.33 209.74,50.33 210.19,50.78 210.19,50.79 211.31,51.91 211.31,54.61 211.84,55.14 211.84,56.78 212.07,57.01 212.07,64.6 210.98,65.69 210.98,115.58 218.24,122.85 218.24,130.67 216.39,132.53 216.39,138.94 222.89,145.44 222.89,151.45 225.23,153.79 225.23,158 229.77,162.55 229.77,181.6 230.61,182.44
  vias: v3(199.32,23.51) v3(199.32,22.85) v3(199.35,22.21) v3(230.64,183.89)
SPK_L2+: length 2.5
  TOP w0.305: 205.82,24.02 205.82,22.52 206.15,22.19 UA1.12
  vias: v4(205.37,24.47)
SPK_L2+_CON: length 178.7
  TOP w0.508: v3(231.86,183.28) 231.86,182.62 v4(231.53,182.28)
  IN1 w0.762: 200.26,26.2 200.26,26.29 201.45,27.49 201.45,36.57 203.13,38.24 203.13,42.76 201.83,44.06 201.83,45.86 206.94,50.97 206.94,51.87 207.71,52.64 209.28,52.64 210.29,53.66 210.29,55.03 210.83,55.56 210.83,57.56 208.46,59.92 208.46,63.7 209.96,65.2 209.96,116.09 215.37,121.5 215.37,139.36 221.77,145.76 221.77,151.88 224.21,154.32 224.21,158.43 226.09,160.31 226.09,167.64 225.23,168.5 225.23,173.27 227.67,175.71 227.67,182.36 230.54,185.23 231.83,185.23
  vias: v3(199.4,25.9) v3(199.4,25.24) v3(199.4,24.6) v3(231.86,183.91)
SPK_R1-: length 2.3
  TOP w0.203: UA1.15 205.6,20.99 205.37,21.22 205.14,21.22 204.88,21.48 v4(204.63,21.48)
SPK_R1-_CON: length 183.8
  TOP w0.508: v4(233.13,183.02) v3(233.13,185)
  IN1 w0.762: 200.16,20.94 200.82,20.94 204.93,25.06 204.93,28.13 203.92,29.15 203.92,34.23 205.34,35.65 205.34,36.84 210.65,42.15 210.65,44.67 211.36,45.38 211.36,50.52 212.14,51.3 213.34,51.3 214.15,52.11 214.15,64.31 212.12,66.34 212.12,115.03 219.26,122.16 219.26,131.09 217.4,132.95 217.4,138.29 223.93,144.82 223.93,151.04 228.07,155.18 228.07,159.35 230.79,162.07 230.79,179.26 233.13,181.6 233.13,183.96
  vias: v3(199.35,21.2) v3(199.37,20.56) v3(199.37,19.93) v3(233.13,185.64)
SPK_R2+: length 3
  TOP w0.305: 204.07,19.32 204.94,20.19 UA1.17
  vias: v4(202.72,19.22)
SPK_R2+_CON: length 184.7
  TOP w0.508: v3(234.37,185) 234.37,184.39 v4(234.63,184.14)
  IN1 w0.762: 200.16,18.84 201.86,18.84 202.75,19.72 202.75,20.49 205.95,23.69 205.95,34.28 213.42,41.75 213.42,47.41 215.17,49.16 215.17,64.73 213.29,66.61 213.29,114.67 220.27,121.66 220.27,132.83 226.14,138.7 226.14,143.68 225,144.82 225,150.56 228.26,153.82 229.66,153.82 230.41,154.57 230.41,155.77 231.81,157.16 231.81,178.81 234.32,181.32 234.32,184.09
  vias: v3(199.27,18.73) v3(199.27,18.1) v3(199.29,17.46) v3(234.37,185.64)
SPKR_MUTE#: length 7.5
  TOP w0.114: v3(216.41,22.85) 216.95,22.32 RA29.2 217.25,22.54 DA5.2 ; UA1.39 213.16,22.19 v5(213.21,22.24)
  BOTTOM w0.114: v5(213.21,22.24) 213.44,22.01 216.01,22.01 216.41,22.42 v3(216.41,22.85)
SPLL_PVDD: length 13.2
  TOP w0.114: LV4.2 162.5,160.92 161.68,160.92 v4(161.58,161.03)
  TOP w0.381: LV4.2 162.55,160.78 CV222.1 162.48,159.63 CV225.1 CV221.1 160.15,159.63 156.03,155.5 v1(154.15,155.5)
  BOTTOM w0.381: UV1.AM10 153.8,155.85 v1(154.15,155.5)
SPLL_VDDC: length 13.7
  TOP w0.381: CV223.1 163.43,164.2 160.04,160.81 160.04,160.35 156.83,157.15 v1(155.02,157.15)
  BOTTOM w0.381: v1(155.02,157.15) 154.99,157.15 UV1.AN9
  vias: v4(165.66,165.14)
SRN: length 4.1
  BOTTOM w0.203: PR128.2 178.17,176.57 178.17,174.96 v4(178.09,174.87) 177.69,174.47 PU101.19
SRP: length 2.8
  BOTTOM w0.203: PU101.20 178.09,174.24 178.62,174.77 178.62,175.81 PR125.2
SSD_DEVSLP1: length 17.1
  TOP w0.114: v3(123.17,100.7) 123.32,100.55 TC27.1
  IN2 w0.14: v3(123.17,100.7) 122.69,101.18 121.65,101.18 119.84,99.38 117.29,99.38 116.9,99.77 114.81,99.77 113.49,101.08 112.55,101.08 v3(111.92,100.45)
  BOTTOM w0.076: UC1.J2 109.18,100.13 109.33,99.98 109.58,99.86 109.92,99.86 110.19,100.13 111.27,100.13 111.59,100.45
  BOTTOM w0.102: 111.59,100.45 v3(111.92,100.45)
SUS_STAT#: length 15
  TOP w0.114: v3(106.42,77.53) 106.42,70.51 106.86,70.07 RC47.1
  BOTTOM w0.076: 104.1,80.74 103.29,81.54 103.29,82.72 UC1.BA11
  BOTTOM w0.102: 104.1,80.74 106.42,78.41 v3(106.42,77.53)
SUSACK#: length 21.7
  TOP w0.114: RC109.1 113.34,73.32 v3(112.81,73.32)
  IN3 w0.076: 102.88,84.33 102.88,84.93 102.52,85.29 102.52,86.63 v3(102.91,87.02)
  IN3 w0.114: 102.88,84.33 103.85,83.36 104.6,83.36 105.59,82.36 107.22,82.36 110.79,78.79 110.79,78.01 112.81,75.99 v3(112.81,73.32)
  BOTTOM w0.076: UC1.AP11 103.29,87.4 v3(102.91,87.02)
SUSCLK_32K: length 269.1
  IN3 w0.114: v3(248.29,171.39) 249.55,170.13 249.55,162.01 248.74,161.2 248.74,147.32 238.5,137.09 231.05,137.09 226.76,132.79 226.76,131.02 220.33,124.58 220.33,109.1 207.74,96.51 207.74,96.01 207.18,95.45 204.41,95.45 198.05,101.82 198.05,103.61 197.27,104.39 196.05,104.39 195.74,104.08 177.09,104.08 176.17,103.16 173.38,103.16 162.89,92.67 162.89,76.47 161.29,74.87 160.25,74.87 158.44,76.68 151.45,76.68 150.78,76.01 150.78,72.19 148.98,70.38 148.98,67.05 145.75,63.82 140.93,63.82 135.71,69.04 128.39,69.04 126.89,67.54 124.96,67.54 124.45,68.05 124.45,68.87 124.8,69.22 v3(124.8,72.07)
  BOTTOM w0.076: 105.21,70.17 103.02,72.37 103.02,78.31 100.21,81.12 100.21,82.52 99.94,82.78 UC1.BA17
  BOTTOM w0.114: 105.21,70.17 107.77,67.62 110.29,67.62 112.8,65.1 116.81,65.1 117.25,64.66 117.94,64.66 118.12,64.48 118.67,64.48 118.99,64.8 120.36,64.8 120.45,64.89 121.1,64.89 121.42,65.21 121.42,68.34 121.09,68.67 121.09,69.18 122.23,70.32 123.04,70.32 v3(124.8,72.07) ; v3(248.29,171.39) 248.53,171.15 JWLBT.50
SUSP: length 413.8
  TOP w0.114: v3(205.92,139.49) R156.2 R157.2 Q6.6 206.94,138.53 207.1,138.37 207.45,138.37 207.59,138.51 Q6.5
  IN1 w0.14: v3(174.83,14.39) 176.19,15.75 176.19,39.78 177.54,41.12 177.54,52.63 178.01,53.1 178.01,54.55 178.97,55.51 178.97,60.26 176.56,62.68 176.56,64.38 177.43,65.24 180.33,65.24 181.22,64.35 187.18,64.35 189.41,66.59 191.58,66.59 202.2,77.21 202.2,94.19 201.22,95.17 201.22,110.71 200.79,111.15 200.79,116.43 201.22,116.87 201.22,119.11 203.23,121.11 203.23,127.94 202.16,129 202.16,131.63 202.65,132.11 202.65,132.55 202.4,132.81 202.4,138.19 203.69,139.49 v3(205.92,139.49)
  IN3 w0.114: v3(174.83,14.39) 174.35,13.91 152.08,13.91 148.13,9.96 141.15,9.96 136.51,5.32 122.36,5.32 117.99,9.69 111.36,9.69 110.53,10.53 35.05,10.53 24.47,21.11 21.72,21.11 15.02,27.82 15.02,37.82 18.8,41.61 18.8,51.06 13.85,56.01 13.85,68.82 17.09,72.06 17.09,77.6 16.73,77.97 16.73,88.73 17.82,89.83 17.82,92.91 20.58,95.67 v3(20.58,96.1)
  BOTTOM w0.114: Q22.2 16.16,98.95 17.15,99.94 17.86,99.94 18.52,99.28 18.52,98.69 v2(19.61,97.6) 20.58,96.64 v3(20.58,96.1)
SUSP#: length 266.6
  TOP w0.114: 183.47,24.68 183.5,24.68 183.77,24.95 U11.3 ; 183.47,24.68 184.21,23.94 184.84,23.94 185.05,24.14 185.46,24.14 U11.5 ; 183.47,24.68 v3(183.29,24.68) ; v3(134.19,44.31) 134.93,43.58 137.88,43.58 v4(138.36,43.09) 146.77,43.09 149.1,40.76 149.1,40.38 v3(149.66,39.82) ; D63.2 199.76,38.43 v3(199.45,38.11) ; RE53.1 209.57,53.21 D65.2 209.29,54.49 209.29,56.82 v3(209.07,57.04) ; Q6.2 207.59,136.68 208.01,136.26 v3(212.07,136.26)
  TOP w0.14: D15.1 128.89,69.35 129.69,69.35 130.05,69.71 130.05,71.87 v3(130.16,71.97)
  IN1 w0.14: v3(149.66,39.82) 149.69,39.82 150.78,38.72 150.78,26.48 v3(157.41,19.85) ; v3(209.07,57.04) 206.91,59.2 206.91,64.43 207.99,65.5 207.99,69.79 208.59,70.4 208.59,81.85 207.35,83.1 207.35,92.75 208.54,93.94 208.54,124.47 212.02,127.95 212.02,136.21 v3(212.07,136.26)
  IN3 w0.114: v3(157.41,19.85) 158.1,20.54 169.91,20.54 172.04,22.67 178.03,22.67 179.25,23.89 182.51,23.89 v3(183.29,24.68) 186.91,28.3 187.24,28.3 193.17,34.23 193.17,37.43 195.41,39.66 v1(197.16,39.66) ; v3(209.07,57.04) 209.1,57.01 209.1,53.91 210.8,52.21 210.8,51.75 208.3,49.25 208.3,45.16 212.83,40.63 v3(212.83,39.33)
  BOTTOM w0.114: v3(134.19,44.31) 132.75,44.31 132.31,44.74 Q24.2 132.31,46.24 131.91,46.65 130.99,46.65 129.7,47.94 129.7,61.06 127.06,63.7 127.06,65.67 127.44,66.05 127.44,67.03 130.16,69.75 v3(130.16,71.97) ; v1(197.16,39.66) 198.71,38.11 v3(199.45,38.11) 199.75,38.11 200.44,37.43 201.78,37.43 204.36,40 212.16,40 v3(212.83,39.33)
  BOTTOM w0.254: v3(134.19,44.31) PR311.2
SUSP#_EC: length 37.6
  TOP w0.114: D63.1 199.76,39.8 198.99,40.58 198.48,40.58 v3(197.9,41.16) 197.9,41.49 198.11,41.71 UE1.124 ; RPE4.8 210.71,58.31 v4(211.26,57.76) 212.03,56.99 212.88,56.99 214.01,55.85 214.01,50.37 v3(212.4,48.76)
  BOTTOM w0.114: v3(212.4,48.76) 212.4,48.22 211.77,47.59 211.77,45.59 210.47,44.29 206.31,44.29 202.52,40.5 198.56,40.5 v3(197.9,41.16)
SUSWARN#: length 22.1
  TOP w0.114: v3(112.18,73.3) 112.57,72.91 113.08,72.91 113.61,72.38 113.61,72.14 RC109.2
  IN3 w0.076: 102.36,84.84 102.36,86.02 v3(101.99,86.39)
  IN3 w0.114: v3(112.18,73.3) 112.18,76.22 110.55,77.86 110.55,78.73 107.17,82.11 105.47,82.11 104.44,83.13 103.68,83.13 102.36,84.45 102.36,84.84
  BOTTOM w0.076: UC1.AR13 102.36,86.75 v3(101.99,86.39)
SVI2_SVC: length 59.7
  TOP w0.114: v4(219.89,156.95) 219.68,156.95 v3(218.95,156.22)
  TOP w0.254: RV181.2 168.89,157.7 168.15,158.43 RV97.2 168.15,159.86 v3(168.08,159.93)
  IN1 w0.254: v3(168.08,159.93) 168.46,160.31 171.89,160.31 173.29,161.71 180.62,161.71 180.81,161.9 208.09,161.9 211.81,158.18 217,158.18 v3(218.95,156.22)
  BOTTOM w0.254: v3(218.95,156.22) 219.11,156.07 PR609.1
SVI2_SVD: length 65.4
  TOP w0.114: v3(219.77,155.79) 219.03,155.06 v4(218.88,155.06)
  TOP w0.254: RV96.2 166.12,158.61 RV180.2 v3(165.18,158.64)
  IN1 w0.254: v3(219.77,155.79) 219.77,156.25 217.46,158.56 211.97,158.56 208.25,162.28 180.65,162.28 180.49,162.12 173.06,162.12 171.76,160.82 167.37,160.82 v3(165.18,158.64)
  BOTTOM w0.254: v3(219.77,155.79) 220.48,155.08 220.48,154.29 220,153.81 PR615.1
SW_1.00VS: length 1.7
  TOP w0.254: v4(136.91,50.33) v3(136.91,51.17)
  TOP w0.508: PR708.2 v3(136.91,51.17)
SW_1A: length 2.3
  BOTTOM w0.114: v2(70.73,111.29) 70.73,112.24 PR412.2
  BOTTOM w0.254: PR451.2 71.76,112.31 PR412.2
SW_1B: length 2.6
  TOP w0.114: PR438.2 63.84,118.89 63.84,119.52 v4(63.43,119.93)
  TOP w0.254: PR438.2 63.25,118.3 PR459.2
SW_1PH: length 155.9
  TOP w0.254: PR459.1 62.72,116.96 v3(63.49,116.18) ; v4(138.94,80.41) 140.16,80.41 v3(140.19,80.38)
  IN2 w0.254: v1(153.79,93.19) 153.79,95.35 156.08,97.64 156.08,103.89 156.43,104.24 156.43,106.56 153.09,109.89 153.09,113.77 150.81,116.05 135.3,116.05 131.08,120.27 117.89,120.27 117.28,120.88 109.18,120.88 108.08,119.79 104.96,119.79 103.92,118.75 96.67,118.75 95.37,117.45 88.07,117.45 87.13,118.38 86.14,118.38 84.96,117.2 81.19,117.2 81.02,117.03 79.92,115.93 77.1,115.93 76.55,115.37 65.77,115.37 65.41,115.02 64.66,115.02 v3(63.49,116.18)
  IN3 w0.254: v1(134.17,80.99) 134.42,81.24 134.42,83.86 138.49,87.92 140.65,87.92 142.3,86.27 148.36,86.27 150.77,88.69 152.71,88.69 154.87,90.85 154.87,92.04 153.79,93.12 v1(153.79,93.19)
  BOTTOM w0.254: v1(134.17,80.99) 134.6,80.56 PL408.1
  vias: v3(140.85,80.38) v3(141.03,82.16) v3(141.05,81.5)
SW_A1: length 81.6
  TOP w0.254: v3(132.82,107.76) 133.69,108.62 133.69,114.09 134.58,114.97 v3(134.58,115.36)
  IN2 w0.254: v3(74.28,114.47) 74.45,114.29 77.84,114.29 78.25,114.7 79.65,114.7 81.51,116.56 95.43,116.56 96.7,117.83 99.9,117.83 100.13,118.06 107.47,118.06 109.66,120.25 112.45,120.25 113.33,119.37 118.23,119.37 119.49,118.11 125.63,118.11 125.98,117.77 129.7,117.77 130.04,118.11 132.11,118.11 134.58,115.65 v3(134.58,115.36)
  BOTTOM w0.203: v3(74.28,114.47) 73.58,113.77 73.08,113.77 72.88,113.56 72.88,111.66 72.43,111.22 PR451.1
  BOTTOM w0.254: v3(132.82,107.76) 132.95,107.89 PL403.1
  vias: v2(131.07,101.92) v3(129.72,101.54) v3(130.38,101.54) v3(132.16,103.11) v3(132.16,102.48)
SW_B1: length 89.3
  TOP w0.114: 46.87,63.18 v3(46.89,63.16) ; v4(40.82,67.02) 40.82,67.78 v3(40.85,67.81)
  IN2 w0.254: v3(45.52,72.15) 45.52,73.47 41.03,77.97 41.03,92.25 46.92,98.15 46.92,99.04 51.36,103.48 51.36,106.66 52.89,108.18 54.57,108.18 57.18,110.78 57.71,110.78 60.81,113.88 60.81,119.48 61.7,120.36 63.07,120.36 63.58,120.87 63.58,122.36 62.26,123.68 62.26,125.44 63.84,127.01 71.17,127.01 73.51,129.36 v3(73.51,130.29)
  IN3 w0.762: 40.04,68.47 37.75,70.75 37.75,71.13
  BOTTOM w0.254: PL406.1 46.13,71.54 v3(45.52,72.15) ; PR455.1 73.51,129.78 v3(73.51,130.29)
  vias: v3(37.65,72.76) v3(37.65,72.1) v3(40.85,68.52) v3(46.89,62.45)
