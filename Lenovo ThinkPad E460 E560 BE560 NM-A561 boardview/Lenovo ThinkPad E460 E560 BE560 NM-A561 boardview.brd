# Allegro board Lenovo ThinkPad E460 E560 BE560 NM-A561 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB20_P4: length 234.5
  TOP w0.114: R178.1 239.31,180.54 238.85,180.54 238.54,180.23 238.16,180.23 237.9,179.97 v3(237.9,178.02) 237.9,177.63 237.12,176.84 237.12,163.27 239.08,161.3 240.29,161.3 241.76,159.83 241.76,148.48 242.27,147.98 242.27,142.88 240.47,141.09 239.33,141.09 238.39,140.15 235.52,140.15 233.79,138.42 230.74,138.42 225.23,132.91 217.28,132.91 207.09,122.72 207.09,118.88 193.51,105.3 174.71,105.3 162.24,92.83 162.24,91.1 161.85,90.72 157.03,90.72 156.62,90.31 156.62,89.56 v3(156.4,89.35)
  IN3 w0.076: v3(104.67,92.26) 104.91,92.49 104.91,92.64 105.08,92.81 107.56,92.81
  IN3 w0.114: 107.56,92.81 107.83,92.55 108.02,92.55 109.43,91.14 109.43,90.39 109.71,90.11 111.08,90.11 112.76,88.43 115.32,88.43 116.34,89.45 116.34,90.26 116.86,90.78 119.07,90.78 120.02,89.83 120.02,88 120.61,87.42 121.42,87.42 124.21,84.62 124.21,81.9 128.43,77.68 129.1,77.68 132.07,74.72 137.27,74.72 138.79,73.19 138.79,72.46 139.13,72.13 145.29,72.13 146.23,73.07 146.23,80.74 149.36,83.86 153.85,83.86 155.43,85.44 155.43,87.42 156.7,88.69 156.7,89.05 v3(156.4,89.35)
  BOTTOM w0.076: UC1.AD10 v3(104.67,92.26)
USB20_P4_FFC_CON: length 4.1
  TOP w0.114: L13.2 240.64,180.26 v3(242.78,180.26) 243.13,180.26 243.49,179.9 243.77,179.9 243.92,180.05 JU3LF.26
USB20_P5: length 180
  TOP w0.114: L22.4 236.13,141.19 235.67,141.19 233.43,138.95 v3(232.49,138.95) 230.45,138.95 224.97,133.47 216.97,133.47 206.41,122.91 206.41,119.17 193.07,105.83 174.42,105.83 161.12,92.53 161.12,91.79 v3(161.5,91.4)
  IN3 w0.114: v3(113.72,83.71) 113.85,83.83 114.46,83.83 114.69,83.61 114.69,80.51 117.99,77.21 123.32,77.21 125.53,75 125.53,72.94 126.22,72.25 126.22,71.19 127.87,69.53 136,69.53 136.42,69.11 146.6,69.11 149.94,72.46 149.94,76.44 150.93,77.43 152.8,77.43 161.27,85.91 161.27,91.17 v3(161.5,91.4)
  BOTTOM w0.076: UC1.AJ2 109.18,89.52 109.33,89.37 109.62,89.24 109.82,89.24 109.85,89.26 110.64,89.26 112.35,87.55 112.66,87.55 112.99,87.22 112.99,84.44 113.38,84.04 113.6,84.04 113.72,83.93 v3(113.72,83.71)
USB20_P5_CON: length 11.9
  TOP w0.114: JTOUCH.5 238.16,148.3 238.24,148.21 238.26,148.21 238.27,148.21 238.97,148.21 241.3,145.88 241.3,143.31 v3(239.93,141.95) 239.63,141.64 238.84,141.64 238.3,141.11 237.64,141.11 L22.3
USB20_P6: length 242.1
  IN3 w0.076: 108.01,90.55 108,90.56 108,90.58 107.89,90.69 107.41,90.69 107.31,90.59 106.93,90.59 106.77,90.74 106.77,90.99 v1(106.58,91.19)
  IN3 w0.114: 108.01,90.55 109.31,89.24 111,89.24 112.7,87.54 115.5,87.54 116.59,86.45 121.11,86.45 123.3,84.26 123.3,81.51 128.04,76.77 128.74,76.77 131.71,73.8 136.71,73.8 137.31,73.2 137.31,72.25 138.35,71.21 145.66,71.21 147.73,73.29 147.73,80.63 149.99,82.89 154.6,82.89 157.66,85.96 157.66,88.56 158.1,88.99 158.1,91.48 160.84,94.22 161.75,94.22 173.26,105.73 216.24,105.73 219.16,108.64 219.16,124.11 226.07,131.02 226.07,132.8 230.9,137.63 234.2,137.63 248.19,151.62 248.19,161.73 248.65,162.19 248.65,165.06 249,165.42 249,169.97 247.73,171.24 247.73,177.24 242.12,182.85 240.23,182.85 v3(240.04,183.04)
  BOTTOM w0.076: UC1.AF7 v1(106.58,91.19)
  BOTTOM w0.114: JWLBT.3 241.21,182.9 241.1,182.79 240.28,182.79 v3(240.04,183.04)
USB20_P7: length 76.7
  TOP w0.114: L15.1 97.97,129.08 98.18,128.88 v3(98.18,128.18) 98.18,123.66 95.21,120.69 93.57,120.69 93.09,121.17 92.44,121.17 92.03,120.76 92.03,120.11 91.77,119.85 v1(91.7,119.85)
  IN3 w0.076: 88.64,102.29 88.64,102.27 88.66,102.25 88.66,100.94 89.4,100.2 93.69,100.2 94.11,99.78 94.11,98.62 94.46,98.27 95.14,98.27 95.78,97.63 95.78,96.8 96.45,96.12 99.47,96.12 100.81,94.79 106.83,94.79 107.26,94.36 107.26,93.72 110.59,90.39 113.54,90.39 114,89.93 114,89.3 113.72,89.02 112.81,89.02 112.63,89.19 112.63,89.36 112.79,89.52 v3(112.94,89.52)
  IN3 w0.114: 88.64,102.29 88.64,103.75 90.18,105.28 90.18,106 91.8,107.63 91.8,108.84 92.82,109.85 92.82,114.32 92.69,114.44 92.69,114.77 92.82,114.9 92.82,115.23 92.69,115.36 92.69,115.69 92.82,115.82 92.82,116.15 92.69,116.27 92.69,116.6 92.82,116.73 92.82,117.06 93.83,118.07 93.83,118.3 93.52,118.61 92.6,118.61 92.11,119.11 92.11,119.44 v1(91.7,119.85)
  BOTTOM w0.076: UC1.AH2 108.9,90.37 108.9,90.44 109.06,90.6 109.83,90.6 110.05,90.39 112.23,90.39 112.69,89.93 112.69,89.77 v3(112.94,89.52)
USB20_P7_CMOS: length 6.8
  TOP w0.114: JLCD.18 94.56,135.09 94.62,135.09 95.26,134.46 95.26,132.62 95.1,132.47 95.1,131.6 95.25,131.46 95.25,131.44 v3(95.48,131.21) 95.66,131.03 95.96,131.03 96.69,130.3 L15.2
USB20_P9: length 167
  TOP w0.114: JFPB.2 213.25,91.65 213.61,91.29 213.61,91.29 213.63,91.26 213.95,91.26 214.31,90.91 216.02,90.91 216.91,91.8 216.91,94.21 214.43,96.69 211.77,96.69 v3(209.53,98.92) 209.07,99.38 208.15,99.38 D4.2 207.16,99.01 206.94,99.23 206.56,99.23 206.21,98.88 206.21,97.86 205.88,97.52 205.88,96.87 206.01,96.74 v3(206.19,96.74)
  IN1 w0.14: v1(104.96,91.17) 105.18,90.95 105.18,90.75 105.37,90.56 108.89,90.56 109.29,90.16 109.29,88.7 109.87,88.11 114.18,88.11 114.93,87.36 114.93,86.87 v3(114.76,86.7)
  IN3 w0.114: v3(114.76,86.7) 114.9,86.7 115.07,86.54 115.07,86.26 115.64,85.69 120.86,85.69 122.54,84.01 122.54,80.22 123.29,79.47 124.21,79.47 127.39,76.29 127.39,74.16 128.1,73.45 128.1,72.22 129.13,71.19 136.68,71.19 137.36,70.51 145.99,70.51 148.44,72.96 148.44,79.34 150.73,81.62 154.59,81.62 158.38,85.41 158.38,88.25 159.31,89.19 159.31,91.71 161.02,93.41 161.93,93.41 173.54,105.02 197.35,105.02 198.58,103.79 198.58,102.15 204.75,95.97 205.54,95.97 205.83,96.26 205.83,96.59 205.98,96.74 v3(206.19,96.74)
  BOTTOM w0.114: UC1.AF9 105.04,91.65 105.19,91.5 105.19,91.4 v1(104.96,91.17)
USB20N2: length 8.6
  TOP w0.114: L20.1 24.96,19.36 v3(29.67,19.36) 30.45,19.36 31.32,18.48 32.12,18.48 32.25,18.35 AOU1.11
USB20P2: length 8.6
  TOP w0.114: L20.4 24.9,19.59 v3(27.13,19.59) 30.54,19.59 31.42,18.71 32.12,18.71 32.25,18.85 AOU1.10
USB_OC0#: length 334.9
  TOP w0.114: U15.3 25.94,22.86 27.74,21.06 v3(29.77,21.06) ; v2(41.27,16.68) 41.15,16.79 v3(41.15,17.31)
  IN1 w0.14: v3(109.2,108.52) 110.22,109.54 119.28,109.54 121.1,111.36 121.1,112.35 120.81,112.64 120.81,115.25 121.57,116.01 121.73,116.17 130.72,116.17 131.7,117.15 135.55,117.15 138.72,113.98 150.53,113.98 152.14,112.37 152.14,112.36 152.19,112.31 152.19,107.22 156.86,102.55 156.86,97.33 152.72,93.19 152.72,89.39 150.53,87.19 150.53,82.64 156.9,76.27 156.9,73.95 160.41,70.45 160.78,70.45 165.92,65.31 165.92,64.51 168.56,61.86 168.56,58.1 169.09,57.57 169.09,50.61 170.72,48.99 170.72,47.26 168.81,45.35 168.81,38.39 170.69,36.51 172.42,36.51 172.73,36.21 172.73,22.26 v3(172.4,21.93) ; v3(41.15,17.31) 39.61,15.77 33.88,15.77 33.65,15.53 31.24,15.53 30.16,16.61 30.16,20.68 v3(29.77,21.06)
  IN3 w0.114: v3(172.4,21.93) 170.49,20.03 158.71,20.03 158,19.32 152.46,19.32 147.51,14.38 141.36,14.38 138.02,11.04 122.84,11.04 115.83,18.05 41.89,18.05 v3(41.15,17.31)
  BOTTOM w0.076: UC1.A9 105.03,105.39 107.79,108.14 108.82,108.14 v3(109.2,108.52)
  BOTTOM w0.114: RPC15.8 109.52,116.49 109.15,116.12 109.15,115.04 109.73,114.45 109.73,111.11 109.66,111.04 109.66,108.98 v3(109.2,108.52)
USB_OC1#: length 303.8
  TOP w0.114: AOU1.13 33.65,16.41 v3(33.28,16.04)
  IN1 w0.14: v3(109.86,108.52) 109.4,108.07 108.97,108.07 108.77,108.27 108.77,108.93 109.02,109.18 109.43,109.18 110.06,109.82 119.17,109.82 120.83,111.48 120.83,112.24 120.53,112.55 120.53,115.35 121.61,116.44 130.61,116.44 131.59,117.41 135.67,117.41 138.84,114.24 150.64,114.24 152.46,112.43 152.46,107.33 157.13,102.66 157.13,97.22 153.09,93.18 153.09,89.38 150.81,87.09 150.81,83.58 v3(151.95,82.44) ; v3(156.93,37.76) 155.89,37.76 150.37,43.27 144.61,43.27 141.91,40.57 140.78,40.57 137.81,43.54 136.9,43.54 135.32,41.95 126.93,41.95 122.84,37.86 119.79,37.86 118.23,36.3 118.23,29.73 113.61,25.11 83.65,25.11 v3(77.91,19.37)
  BOTTOM w0.076: v3(109.86,108.52) 109.33,107.99 107.87,107.99 105.34,105.46 105.34,104.81 105.19,104.66 104.93,104.66 104.81,104.54 104.77,104.4 104.77,104.23 104.85,103.97 UC1.C9
  BOTTOM w0.114: v3(151.95,82.44) 153.57,80.81 153.57,72.28 151.92,70.63 151.92,66.61 155.61,62.93 156.52,62.93 156.8,62.65 156.8,60.36 157.16,60.01 157.16,47.41 157.47,47.09 157.47,45.57 157.16,45.25 157.16,37.99 v3(156.93,37.76) ; v3(109.86,108.52) 110.09,108.75 110.09,114.54 109.4,115.23 109.4,115.8 109.59,115.99 110.29,115.99 RPC15.7 ; v3(77.91,19.37) 75.49,16.96 v4(47.66,16.96) 47.25,16.96 43.87,20.33 36.23,20.33 35.74,19.85 35.74,17.12 35.3,16.68 33.92,16.68 v3(33.28,16.04)
USB_OC2#: length 210.7
  TOP w0.114: v3(244.66,163.11) 244.81,163.11 v4(245.24,163.54) 245.6,163.9 245.6,167.76 245.31,168.05 JU3LF.2
  IN1 w0.14: v3(155.73,104.71) 152.77,107.67 152.77,112.5 150.76,114.51 138.95,114.51 135.76,117.71 130.49,117.71 129.53,116.75 121.53,116.75 120.22,115.44 120.22,112.47 120.57,112.13 120.57,111.6 119.07,110.1 109.91,110.1 109.24,109.42 108.73,109.42 108.34,109.03 v3(108.34,108.52)
  IN3 w0.114: v3(155.73,104.71) 160.42,104.71 164,108.29 170.61,108.29 172.45,110.13 173.62,110.13 174.3,109.45 183.69,109.45 185.22,110.98 201.68,110.98 202.44,111.75 206.36,111.75 216.11,121.5 216.11,128.11 221.88,133.87 222.94,133.87 243.35,154.28 243.35,161.8 v3(244.66,163.11)
  BOTTOM w0.076: v3(108.34,108.52) 107.94,108.52 104.6,105.19 104.6,104.83 104.64,104.73 104.64,104.54 104.6,104.45 104.6,104.2 104.74,103.72 104.74,103.61 104.82,103.34 UC1.D9
  BOTTOM w0.114: v3(108.34,108.52) 108.57,108.75 108.57,110.33 109.45,111.22 109.45,114.35 108.83,114.97 108.83,116.24 109.4,116.82 110.61,116.82 110.86,116.56 110.86,115.74 110.61,115.49 RPC15.6
USB_OC3#: length 14.7
  BOTTOM w0.076: 110.14,108.14 109.84,107.84 107.96,107.84 105.72,105.6 105.72,104.84 105.2,104.31 UC1.B9
  BOTTOM w0.114: RPC15.5 110.34,114.93 110.34,112.82 111.11,112.05 v2(111.11,111.67) 111.11,111.47 110.34,110.71 110.34,108.35 110.14,108.14
USB_ON#: length 364
  TOP w0.114: JU3LF.3 243.37,168.55 242.5,167.68 242.5,164.5 243.78,163.22 243.78,154.61 244.25,154.14 244.25,142.16 241.04,138.95 v3(239.48,138.95) ; v3(200.08,56.91) 199.71,57.28 UE1.33 199.71,59.34 199.88,59.5 201.02,59.5 201.29,59.77 RE2.1 ; U15.4 28.87,22.86 v3(29.93,21.81)
  IN3 w0.114: v3(218.5,62.14) 216.69,63.95 208.51,63.95 202.98,58.41 200.97,58.41 200.08,57.52 v3(200.08,56.91) 200.69,56.3 200.69,50.19 199.51,49.01 199.51,39.32 198.75,38.56 198.75,36.93 190.28,28.47 190.28,26.76 185.16,21.63 183.83,21.63 183.19,20.99 183.19,19.66 180.65,17.12 158.68,17.12 157.96,17.85 153.62,17.85 148.95,13.17 141.87,13.17 138.53,9.83 120.71,9.83 117.5,13.04 38.76,13.04 35.41,16.38 35.41,19.75 34.5,20.66 33.13,20.66 31.98,21.81 v3(29.93,21.81)
  BOTTOM w0.114: v3(239.48,138.95) 237.45,136.92 231.13,136.92 228.78,134.58 228.78,127.83 226.23,125.27 226.23,114.66 219.26,107.69 219.26,62.9 v3(218.5,62.14)
USBCOMP: length 6.6
  BOTTOM w0.203: 107.23,93.33 107.37,93.18 107.58,93.18 107.6,93.17 107.87,93.17 107.88,93.18 109.48,93.18 109.52,93.14 109.53,93.14 109.73,92.94 111.35,92.94 111.69,93.28 112.71,93.28 RC384.1
  BOTTOM w0.254: UC1.AB6 107.23,93.33
VBUCK_1V5: length 20.5
  TOP w0.305: 33.79,90.21 33.09,89.51 32.68,89.51 32.35,89.17 UVG2.6
  TOP w0.381: v3(33.03,90.21) CVG41.1
  BOTTOM w0.508: v3(33.03,90.21) 34.65,88.58 35.9,88.58 36.79,87.7 36.79,83.69 36.19,83.1 36.19,79.92 35.46,79.19 L21.2
  vias: v1(29.65,79.16) v1(30.09,79.61) v1(30.47,80.81) v1(30.47,80.18) v4(28.44,80.62)
VGA_AC_DC#: length 143.1
  TOP w0.114: v4(165.61,152.34) 165.61,152.14 164.93,151.45 DV5.1 164.65,150.79 v3(164.65,150.53) ; UE1.126 198.91,46.52 v3(198.43,47)
  IN2 w0.14: v3(198.43,47) 200.15,48.73 200.15,51.46 198.78,52.83 198.78,55.86 193.91,60.72 193.15,60.72 189.92,63.95 180.88,63.95 180.02,64.81 171,64.81 161.91,73.9 161.91,76.46 161.49,76.88 161.49,89.92 162.08,90.51 162.08,95.32 161.7,95.7 161.7,116.24 161.5,116.45 161.5,117.55 166.19,122.24 166.19,123.9 164.39,125.69 164.39,130.34 164.9,130.85 164.9,134.34 163.87,135.37 163.87,140.88 164.38,141.39 164.38,150.27 v3(164.65,150.53)
VGA_BLUE: length 10.1
  TOP w0.114: R231.1 17.33,85.21 17.76,85.64 17.76,85.64 v2(18.94,86.82) 19.46,87.34 24.11,87.34 24.94,88.17 UVG2.21
VGA_BLUE_CON: length 11.6
  TOP w0.114: JCRT.3 6.46,91 7.6,89.85 8.36,89.85 11.43,86.79 v4(11.43,86.51) 11.87,86.07 12.2,86.07 12.31,85.96 DT1.6 12.67,84.83 CT28.1 14.45,84.83 LT1.2
VGA_BLUE_R: length 4.1
  TOP w0.114: LT1.1 14.62,83.91 CT24.1 RT23.1 R231.2 17.63,83.91 v2(18.29,84.57)
VGA_DDC_SCL: length 19.3
  TOP w0.114: UVG2.16 25.63,90.97 24.69,91.91 RT36.2 23.73,93.51 22.1,91.89 22.1,90.39 21.8,90.08 v3(21.75,90.08) ; RT28.1 v3(16.14,92.95)
  BOTTOM w0.114: v3(16.14,92.95) v4(15.3,92.11) 15.3,90.34 15.42,90.21 QT1.1 21.62,90.21 v3(21.75,90.08)
VGA_DDC_SCL_CON: length 13.1
  TOP w0.114: JCRT.15 v4(9.15,95.58) 10.97,95.58 12.63,93.92 12.63,92.33 DT2.3 13.46,92.04 RT14.2 RT28.2 15.42,91.73 15.04,91.35 v3(14.79,91.35)
  BOTTOM w0.114: v3(14.79,91.35) 14.92,91.23 14.92,90.34 14.79,90.21 QT1.6
VGA_DDC_SDA: length 28.6
  TOP w0.114: UVG2.18 25.28,89.67 24.97,89.98 22.33,89.98 v3(21.72,89.37)
  BOTTOM w0.114: v3(21.72,89.37) 21.7,89.37 17.28,84.95 14.81,84.95 v2(14.48,85.28) 13.39,86.37 12.03,86.37 11.79,86.61 RT37.2 RT29.1 11.08,88.64 11.08,92.04 11.39,92.34 12.17,92.34 13.14,91.38 13.14,89.57 13.8,88.91 QT1.4
VGA_DDC_SDA_CON: length 13.9
  TOP w0.114: v3(11.74,91.73) 11.71,91.77 DT2.4 9.77,91.77 v5(9.76,91.78)
  BOTTOM w0.114: v3(11.74,91.73) 11.74,90.46 12.71,89.5 RT13.2 RT29.2 15.07,87.92 QT1.3 ; JCRT.12 7.6,89.62 v5(9.76,91.78)
VGA_GREEN: length 11
  TOP w0.114: UVG2.22 25.38,87.67 24.77,87.06 21.67,87.06 20.71,86.1 20.71,85.38 v4(20.49,85.17) 17.86,82.54 R230.1
VGA_GREEN_CON: length 14
  TOP w0.114: JCRT.2 6.31,88.71 7.3,87.72 9.25,87.72 v4(9.45,87.52) 10.78,86.2 10.78,84.16 DT1.3 10.66,82.54 CT27.1 14.45,82.54 LT2.2
VGA_GREEN_R: length 4.1
  TOP w0.114: LT2.1 14.62,81.62 CT26.1 RT22.1 R230.2 17.58,81.62 v2(18.29,82.34)
VGA_HSYNC: length 7.6
  TOP w0.114: UT3.2 18.19,87.89 18.8,88.51 RT34.1 19.54,89.7 v4(20.07,89.17) 20.81,88.43 RVG18.2
VGA_HSYNC_1: length 6.2
  TOP w0.114: UT3.4 v4(15.18,89.8) ; UT3.4 15.94,88.54 16.36,88.97 17.56,88.97 17.89,89.3 RT34.2 ; UT3.4 14.3,88.54 14.26,88.59 RT20.1
VGA_HSYNC_CON: length 7.6
  TOP w0.114: JCRT.13 8.44,91 9.54,89.89 v4(9.73,89.89) 10.77,89.89 DT2.6 11.03,89.63 11.03,89.32 12.67,87.68 RT20.2
VGA_HSYNC_L: length 5.5
  TOP w0.114: UVG2.20 23.79,88.67 RVG18.1 23.55,87.73 23.4,87.58 21.61,87.58 v4(21.29,87.9)
VGA_LGATE1: length 21.5
  TOP w0.114: v3(208.26,152.14) 208.69,152.57 v4(208.69,152.64)
  IN3 w1.016: 206.69,151.65 195.69,151.65 188.75,144.72
  vias: v3(188.45,143.52) v3(188.78,142.97) v3(189.08,143.52) v3(207.8,151.68)
VGA_LGATE2: length 19.7
  TOP w0.114: v3(208.13,154.17) 207.73,154.57 v4(207.6,154.57)
  IN3 w1.016: 207.19,154.42 189.74,154.42 188.63,153.3
  vias: v3(188.32,151.86) v3(188.63,152.41) v3(188.98,151.86) v3(208.59,153.71)
VGA_ON: length 297.3
  TOP w0.114: RV13.2 152.91,119.52 154.7,121.31 156.64,121.31 158.65,119.29 161.78,119.29 162.54,120.05 165.54,120.05 v3(165.79,120.31) ; 187.25,128.78 187.25,128.97 186.8,129.43 185.91,129.43 185.4,128.92 185.4,128.56 184.74,127.9 184.74,127.07 183.85,126.18 182.51,126.18 v3(181.31,124.98) ; v3(179.44,120.63) 179.44,121.31 RV183.1 ; RPC9.2 148.92,92.19 148.62,91.89 147.61,91.89 v3(147.54,91.95) 147.5,91.99 147.5,92.57 148.11,93.18 149.21,93.18 150.37,94.35 156.75,94.35 159.09,96.69 161.73,96.69 v3(164.66,99.62) ; DV7.1 RV188.1 RV153.1 174.55,179.36 173.48,179.36 170.43,176.32 170.17,176.32 168.65,174.79 168.65,168.89 169.03,168.51 169.92,168.51 170.24,168.19 170.24,167.49 175.19,162.54 179.98,162.54 v3(180.09,162.65)
  IN1 w0.076: 109.11,95.62 106.1,95.62 v3(105.94,95.46)
  IN1 w0.14: v3(147.54,91.95) 147.48,92.01 143.03,92.01 141.64,93.41 135.15,93.41 134.59,93.97 126.98,93.97 125.99,94.96 125.99,95.54 124.76,96.78 120.14,96.78 119.67,97.25 117.47,97.25 117.39,97.32 115.14,97.32 115,97.18 113.16,97.18 112.7,96.72 110.21,96.72 109.11,95.62 ; v3(179.44,120.63) 179.44,121.64 181.31,123.51 v3(181.31,124.98) 182.56,126.23 199.78,126.23 v3(200.67,127.12) ; v3(165.79,120.31) 165.11,119.62 165.11,116.19 165.31,115.99 165.31,115.18 165,114.87 165,105.08 164.17,104.25 164.17,100.12 v3(164.66,99.62) ; v3(212.22,142.15) 211.77,142.61 211.77,144.92 213.24,146.39 216.57,146.39 217.53,147.36 217.53,152.8 219.26,154.52 219.26,155.01 219.51,155.26 219.92,155.26 v3(220.48,155.82)
  IN2 w0.14: v3(212.22,142.15) 212.22,142.23 213.32,143.32 214.84,143.32 215.45,143.93 217.43,143.93 222.04,148.54 222.04,155.79 219.46,158.37 212.27,158.37 207.66,162.98 180.42,162.98 v3(180.09,162.65)
  BOTTOM w0.076: UC1.U8 v3(105.94,95.46)
  BOTTOM w0.114: PR603.1 221.47,151.3 221.47,155.03 220.68,155.82 v3(220.48,155.82) ; v3(212.22,142.15) 212.22,140.63 200.67,129.07 v3(200.67,127.12) ; v3(179.44,120.63) 179.44,120.5 178.43,119.48 171.63,119.48 170.78,120.33 165.82,120.33 v3(165.79,120.31)
VGA_PHASE1: length 64.9
  TOP w0.254: PR616.2 214.55,143.89 v3(213.52,142.86)
  IN3 w0.254: v3(213.52,142.86) 213.52,142 206.66,135.14 202.36,135.14 201.19,133.97 180.45,133.97 179.06,135.37 179.06,137.33 v3(179.41,137.68)
  IN3 w0.762: 206.86,150.23 202.11,150.23 193.27,141.39
  BOTTOM w0.254: PR608.2 213.72,143.07 v3(213.52,142.86)
  BOTTOM w0.381: v3(179.41,137.68) 179.89,138.17 PL603.1
  vias: v3(183.27,135.7) v3(183.6,140.07) v3(183.6,138.75) v3(183.57,137.5) v3(183.57,136.31) v3(183.67,135.19) v3(184.26,140.07) v3(184.26,138.72) v3(184.26,137.45) v3(184.26,136.18) v3(184.26,135.5) v3(184.89,135.55) v3(185.55,135.47) v3(186.19,135.47) v3(186.82,135.47) v3(187.48,135.47) v3(188.12,135.47) v3(188.88,135.47) v3(189.52,135.47) v3(190.18,135.47) v3(190.81,135.47) v3(191.47,135.47) v3(193.05,138.47) v3(193.07,137.83) v3(193.25,137.17) v3(193.3,139.38) v3(193.76,138.93) v3(193.78,138.24) v3(193.83,137.61) v3(193.94,136.79) v3(208.44,150.81) v3(208.9,151.27) v4(191.75,139.54)
VGA_PHASE2: length 79.1
  TOP w0.254: v3(216.45,143.19) 216.45,143.2 216.44,143.21 216.44,143.35 216.31,143.47 PR632.2
  IN3 w0.254: v3(216.45,143.19) 216.45,143.47 216.85,143.87 216.85,146.6 217.8,147.55 217.8,149.26 218.19,149.66 218.19,156.82 217.16,157.85 211.13,157.85 205.57,163.41 188.98,163.41 187.99,162.42 180.83,162.42 179,160.59 v3(179,157.65)
  IN3 w0.762: 194.19,156.17 206.76,156.17
  BOTTOM w0.254: v3(216.45,143.19) 216.58,143.19 216.9,143.5 PR631.2 ; v3(179,157.65) 179.53,157.11 PL604.1
  vias: v3(182.43,160.12) v3(182.43,159.49) v3(183.19,158.47) v3(183.19,157.84) v3(183.19,157.2) v3(183.19,156.57) v3(184.33,157.65) v3(184.33,157.01) v3(184.33,156.38) v3(184.33,155.74) v3(184.52,160.5) v3(184.52,159.87) v3(185.92,160.5) v3(185.92,159.87) v3(186.94,160.5) v3(186.94,159.87) v3(187.89,160.5) v3(187.89,159.87) v3(189.03,160.5) v3(189.03,159.87) v3(189.67,160.5) v3(189.67,159.87) v3(190.3,160.5) v3(190.3,159.87) v3(190.94,160.5) v3(190.94,159.87) v3(191.57,160.5) v3(191.57,159.87) v3(192.21,160.5) v3(192.21,159.87) v3(193.3,156.71) v3(193.3,156.07) v3(208.06,155.21) v3(208.51,154.75) v4(190.2,159.22)
VGA_RED: length 11.3
  TOP w0.114: UVG2.24 25.41,86.67 23.41,84.67 21.39,84.67 v4(20.03,83.31) 17.33,80.61 R229.1
VGA_RED_CON: length 15.1
  TOP w0.114: JCRT.1 6.4,86.42 7.08,87.1 8.7,87.1 9.91,85.9 DT1.1 9.72,85 9.4,85 8.57,84.16 8.57,83.5 v4(10.85,81.22) 11.82,80.25 CT25.1 14.45,80.25 LT3.2
VGA_RED_R: length 4.5
  TOP w0.114: v2(18.45,80.56) 18.45,80.46 R229.2 RT21.1 CT29.1 14.62,79.34 LT3.1
VGA_UGATE1: length 16
  TOP w0.114: v3(209.35,150.74) 209.76,151.14 v4(209.76,151.2)
  IN3 w0.762: 196.17,140.37 204.91,149.11 207.93,149.11
  vias: v3(194.42,140.55) v3(195.15,140.58) v3(208.87,150.26)
VGA_UGATE2: length 16.1
  TOP w0.114: v3(209.45,154.88) 209.89,154.45 v4(209.96,154.45)
  IN3 w0.762: 195.64,160.63 196.21,160.63 199.14,157.7 207.6,157.7 209.15,156.15
  vias: v3(193.29,160.57) v3(193.29,159.93) v3(209,155.34)
VGA_VSYNC: length 9.7
  TOP w0.114: RT35.1 19.46,94.15 19.16,93.84 19.16,92.85 19.39,92.62 UT4.2 21.27,92.62 21.77,92.12 21.77,91.66 v4(21.04,90.92) 21.04,89.24 21.37,88.91 22.23,88.91 RVG19.2
VGA_VSYNC_1: length 5.5
  TOP w0.114: RT35.2 18.55,94.22 18.9,93.87 18.9,93.49 18.69,93.27 UT4.4 17.47,93.27 16.91,93.83 16.58,93.83 v4(16.57,93.82) 16.44,93.69 16.44,93.36 16.69,93.11 RT27.1
VGA_VSYNC_CON: length 14
  TOP w0.114: JCRT.14 9.56,93.29 10.17,93.89 11.79,93.89 v4(11.82,93.87) 12.25,93.44 12.25,91.61 11.79,91.15 11.79,90.41 12.34,89.87 DT2.1 14.09,89.87 15.49,91.26 RT27.2
VGA_VSYNC_L: length 2.3
  TOP w0.114: RVG19.1 23.7,89.17 v4(24.57,89.17) 24.57,89.17 UVG2.19
VGATE: length 211.8
  TOP w0.114: v3(165.79,63.16) 165.79,62.73 169.73,58.79 v4(169.73,58.1) 169.55,57.93 169.55,57.14 170.41,56.28 170.41,55.39 169.55,54.52 169.55,47.59 172.9,44.24 176.71,44.24 178.05,45.57 178.05,48.83 178.56,49.34 179.86,49.34 181.92,51.4 184.56,51.4 184.83,51.67 UE1.78
  IN2 w0.14: v3(165.79,63.16) 161.63,63.16 160.88,63.91 160.88,65.26 161.14,65.53 161.14,69.84 155.86,75.12 155.86,87.77 153.23,90.41 153.23,91.23 153.98,91.99 154.62,91.99 158.51,95.89 158.51,107 155.22,110.3 155.22,114.42 151.34,118.3 136.18,118.3 132.58,121.9 127.43,121.9 126.16,123.17 121.1,123.17 120.49,122.55 119.02,122.55 118.41,123.17 116.77,123.17 116.01,123.93 111.26,123.93 110.69,123.36 107.94,123.36 107.08,122.5 105.63,122.5 105.15,122.98 98.04,122.98 97.6,123.41 95.31,123.41 95.12,123.23 92.96,123.23 92.58,123.61 88.6,123.61 87.1,125.12 84.66,125.12 83.96,125.82 81.13,125.82 79.17,123.86 79.17,120.05 78.38,119.26 77.43,119.26 76.26,118.09 71.18,118.09 69.27,116.18 65.35,116.18 v1(65.12,115.95)
  BOTTOM w0.203: PU401.38 67.1,119.51 66.76,119.17 66.76,117.97 66.38,117.59 66.38,117.31
  BOTTOM w0.254: 66.38,117.31 65.84,116.78 PR406.1 65.28,116.12 v1(65.12,115.95)
VMB:
  vias: v4(197.03,181.85)
VMB2: length 2.2
  TOP w0.254: v4(192.99,186.48) 192.66,186.81 JBATT1.1 ; v4(192.01,184.49) 192.01,185.07 v3(192.05,185.12)
  vias: v4(196.04,184.85)
VR_HOT#: length 385.1
  TOP w0.203: RC5.1 71.37,113.64 70.5,114.5 v1(70.5,114.56)
  TOP w0.254: v1(80.07,133.71) 80.19,133.71 80.45,133.96 83.25,133.96 97.06,147.77 98.61,147.77 v3(98.94,147.44) ; v1(74.86,131.8) 74.86,131.74 73.97,130.85 73.34,130.85 72.95,130.47 72.95,130.02 73.21,129.77 75.34,129.77 75.88,129.23 75.88,129.2 75.91,129.17 75.91,128.41 75.37,127.87 75.37,124.94 v4(75.49,124.82) 76,124.31 76,123.04 76.45,122.59 76.45,119.89 75.85,119.29 74.61,119.29 73.72,118.4 73.72,117.16 73.55,116.99 73.55,116.77 73.28,116.51 71.63,116.51 71.04,115.91 RC294.2 70.5,114.82 v1(70.5,114.56) ; v3(176.97,41.82) 179.28,41.82 180.05,41.05 180.92,41.05 183.14,38.83 CE17.1 185.26,38.83 QE1.1
  IN1 w0.14: v3(170.03,171.97) 169.32,172.68 169.32,176.8 166.39,179.73 166.39,182.09 161.03,187.45 123.21,187.45 117.84,182.08 v3(116.19,182.08)
  IN1 w0.254: v3(200.89,134.63) 200.89,129.81 202.91,127.8 202.91,121.36 200.9,119.35 200.9,117.01 200.46,116.57 200.46,111.01 200.9,110.57 200.9,95.04 201.88,94.06 201.88,77.34 191.45,66.91 189.15,66.91 187.94,65.7 177.42,65.7 176.23,64.51 176.23,62.45 177.98,60.7 177.98,56.38 177.6,56 177.6,53.25 177.2,52.85 177.2,42.05 v3(176.97,41.82) ; v1(74.86,131.8) 78.67,131.8 80.07,133.2 v1(80.07,133.71)
  IN2 w0.254: v3(200.89,134.63) 202.27,136.01 202.27,138.62 204.55,140.91 204.55,142.31 212.3,150.05 216.29,150.05 217.56,151.32 217.56,155.64 215.93,157.27 211.8,157.27 209,160.06 202.65,160.06 200.67,162.04 175.22,162.04 170.72,166.54 170.72,171.39 170.14,171.97 v3(170.03,171.97) ; v3(116.19,182.08) 115.22,181.12 111.2,181.12 99.7,169.62 99.7,150.72 98.41,149.42 98.41,147.97 v3(98.94,147.44)
  BOTTOM w0.254: v3(170.03,171.97) 170.52,171.97 171.23,171.26 171.74,171.26 PR126.1 ; PR409.2 71.05,115.1 v1(70.5,114.56)
VR_HOT#_R: length 25.8
  TOP w0.114: v3(68.48,107.43) 68.48,107.05 69.35,106.19 71.61,106.19 72.1,106.67 74.1,106.67 74.61,107.18 74.61,107.96 74.86,108.22 75.34,108.22 76.11,108.99 76.11,110.23 75.25,111.1 75.25,113.89 74.99,114.15 v2(74.99,114.34) 74.8,114.34 74.48,114.02 72.97,114.02 RC5.2
  BOTTOM w0.076: UC1.C65 72.64,103.97 72.55,104.23 72.55,104.4 72.61,104.59 72.61,104.74 72.55,104.86 72.55,105.12 72.75,105.31 72.75,105.85 72.08,106.52 69.4,106.52 v3(68.48,107.43)
VR_HOT_R#: length 2.4
  BOTTOM w0.203: PU101.10 173.21,171.31 PR126.2
VR_ON: length 251.2
  TOP w0.114: v1(78.61,126.02) 77.84,126.79 77.84,128.44 75.34,130.95 75.34,131.3 75.84,131.8 QC3.2 ; D61.2 211.95,61.99 v3(211.26,61.99) ; v3(205.47,57.29) 205.73,57.02 207.05,57.02 RE51.1 208.64,56.38 D59.2 ; v4(66.91,113.88) 66.91,114.33 v1(67.18,114.59) 67.18,115.55 66.1,116.63 66.1,117.45 65.59,117.96 65.59,118.66 65.97,119.04 65.97,119.86 65.27,120.56 65.27,121.64 65.97,122.34 65.97,124.56 68.26,126.85 72.95,126.85 74.35,128.25 v1(74.35,128.88)
  IN2 w0.14: v1(67.18,114.59) 67.58,114.99 71.41,114.99 71.81,114.59 71.81,112.17 72.67,111.32 77.84,111.32 78.77,112.24 79.19,112.24 79.97,113.03 80.99,113.03 82.51,114.55 82.67,114.71 100.13,114.71 101.38,115.97 108.43,115.97 110.64,118.18 111.53,118.18 114.39,115.32 130.58,115.32 131.66,114.24 135.09,114.24 136.41,115.55 150.56,115.55 150.56,115.55 150.78,115.55 152.61,113.72 152.61,109.54 155.2,106.95 155.2,101.03 153.75,99.58 153.75,95.84 152.21,94.3 152.21,90.15 154.84,87.51 154.84,74.18 v3(157.52,71.5)
  IN3 w0.114: v3(211.26,61.99) 210.55,61.28 207.19,61.28 205.47,59.55 v3(205.47,57.29) ; v1(74.35,128.88) 74.35,127.87 75.49,126.72 77.91,126.72 v1(78.61,126.02)
  BOTTOM w0.114: v3(157.52,71.5) 157.62,71.5 163.96,65.16 163.96,63.24 169.5,57.7 170.27,57.7 171.34,56.63 174.68,56.63 175.37,55.95 178.8,55.95 180.8,57.95 187.53,57.95 188.19,58.61 197.54,58.61 199.71,56.44 201.03,56.44 202.7,54.78 203.76,54.78 205.47,56.48 v3(205.47,57.29)
  BOTTOM w0.254: v1(67.18,114.59) 67.6,115.01 PR407.1
VR_ON_EC: length 14.7
  TOP w0.114: v3(203.94,56.5) 203.19,56.5 202.75,56.07 UE1.30 ; v3(211.23,62.7) 211.85,62.7 D61.1
  IN3 w0.114: v3(203.94,56.5) 204.93,57.49 204.93,59.5 208.13,62.7 v3(211.23,62.7)
VR_SVID_ALRT#: length 7.1
  TOP w0.114: v1(69.17,114.57) 69.17,114.37 v4(68.69,113.88) 68.87,113.7 69.86,113.7 70.57,112.99 RC20.2 69.83,111.8 69.83,110.3 RC19.2
  BOTTOM w0.114: PR408.1 69.17,115.08 v1(69.17,114.57)
VR_SVID_ALRT#_R: length 8.7
  TOP w0.114: RC19.1 70.01,108.27 69.58,107.84 69.58,107.58 70.01,107.15 70.8,107.15 v3(71.35,107.71)
  BOTTOM w0.076: v3(71.35,107.71) 71.86,107.2 72.26,107.2 73.62,105.84 73.62,104.64 UC1.B63
VR_SVID_CLK: length 17.8
  TOP w0.114: v3(71.99,107.74) 71.13,106.87 69.88,106.87 69.37,107.38 69.37,109.92 68.7,110.59 v2(68.7,110.75) 68.64,110.81 68.64,111.95 RC387.2 68.54,112.54 68.07,113.01 68.07,114.17 v1(68.46,114.57) 68.46,114.97 PR404.2
  BOTTOM w0.076: UC1.A63 73.79,105.1 73.79,105.94 v3(71.99,107.74)
  BOTTOM w0.114: v1(68.46,114.57) PR410.1
VR_SVID_DAT: length 16.9
  TOP w0.114: v3(70.72,107.66) 71.84,108.78 RC388.2 72.32,109.69 72.32,110.45 71.15,111.62 71.15,113.25 v4(70.62,113.78) 69.86,114.54 v1(69.86,114.57) 69.86,115.51 PR403.2
  BOTTOM w0.076: v3(70.72,107.66) 71.33,107.05 72.19,107.05 73.46,105.79 73.46,104.33 73.68,104.11 73.68,103.87 73.38,103.58 UC1.D64
  BOTTOM w0.114: PR411.1 69.86,114.9 v1(69.86,114.57)
VRALERT#: length 33
  TOP w0.114: v3(124.01,69.28) 123.98,69.25 TC24.1
  IN1 w0.076: 112.62,77.07 107.27,82.41 105.54,82.41 104.76,83.2 104.24,83.2 103.28,84.15 103.28,87.92 v3(102.91,88.29)
  IN1 w0.14: 112.62,77.07 116.43,73.26 117.85,73.26 119.76,71.34 119.76,70.52 120.24,70.04 121.45,70.04 121.85,69.64 123.65,69.64 v3(124.01,69.28)
  BOTTOM w0.076: UC1.AM11 103.32,88.7 v3(102.91,88.29)
VREFG: length 4
  TOP w0.381: v3(151.87,153.25) 151.75,153.38 CV214.1 RV160.2 150.35,153.25 150.78,152.82 RV128.1
  BOTTOM w0.381: v3(151.87,153.25) 151.78,153.16 UV1.AH13
VSUM+: length 14.3
  BOTTOM w0.203: PU601.14 213.72,148.32 214.05,147.99 215.55,147.99 215.96,147.59 PC634.1
  BOTTOM w0.254: PC634.1 PC633.1 PR634.1 215.98,145.63 PR633.1 216.8,144.92 PR631.1 217.1,144.82 217.51,144.42 217.51,143.25 v4(216.74,142.48) 215.98,141.72 214.74,141.72 PR608.1
VSUM-: length 46.4
  TOP w0.254: v4(212.91,145.33) 213.42,144.82 v3(213.52,144.82) 213.99,145.29 PC608.1 PC628.1
  IN2 w0.254: v3(178.34,134.02) 178.47,134.15 192.26,134.15 192.87,133.54 197.57,133.54 198.13,132.98 202.44,132.98 209.35,139.89 209.35,142.51 212.05,145.2 213.14,145.2 v3(213.52,144.82)
  BOTTOM w0.254: PRT601.1 v3(178.34,134.02)
VSYSTEM: length 386.6
  TOP w0.508: v3(183.47,166.64) 182.78,167.33 182.06,167.33 v4(181.13,166.41) 174.5,166.41 v3(173.44,165.34) ; v3(115.53,13.62) 116.1,13.62 129.93,27.45 129.93,41.31 131.35,42.74 136.45,42.74 137.31,41.88 146.87,41.88 148.29,40.45 148.29,40.04 149.23,39.11 152.51,39.11 154.54,37.07 166.6,37.07 v4(170.06,40.53) v3(172.37,40.53) ; v3(74.27,13.78) 73.89,14.16 PD1.2 ; v3(229.93,160.06) v4(230.79,160.92) v3(234.83,160.92)
  IN1 w0.508: v3(172.37,40.53) 173.31,40.53 175.11,42.33 175.11,53.43 176.13,54.45 176.13,60.59 174.68,62.04 174.68,63.41 163.02,75.07 163.02,92.85 170.68,100.5 170.68,109.28 v3(169.93,110.02)
  IN2 w0.508: v3(74.27,13.78) 74.43,13.62 v3(115.53,13.62) ; v3(212.91,126.35) 212.91,131.79 216.41,135.29 216.41,137.4 225.91,146.9 226.98,146.9 231.65,151.58 231.65,157.75 v3(234.83,160.92) 237,160.92 238.75,159.17 241.07,159.17 241.16,159.26 v3(244.39,159.26)
  IN3 w0.508: v3(183.47,166.64) 185.88,164.23 206.41,164.23 211.23,159.4 229.27,159.4 v3(229.93,160.06) ; v3(169.93,110.02) 171.38,110.02 172.17,110.81 174.4,110.81 175,110.21 182.17,110.21 183.81,111.85 199.47,111.85 201.17,113.55 207.22,113.55 215.19,121.53 215.19,124.07 v3(212.91,126.35)
  BOTTOM w0.254: v3(173.44,165.34) 173.56,165.22 PR113.1 ; 224.75,163.51 223.91,162.68 PC101.1 ; PR5.1 243.82,158.54 244.39,159.11 v3(244.39,159.26)
  BOTTOM w0.508: v3(183.47,166.64) 183.86,166.25 184.63,166.25 PD102.2
VTTREF_0.675V: length 2.2
  BOTTOM w0.203: PC315.1 133.3,38.43 PU301.4
WLAN_PWRON: length 26.2
  TOP w0.114: UE1.123 197.71,43.87 v3(198.05,44.21) ; v3(204.3,43.32) v4(204.3,34.36) 206.87,31.79 211.81,31.79 212.06,31.54 R9460.1
  BOTTOM w0.114: v3(198.05,44.21) 203.41,44.21 v3(204.3,43.32)
WLAN_PWRON#: length 4
  TOP w0.114: Q5.1 214.79,34.56 R51.1 R28.2 213.06,36.16 v4(212.83,36.16)
WLAN_PWRON_R: length 3.7
  TOP w0.114: R69.1 212.15,32.53 R9460.2 212.35,32.32 Q5.2 213.5,31.19 v4(213.26,30.95)
WRST#: length 9.5
  TOP w0.114: UE1.14 202.46,49.67 203.21,50.41 205.67,50.41 206.23,50.97 206.61,50.97 207.07,50.51 RE4.2 CE11.1 208.72,49.32 IT8.1
XDP_BPM#0: length 18.3
  TOP w0.114: v3(78.97,110.81) 79.94,109.84 80.8,109.84 81.49,110.53 81.49,117.16 TC1.1
  BOTTOM w0.076: UC1.C55 78.25,104.08 78.25,106.05 77.35,106.94 77.35,108.4 78.16,109.21 78.16,110.15 78.54,110.53 78.7,110.53
  BOTTOM w0.114: 78.7,110.53 v3(78.97,110.81)
XDP_BPM#1: length 7.7
  BOTTOM w0.076: UC1.D55 78.34,103.58 78.63,103.87 78.63,104.11 78.41,104.33 78.41,106.12 77.5,107.02 77.5,108.34 78.36,109.19 78.36,109.84 TC2.1
XDP_BPM#2: length 15.5
  TOP w0.114: v3(79.69,110.73) 80.3,110.12 80.73,110.12 81.25,110.64 81.25,115.62 80.83,116.04 TC7.1
  BOTTOM w0.076: 77.88,108.4 77.88,106.9 78.64,106.14 78.64,104.74 78.9,104.48 UC1.B54
  BOTTOM w0.114: v3(79.69,110.73) 79.36,110.4 79.36,109.95 77.88,108.47 77.88,108.4
XDP_BPM#3: length 9.6
  BOTTOM w0.076: UC1.C56 77.78,103.79 78.1,104.11 78.1,105.98 77.2,106.88 77.2,108.46 78.01,109.27 78.01,110.5 78.03,110.53
  BOTTOM w0.114: TC9.1 78.82,111.32 78.03,110.53
XDP_PRDY_N: length 11.9
  BOTTOM w0.076: 77.2,110.53 77.2,110.42 77.53,110.09 77.53,109.45 76.64,108.56 76.64,106.67 77.49,105.82 77.49,105.34 77.34,105.19 77.34,104.82 77.38,104.75 77.38,104.54 77.37,104.51 77.37,104.48 77.35,104.47 77.34,104.45 77.34,104.2 77.48,103.72 77.48,103.61 77.56,103.34 UC1.D56
  BOTTOM w0.114: TC25.1 77.91,113.26 77.91,111.95 77.2,111.24 77.2,110.53
XDP_PREQ_N: length 14.6
  TOP w0.114: v1(75.7,109.97) 74.83,110.84 74.83,112.66 74.29,113.2 73.46,113.2 72.7,112.43 72.07,112.43 71.88,112.63 TC26.1
  BOTTOM w0.076: v1(75.7,109.97) 75.7,109.08 75.57,108.96 75.57,107.58 75.37,107.38 75.09,107.38 74.91,107.2 74.91,106.65 75.59,105.97 75.59,104.13 75.57,104.11 75.57,103.87 75.59,103.85 75.59,103.48 75.57,103.46 75.57,103.29 UC1.D61
XDP_TCLK: length 12.4
  TOP w0.114: v4(74.03,112.56) 74.29,112.31 v1(74.29,111.99) 74.42,111.86 74.42,111.38 RC4.1 75.14,109.51 v3(75.14,108.68)
  BOTTOM w0.076: UC1.B61 75.09,104.52 75.09,104.74 75.03,104.86 75.03,105.12 75.21,105.29 75.21,105.88 74.45,106.63 74.45,107.99 v3(75.14,108.68)
  BOTTOM w0.114: RC415.1 73.21,112.52 73.21,111.8 73.53,111.48 74.07,111.48 74.29,111.7 v1(74.29,111.99)
XDP_TDI: length 13.5
  TOP w0.114: RC31.1 RC422.1 76.35,114.95 76.7,114.59 v1(76.7,112.82)
  BOTTOM w0.076: 76.1,110.53 76.1,109.15 75.72,108.76 75.72,106.4 75.75,106.37 75.75,106.33 75.77,106.31 75.77,106.29 75.94,106.13 75.94,104.33 76.15,104.11 76.15,103.87 75.86,103.58 UC1.D60
  BOTTOM w0.114: 76.1,110.53 76.1,111.67 76.7,112.27 v1(76.7,112.82)
XDP_TDO: length 32.3
  TOP w0.114: RC426.1 73.34,115.44 RC3.1 74.57,114.85 74.99,114.85 75.67,114.17 75.67,111.27 76.53,110.41 76.53,110.38 76.54,110.37 76.54,108.73 75.62,107.81 v3(75.16,107.81) 74.86,107.51 74.86,106.75 75.14,106.47 79.5,106.47 81.27,108.24 81.27,109.45 82.19,110.36 v1(83.05,110.36)
  BOTTOM w0.076: UC1.A61 75.38,105.05 75.38,105.94 74.61,106.71 74.61,107.25 v3(75.16,107.81)
  BOTTOM w0.114: v4(80.51,114.72) 80.19,114.72 79.69,114.21 RC423.1 80.28,113.68 83.05,110.91 v1(83.05,110.36)
XDP_TMS: length 16.4
  TOP w0.114: v3(75.29,107) 75.81,107 77.55,108.74 77.55,109.83 77.26,110.13 77.26,110.55 76.26,111.55 76.26,114.53 75.98,114.81 75.98,115.61 RC424.1 76.28,116.63 RC34.1 76.35,116.97 v4(76.89,117.51)
  BOTTOM w0.076: UC1.C60 75.77,104.08 75.77,106.02 75.29,106.5 v3(75.29,107)
XDP_TRST#: length 12.9
  BOTTOM w0.076: 76.46,110.53 76.46,110.16 76.26,109.96 76.26,109.08 75.88,108.7 75.88,106.46 75.9,106.43 75.9,106.4 76.1,106.2 76.1,104.64 UC1.B59
  BOTTOM w0.114: v4(75.49,112.24) 75.62,112.37 75.62,112.82 75.85,113.04 RC425.1 ; RC425.1 76.87,113.39 77.15,113.11 77.15,112.33 76.46,111.65 76.46,110.53 ; RC425.1 RC6.1
XTALIN: length 16
  BOTTOM w0.127: UV1.AV33 158.58,137.36 158.68,137.26 160.46,137.26 163.19,134.53 163.19,133.83 v2(165.03,131.99) 165.74,131.28 RV10.1 166.35,131.1 CV17.1 166.93,130.52 166.93,128.94 YV1.1
XTALOUT: length 14
  BOTTOM w0.127: YV1.3 165.16,130.21 CV18.1 164.47,130.75 RV10.2 164.83,131.18 164.13,131.88 163.43,131.88 162.55,132.75 v2(162.55,132.95) 162.55,134.22 160.27,136.5 158.68,136.5 158.25,136.93 157.37,136.93 UV1.AU34
XTLI: length 7.9
  TOP w0.114: YVG1.1 23.88,80.15 24.77,81.04 CVG32.1 24.5,83.57 24.5,84.18 v4(24.57,84.24) 24.64,84.32 RVG16.1 25.53,84.32 25.53,84.82 25.71,85 26.09,85 26.58,85.49 UVG2.25
XTLO: length 4.6
  TOP w0.114: YVG1.3 25.89,81.97 CVG33.1 25.89,83.53 26.45,84.09 RVG16.2 26.45,84.47 27.08,85.1 UVG2.26
N09817: length 6
  BOTTOM w0.203: PU601.17 212.53,149.07 211.56,148.11 PC621.2
  BOTTOM w0.254: PC621.2 PC622.1 PR626.1 211.56,144.9 PR625.1
N09897: length 15.4
  TOP w0.254: v3(210.52,142.25) 210.69,142.42 v4(210.69,144.95) 210.69,146.28 212.4,147.99 v3(212.4,148.25)
  BOTTOM w0.203: PU601.16 212.93,148.77 v3(212.4,148.25) 212.4,147.51 PC621.1
  BOTTOM w0.254: 210.7,143.75 PR621.2 210.7,142.43 v3(210.52,142.25) ; 210.7,143.75 210.45,144.01 PR622.2 PC619.2 ; 210.7,143.75 210.7,144.82 PC617.1 210.7,144.87 PR623.1
N10003: length 2.2
  BOTTOM w0.114: PC610.1 206.81,146.57 v4(206.76,146.52)
  BOTTOM w0.254: PC610.1 208.08,146.55 PR613.2
N10023: length 5.5
  BOTTOM w0.203: PC609.2 209.91,147.51 209.91,147.79 211.73,149.6 PU601.19
  BOTTOM w0.254: PC609.2 PR619.2 PC610.2
N10051: length 7.4
  BOTTOM w0.203: PR617.2 209.84,146.55 PR613.1 ; PC609.1 210.75,147.99 212.13,149.37 PU601.18
  BOTTOM w0.254: PR617.2 PR623.2 210.75,146.65 PC609.1 ; PR613.1 PR624.1
N10079: length 0.8
  BOTTOM w0.254: PC617.2 209.84,144.87 PR617.1
N10153: length 2.1
  BOTTOM w0.114: v4(206.94,144.64) 207.14,144.85 PR624.2
  BOTTOM w0.254: PR624.2 PC620.1
N13273: length 3.9
  BOTTOM w0.203: PC635.1 213.32,147.45 PU601.15
  BOTTOM w0.254: PC635.1 PR635.1
N13333: length 0.9
  BOTTOM w0.254: PC635.2 213.34,145.68 PR639.1
N13487: length 52.3
  IN2 w0.254: v3(175.77,134.02) 176.28,134.53 192.42,134.53 193.03,133.92 197.73,133.92 198.28,133.36 202.29,133.36 208.97,140.05 208.97,142.74 211.82,145.58 217.3,145.58 217.71,145.99 v3(217.71,146.17)
  BOTTOM w0.114: v3(175.77,134.02) 175.44,133.69 v4(175.44,133.36)
  BOTTOM w0.254: PR633.2 217.18,146.17 v3(217.71,146.17) ; PRT601.2 v3(175.77,134.02)
N18669: length 1.4
  BOTTOM w0.114: v4(205.26,149.14) 206.66,149.14 PC612.1
N22144: length 1.3
  BOTTOM w0.114: PC618.1 206.64,156.96 v4(206.64,158.05)
N22186: length 1.4
  BOTTOM w0.114: v4(209.3,158.08) 209.3,156.68 PR620.1
N32858: length 3
  TOP w0.114: v4(217.02,151.53) PC636.2
  TOP w0.254: v3(216.03,150.56) 215.88,150.71 PC636.2 PR642.1
N34928: length 8.2
  BOTTOM w0.114: v4(204.68,154.9) 204.68,153.53 PR602.1
  BOTTOM w0.203: PU601.26 208.26,153.05 208.03,153.28 PC605.1
  BOTTOM w0.381: PR602.1 205.31,153.91 206.66,153.91 207.09,153.48 PC605.1
N41772: length 7.1
  BOTTOM w0.114: PR603.2 220.45,151.96 v4(220.78,152.29)
  BOTTOM w0.203: PC601.1 217.54,151.85 PU601.8
  BOTTOM w0.254: PR603.2 220.45,151.12 219.97,150.64 218.55,150.64 218.19,150.99 PC601.1
N193745: length 27.8
  TOP w0.114: v4(204.2,137.83) v3(203.41,137.83)
  IN2 w0.254: v3(218.32,148.4) 218.32,148.07 216.8,146.55 211.26,146.55 207.37,142.66 207.37,140.15 204.83,137.61 203.64,137.61 v3(203.41,137.83)
  BOTTOM w0.203: PR641.1 217.4,149.98 215.3,149.98
  BOTTOM w0.254: v3(203.41,137.83) 203.21,137.63 201.96,137.63 PRT602.1 ; v3(218.32,148.4) 218.32,149.06 PR641.1
N14385930: length 1.4
  TOP w0.084: v1(150.08,151.56) 150.1,151.58 RV7.2
  BOTTOM w0.102: v1(150.08,151.56) 150.29,151.36 150.49,151.16 UV1.AH16
N14386081: length 3.2
  TOP w0.084: RV6.1 v2(144.53,139.92) 144.53,139.77 144.06,139.29 v1(143.37,139.29)
  BOTTOM w0.084: 143.87,139.43 143.73,139.29 v1(143.37,139.29)
  BOTTOM w0.102: UV1.Y30 143.87,139.43
N14386085: length 2.7
  TOP w0.084: RV8.1 142.77,139.79 142.65,139.68 142.65,139.44 142.78,139.31 v2(142.83,139.31) 142.86,139.31 143.41,139.86 v1(143.41,139.94)
  BOTTOM w0.084: v1(143.41,139.94) 143.58,139.94 UV1.Y29
N14410135: length 2.8
  TOP w0.084: v1(137.12,142.59) 137.12,143.13 137.45,143.45 137.45,143.98 137.29,144.13 RV26.2
  BOTTOM w0.102: v1(137.12,142.59) 137.56,142.16 UV1.M27
N14437159: length 7.7
  BOTTOM w0.114: RV17.2 158.93,130.85 158.1,131.69 v2(154.59,131.69) 154.01,132.27 154.01,132.65 153.6,133.06 UV1.AM39
N15168718: length 1.5
  BOTTOM w0.114: v4(134.8,30.93) 134.8,31.71 PR303.1
N15172206: length 1.9
  BOTTOM w0.203: 137.8,39.46 138.64,40.3 PR301.2
N15173757: length 2.9
  BOTTOM w0.254: 136.94,40.02 137.14,40.02 v4(138.28,41.16) PR308.1
N15178230: length 3.5
  BOTTOM w0.114: v4(139.33,36.51) PR302.2
  BOTTOM w0.203: PR302.2 138.66,37.56 138.19,38.03 PU301.13
N15269244: length 5.7
  BOTTOM w0.114: v4(191.19,182.13) 191.19,182.97 PR805.1
  BOTTOM w0.254: 186.98,184.24 188.14,184.24 PR804.2 189.26,183.15 PC805.2 PR805.1
N15269410: length 2.7
  TOP w0.114: v4(180.24,184.98) 181.51,184.98 PR803.1
  TOP w0.254: PC804.2 181.9,184.6 PR803.1
N16794113: length 2.7
  BOTTOM w0.203: PR120.2 173.16,172.58 v4(174,171.74) 174.03,171.71 PU101.11
N16794114: length 4.2
  BOTTOM w0.114: PR121.2 172.95,173.95 v4(172.42,174.49)
  BOTTOM w0.203: PR121.2 173.49,172.94 173.49,172.86 174.24,172.11 PU101.12
N16794121: length 53.7
  IN1 w0.254: v1(181.1,163.74) 181.22,163.87 182.59,163.87 184.49,165.77 186.24,165.77 187.19,164.82 211.45,164.82 220.15,173.52 v3(220.15,177.2)
  BOTTOM w0.114: v1(181.1,163.74) 181.29,163.55 181.29,162.93 v4(180.93,162.57)
  BOTTOM w0.254: v1(181.1,163.74) 180.83,163.74 PC105.2 179.58,164.99 PC107.1 179.23,165.17 PR107.1 ; PR101.1 219.84,176.9 v3(220.15,177.2)
N16794165: length 1.8
  BOTTOM w0.114: PR114.1 184,168.24 v4(184,166.97)
N16794166: length 1.6
  BOTTOM w0.114: PD103.1 186.29,170.6 v4(186.29,172.1)
N16794173: length 1.1
  BOTTOM w0.114: v4(184.69,170.32) PC118.2
N16794272: length 2.9
  BOTTOM w0.203: PR111.2 176.94,167.91 v4(177.29,168.26) PU101.4
N16794274: length 3
  BOTTOM w0.203: PR112.2 178.16,168.31 177.69,168.78 PU101.3
N16794279: length 57.9
  TOP w0.254: v3(221.62,162.68) 222.23,162.68 222.84,162.07 PR102.2 222.84,161.76 222.48,161.41 v4(222.48,160.54) 223.4,159.63 PQ103.1 222.97,158.71 v3(221.77,158.71)
  IN1 w0.254: v3(221.77,158.71) 221.32,159.17 212.3,159.17 208.69,162.78 180.7,162.78 179.3,164.17 178.06,164.17 v3(177.83,163.95)
  BOTTOM w0.254: v3(177.83,163.95) PD101.2 176.94,163.99 PR111.1 ; 222.1,158.84 223.65,158.84 PC102.2 ; PC101.2 v3(221.62,162.68)
N16794300: length 5.1
  BOTTOM w0.203: PC117.2 175.01,167.73 v4(175.56,168.28) 176.49,169.21 PU101.6
  BOTTOM w0.254: PC117.2 PR115.2 PR113.2
N16794308: length 3.2
  BOTTOM w0.203: PU101.5 176.89,168.52 175.88,167.5 PR118.2
N16794310: length 0.8
  BOTTOM w0.254: PR123.1 PC126.2
N16794335: length 3.8
  TOP w0.114: PR105.2 v4(225.1,156.1)
  TOP w0.254: PR104.1 225.01,158.51 PQ103.2 225,157.27 PR105.2
N16794344: length 3.5
  BOTTOM w0.254: 175.42,169.18 174.2,167.96 v4(173.84,167.96) 173.84,168.26 173.23,168.87 PR122.2
N16794345: length 1.8
  BOTTOM w0.254: PR123.2 v4(174.05,169.74) 174.71,169.74
N16794346: length 2.4
  BOTTOM w0.203: PU101.9 174.13,170.91 173.87,170.65 PR124.2
N16797507: length 5.7
  TOP w0.114: v4(69.67,17.05) 69.6,16.98 PR3.2 PR2.2 70.34,15.05 PD1.1 PD3.1
N16797515: length 93.1
  TOP w0.254: v3(60.92,26.89) 61.58,26.89 v4(68.69,19.78) PR3.1 66.07,16.04 64.67,14.64 PQ1.1 64.67,10.66 PQ2.2 62.95,10.56 PC1.2
  IN3 w0.254: v3(60.92,26.89) 60.92,28.32 56.88,32.35 56.88,33.6 50.74,39.74 47.09,39.74 44.96,37.61 34.63,37.61 32.34,39.89 32.34,52.18 34.8,54.64 34.8,66.11 v3(32.98,67.93)
  BOTTOM w0.254: PRT1.2 v3(32.98,67.93)
N16797523: length 4.3
  TOP w0.114: PQ1.3 67.21,15.05 PR2.1 PR1.2 69.17,14.04 v4(69.63,13.58)
N16797527: length 8.9
  TOP w0.114: PQ2.1 66.76,9.69 PQ1.2 67.21,13.12 PR1.1 68.99,12.82 PD2.1 70.16,11.29 v4(70.54,10.91)
N16797541: length 42.3
  BOTTOM w0.254: PRT4.1 141.38,71.06 146.16,71.06 146.74,71.64 146.74,72.73 145.98,73.5 145.98,80.25 144.51,81.73 144.51,83.28 v2(145.14,83.91) 146.39,85.16 146.39,87.14 145.47,88.05 145.47,89.27 142.25,92.5 134.88,92.5 133.43,93.94 PRT5.1
N16797550: length 109.5
  TOP w0.254: v3(202.37,127.17) 202.37,117.72 192.06,107.41 173.56,107.41 170.62,104.46 165.66,104.46 164.75,103.55 164.75,102.32 165.61,101.46 165.61,98.34 159.34,92.06 v4(157.13,92.06) 155.35,90.29 149.82,90.29 149.69,90.41 146.01,90.41 v3(144.79,89.19)
  IN1 w0.254: v3(200.23,134.63) 200.23,129.3 v3(202.37,127.17)
  BOTTOM w0.254: PRT5.2 132.62,95.92 132.62,93.61 134.52,91.71 141.87,91.71 144.38,89.19 v3(144.79,89.19) ; PRT2.1 v3(200.23,134.63)
N16797569: length 65.3
  TOP w0.254: v3(195.26,166.16) 197.03,164.38 200.46,164.38 203.76,161.08 v3(203.76,160.69)
  IN2 w0.254: v3(196.94,134.8) 197.91,134.8 198.66,134.05 201.14,134.05 202.7,135.61 202.7,138.52 204.93,140.75 204.93,142.15 212.28,149.49 216.49,149.49 217.94,150.94 217.94,155.8 216.09,157.65 211.95,157.65 208.91,160.69 v3(203.76,160.69)
  BOTTOM w0.254: v3(196.94,134.8) 197.1,134.63 PRT2.2 ; PRT6.1 195.23,166.18 v3(195.26,166.16)
N16797599: length 142.7
  IN3 w0.254: v3(33.14,65.61) 34.22,64.53 34.22,54.6 31.96,52.34 31.96,39.71 34.45,37.23 45.12,37.23 47.25,39.36 50.58,39.36 56.5,33.44 56.5,32.2 60.03,28.67 60.03,26.84 61.4,25.47 63.23,25.47 64.65,24.04 75.39,24.04 76.35,23.09 104.64,23.09 105.34,22.39 106.79,22.39 110.34,25.95 117.05,25.95 v3(117.53,26.43)
  BOTTOM w0.114: v3(33.14,65.61) 33.1,65.57 v2(33.1,64.99)
  BOTTOM w0.254: PRT3.2 130.87,28.54 127.44,25.11 121.57,25.11 120.25,26.43 v3(117.53,26.43) ; v3(33.14,65.61) 32.98,65.78 PRT1.1
N16797601: length 67.6
  TOP w0.254: v3(145.55,40.6) v4(137.39,40.6) 136.07,41.92 132.64,41.92 130.44,39.71 130.44,30.39 130.69,30.14 v3(131.55,30.14)
  BOTTOM w0.254: PRT3.1 v3(131.55,30.14) ; v3(145.55,40.6) 146.84,41.89 146.84,48.79 150.53,52.47 150.53,61.97 146.28,66.21 146.28,68.65 144.25,70.68 140.39,70.68 139.83,71.24 PRT4.2
N16880265: length 5.2
  TOP w0.305: T96.1 221.01,155.77 v3(221.01,154.85)
  BOTTOM w0.254: PR611.1 219.89,152.08 221.01,153.2 v3(221.01,154.85)
N16880284: length 3.2
  BOTTOM w0.203: PR606.2 216.79,151.45 PU601.9
N16880287: length 3.4
  BOTTOM w0.203: PU601.3 216.27,153.85 217.96,155.54 PR609.2
N16880290: length 3
  BOTTOM w0.203: PU601.5 216.74,153.05 217.51,153.81 PR615.2
N16880296: length 2.7
  BOTTOM w0.203: PR611.2 218.03,152.25 PU601.7
N16880299: length 3.2
  BOTTOM w0.203: PR610.2 217.73,154.68 216.51,153.45 PU601.4
N16901916: length 2.5
  TOP w0.254: PC616.1 v4(184.79,141.26)
  TOP w0.508: PC616.1 186.24,141.14 PR607.1
N16902103: length 1.1
  TOP w0.114: v4(192.03,154.88) 191.19,154.88 PC632.1
N16922606: length 4.5
  TOP w0.254: v3(179.08,174.23) v4(179.08,175.12) 177.67,176.53 v3(177.67,177.08)
  BOTTOM w0.254: PR129.2 177.67,177.22 v3(177.67,177.08)
N16922622: length 5.5
  BOTTOM w0.254: v4(174.07,175.15) 174.91,175.15 175.24,175.48 PR132.1 PC128.1 176.08,177 PR131.1 176.08,177.05 PR129.1 176.08,178.78
N16922664: length 2.6
  BOTTOM w0.203: PU101.16 176.49,174.94 v4(176.33,175.1) 176.1,175.33 176.1,176.11 PR131.2
N16954250: length 5.7
  TOP w0.508: v4(204.37,182.84) PR17.1 PR16.2 204.37,186.14 JBATT1.5
N19577504: length 2.4
  TOP w0.114: UL1.33 48.71,113.59 v2(49,113.3) 49.33,112.97 RL5.2
N19577505: length 3.1
  TOP w0.114: RL6.2 51.11,112.69 50.4,113.4 v2(50.32,113.4) 49.97,113.4 49.51,113.86 UL1.35
N19577517: length 2.2
  TOP w0.114: UL1.30 47.51,113.86 47.45,113.81 47.45,113.3 v2(47.5,113.25) 47.55,113.2 RL7.1
N19577520: length 4.6
  TOP w0.203: UL1.12 45.51,121.08 45.32,121.27 43.9,121.27 43.72,121.45 v4(43.11,121.45) 42.73,121.83 RL8.1
N19577582: length 13.7
  TOP w0.114: UL1.1 49.91,120.86 50.23,121.18 v3(50.44,121.18) ; RL4.1 v3(46.01,111.47)
  BOTTOM w0.114: v3(50.44,121.18) v2(50.44,120.36) 50.44,115.09 46.82,111.47 v3(46.01,111.47)
N26325477:
  vias: v2(142.22,100.95)
N26386889: length 0.5
  BOTTOM w0.114: 143.88,114.02 143.88,114.21 v2(144.14,114.47)
N31349437: length 1.2
  BOTTOM w0.114: v2(130.71,98.19) 130.74,98.21 PC442.2
N31349441:
  vias: v2(126.75,99.99)
N31382737:
  vias: v3(35.34,60.19) v3(35.36,59.43) v3(38.26,58.46) v3(38.26,57.8) v4(38.94,59.7)
N31383366: length 1.3
  TOP w0.114: PC456.2 48.7,60.34 v4(49.89,60.34)
N31383897: length 1.2
  BOTTOM w0.114: v2(34.27,72.35) 35.39,72.35 PC453.2
N31383905: length 1.2
  BOTTOM w0.114: 35.41,75.1 35.29,75.22 v2(35.29,76.24)
N31389989:
  vias: v3(143.77,74.87) v3(143.77,74.21) v3(144.43,74.84) v3(144.46,74.21) v3(145.17,74.87) v3(145.19,74.21) v4(143.77,73.62)
N31390138: length 1.4
  TOP w0.254: PR458.1 140.44,78.22 v4(139.07,78.22)
N31390277:
  vias: v2(138.74,85.71)
N31396697: length 2.9
  TOP w0.114: v4(67.11,124.25) v1(67.62,124.75)
  TOP w0.254: v1(67.62,124.75) 68.64,124.75 PC416.2 PR425.2
N31396723: length 6.9
  BOTTOM w0.114: v2(63,127.75) 63.33,127.42 64.47,127.42 64.83,127.07 PC415.2
  BOTTOM w0.203: PC415.2 PR424.2 65.94,125.9 66.45,125.39 66.45,124.63 67.04,124.04 67.24,124.04
N31396745: length 4
  TOP w0.254: v1(73.02,117.02) 73.11,117.11 PC412.2 PR420.2
  BOTTOM w0.203: v1(73.02,117.02) 72.64,117.02 71.96,117.7 PU401.27
N31396767: length 3.8
  TOP w0.254: v1(71.1,116.85) 71.15,116.91 PC411.2 PR421.1
  BOTTOM w0.203: v1(71.1,116.85) 71.1,117.06 v2(70.76,117.4) PU401.30
N31396821: length 4.3
  BOTTOM w0.203: 73.95,118.84 74,118.89 77.1,118.89 PR414.2 77.27,117.9 PR415.2
N31396831: length 2.1
  BOTTOM w0.114: v2(79.3,118.21) 78.86,118.21 78.52,117.87 PC404.2
  BOTTOM w0.203: PC404.2 78.19,117.9 PR414.1
N31396857: length 2
  BOTTOM w0.114: PR440.2 62.03,120.21 v2(61.83,120)
  BOTTOM w0.254: PC428.1 PR440.2
N31396859: length 5.3
  BOTTOM w0.114: 64.73,120.21 v2(65.61,120.21)
  BOTTOM w0.203: 66.25,121.51 PU401.43
  BOTTOM w0.254: 66.25,121.51 66.03,121.51 64.73,120.21 PC428.2 PC427.2
N31396879: length 4.5
  BOTTOM w0.203: PU401.26 72.36,117.78 72.6,117.54 73.18,117.54 74.05,116.68 74.3,116.68 74.56,116.42 PC409.2
  BOTTOM w0.254: PC409.2 PC410.2
N31396887: length 0.8
  BOTTOM w0.254: PC410.1 76.28,115.31 PR419.2
N31396963: length 3.3
  BOTTOM w0.203: 73.29,118.18 73.56,117.9 74.48,117.9 v2(74.56,117.82) 74.68,117.95 PC407.2 PR416.2
N31397011: length 8.1
  TOP w0.254: PR438.1 63.79,116.84 v3(63.94,116.69)
  BOTTOM w0.203: PR439.1 PC429.1 PC439.1 64.95,117.39 65.41,117.85 65.41,118.23 65.77,118.58 65.77,119.29 66.78,120.31 PU401.40
  BOTTOM w0.254: PC429.1 63.79,117.21 63.79,116.84 v3(63.94,116.69)
N31397019: length 168.6
  TOP w0.114: v3(131.1,82.54) 131.32,82.77 v4(131.93,82.77)
  IN2 w0.254: v3(154.01,90.81) 156.15,90.81 159.35,94 159.35,107.37 156.03,110.69 156.03,118.57 153.12,121.48 144.59,121.48 143.55,120.44 142.86,120.44 141.26,122.03 139.72,122.03 139.06,122.68 139.06,124.82 137.1,126.79 118.28,126.79 116.93,128.14 102.78,128.14 101.05,129.87 91.17,129.87 90.14,128.83 78,128.83 75.9,126.73 73.88,126.73 72.07,124.92 68.82,124.92 66.95,123.05 66.95,122.56 62.48,118.09 v1(62.05,118.09)
  IN3 w0.254: v3(154.01,90.81) 151.2,90.81 148.01,87.62 141.84,87.62 140.96,88.5 138.23,88.5 132.43,82.69 131.25,82.69 v3(131.1,82.54)
  BOTTOM w0.254: v3(131.1,82.54) 130.67,82.97 PRT405.1 ; PR439.2 62.69,118.3 62.48,118.09 v1(62.05,118.09)
N31397040: length 2.6
  BOTTOM w0.203: PU401.31 70.36,117.24 70.62,116.98 70.62,116.58 PR409.1
N31397051: length 4.4
  BOTTOM w0.203: PU401.11 72.36,124.66 73.54,125.85 74.2,125.85 74.48,126.13 PR435.1
  BOTTOM w0.254: PC424.1 74.48,127.27 PR435.1
N31397062: length 100.9
  TOP w0.254: v3(40.72,73.6) 41.13,73.6 41.9,74.37 41.9,75.86 42.73,76.68 42.73,90.76 43.26,91.29 43.26,93.25 46.58,96.57 46.58,101.16 v4(40.03,107.71) v3(38.46,107.71)
  IN3 w0.254: v3(38.46,107.71) 38.44,107.73 38.44,108.09 43.57,113.21 43.57,113.71 44.5,114.64 46.24,114.64 49.84,118.24 49.84,121.38 51.57,123.1 56.32,123.1 57.12,123.9 60.65,123.9 62.49,125.74 69.82,125.74 73.53,129.45 75.43,129.45 76.08,128.81 v3(76.08,127.7)
  BOTTOM w0.254: PR435.2 75.37,126.48 PR436.2 75.7,127.32 v3(76.08,127.7) ; v3(40.72,73.6) 40.72,71.92 38.79,69.99 PRT404.1
