# Allegro board Lenovo ThinkPad E460 E560 BE560 NM-A561 boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D36: length 52
  IN1 w0.076: v3(86.45,86.39) 86.07,86.01 86.07,85.49 85.86,85.29 85.86,83.43 86.72,82.57 86.72,81.98 88.63,80.08 88.63,70.65 88.72,70.56
  IN1 w0.114: 88.72,70.56 88.83,70.45 88.83,69.34 99.24,58.93 99.24,47.18 100.11,46.32 100.51,46.32 100.87,45.96 100.87,44.8 v5(100.4,44.32)
  BOTTOM w0.076: UC1.AR40 v3(86.45,86.39)
  BOTTOM w0.114: JDIMM2.130 101.02,43.7 v5(100.4,44.32)
DDR_B_D37: length 52.8
  IN1 w0.076: 87.94,70.78 87.84,70.88 87.84,80.51 86.33,82.02 86.33,82.42 86.06,82.69 85.65,82.69 85.53,82.82 85.53,83.28 85.71,83.45 85.71,85.35 85.92,85.56 85.92,86.49 v3(86.45,87.02)
  IN1 w0.114: v5(100.42,45.64) 100.32,45.64 98.91,47.05 98.91,58.79 88.5,69.2 88.5,70.22 87.94,70.78
  BOTTOM w0.076: UC1.AP40 v3(86.45,87.02)
  BOTTOM w0.114: JDIMM2.132 101.62,43.86 100.93,44.55 100.93,45.14 v5(100.42,45.64)
DDR_B_D38: length 53.8
  IN1 w0.076: v3(88.28,87.02) 88.81,86.49 88.81,85.54 89.04,85.31 89.04,84.71 88.8,84.46 88.8,83.3 90.99,81.11 90.99,78.53 91.37,78.14 91.37,77.82
  IN1 w0.114: 91.37,77.82 91.37,72.84 91.55,72.66 91.55,71.87 103.55,59.87 103.55,46.31 103.82,46.04 103.82,45.23 104.02,45.02 104.27,45.02 104.48,44.82 104.48,44.53 104.27,44.32 v5(103.37,44.32)
  BOTTOM w0.076: UC1.AP37 v3(88.28,87.02)
  BOTTOM w0.114: v5(103.37,44.32) 104.02,43.67 JDIMM2.140
DDR_B_D39: length 53.3
  IN1 w0.076: v3(88.28,86.39) 88.66,86.01 88.66,85.48 88.86,85.27 88.86,84.84 88.58,84.56 88.58,83.22 90.02,81.78 90.02,80.96 90.84,80.15 90.84,78.46 91.01,78.28 91.01,78.01
  IN1 w0.114: 91.01,78.01 91.01,72.63 91.22,72.43 91.22,71.72 103.19,59.74 103.19,50.12 103.22,50.09 103.22,47.02 103.1,46.91 102.48,46.91 102.37,46.79 102.37,46.38 102.48,46.26 103.1,46.26 103.22,46.15 103.22,45.76 v5(103.36,45.61)
  BOTTOM w0.076: UC1.AR37 v3(88.28,86.39)
  BOTTOM w0.114: v5(103.36,45.61) 103.42,45.61 104.62,44.41 JDIMM2.142
DDR_B_D40: length 55.1
  IN1 w0.076: v3(90.11,85.75) 90.11,85.66 89.71,85.27 89.71,84.86 90.33,84.25 90.33,82.44 91.57,81.19 91.57,79.82 91.98,79.41 92.43,79.41 92.92,78.92
  IN1 w0.114: v5(105.53,46.72) 105.11,47.14 105.11,48.22 105.39,48.5 105.39,50.94 104.83,51.5 104.83,60.43 100.25,65.01 100.25,65.17 100.44,65.36 100.44,65.52 100.16,65.8 100,65.8 99.81,65.61 99.65,65.61 99.37,65.89 99.37,66.05 99.56,66.24 99.56,66.4 99.28,66.68 99.12,66.68 98.93,66.49 98.77,66.49 98.49,66.77 98.49,66.93 98.68,67.12 98.68,67.28 98.4,67.56 98.24,67.56 98.05,67.37 97.89,67.37 97.61,67.65 97.61,67.81 97.8,68 97.8,68.16 97.52,68.44 97.36,68.44 97.17,68.25 97.01,68.25 96.73,68.53 96.73,68.69 96.92,68.88 96.92,69.04 96.64,69.32 96.48,69.32 96.29,69.13 96.13,69.13 95.85,69.41 95.85,69.57 96.04,69.76 96.04,69.92 92.92,73.04 92.92,78.92
  BOTTOM w0.076: v3(90.11,85.75) 90.29,85.89 UC1.AT33
  BOTTOM w0.114: JDIMM2.147 106.12,48.79 105.88,48.55 105.39,48.55 105.11,48.27 105.11,47.14 v5(105.53,46.72)
DDR_B_D41: length 54.7
  IN1 w0.076: v3(90.11,85.12) 90.11,84.69 90.64,84.15 90.64,82.35 91.78,81.22 91.78,79.97 92.03,79.72 92.98,79.72 93.23,79.47 93.23,79.35
  IN1 w0.114: 93.23,79.35 93.23,73.21 101.88,64.56 101.88,64.4 101.68,64.2 101.68,64.04 101.96,63.76 102.12,63.76 102.32,63.96 102.48,63.96 102.76,63.68 102.76,63.52 102.56,63.32 102.56,63.16 102.84,62.88 103,62.88 103.2,63.08 103.36,63.08 103.64,62.8 103.64,62.64 103.44,62.44 103.44,62.28 103.72,62 103.88,62 104.08,62.2 104.24,62.2 104.52,61.92 104.52,61.76 104.32,61.56 104.32,61.4 105.16,60.56 105.16,57.65 105.28,57.53 105.61,57.53 105.72,57.42 105.72,57.02 105.61,56.91 105.28,56.91 105.16,56.79 105.16,56.4 105.28,56.29 105.61,56.29 105.72,56.17 105.72,55.78 105.61,55.66 105.28,55.66 105.16,55.55 105.16,55.16 105.28,55.04 105.61,55.04 105.72,54.93 105.72,54.53 105.61,54.42 105.28,54.42 105.16,54.3 105.16,53.91 105.28,53.8 105.61,53.8 105.72,53.68 105.72,53.29 105.61,53.17 105.28,53.17 105.16,53.06 105.16,52.67 105.28,52.55 105.61,52.55 105.74,52.42 105.74,48.22 v5(105.61,48.09)
  BOTTOM w0.076: v3(90.11,85.12) 90.29,85.25 UC1.AU33
  BOTTOM w0.114: JDIMM2.149 106.72,47.75 106.53,47.56 106.14,47.56 v5(105.61,48.09)
DDR_B_D42: length 53.8
  IN1 w0.076: v5(91.94,85.12) 92.25,84.81 92.25,82.72 92.76,82.21 92.76,81.23 93.33,80.66 93.78,80.66 94.44,80 94.44,73.42 96.6,71.26 96.86,71.26 96.97,71.15
  IN1 w0.114: 96.97,71.15 97.52,70.6 97.98,70.6 106.62,61.97 106.62,58.68 107.19,58.1 107.19,57.77 107.31,57.66 107.64,57.66 107.75,57.54 107.75,57.15 107.64,57.04 107.31,57.04 107.19,56.92 107.19,56.53 107.31,56.41 107.64,56.41 107.75,56.3 107.75,55.91 107.64,55.79 107.31,55.79 107.19,55.68 107.19,55.28 107.31,55.17 107.64,55.17 107.75,55.05 107.75,54.66 107.64,54.55 107.31,54.55 107.19,54.43 107.19,54.04 107.31,53.92 107.64,53.92 107.75,53.81 107.75,53.42 107.64,53.3 107.31,53.3 107.19,53.19 107.19,50.3 107.31,50.19 107.64,50.19 107.75,50.08 107.75,49.68 107.64,49.57 107.31,49.57 107.19,49.45 107.19,48.01 v3(107.64,47.56)
  BOTTOM w0.076: UC1.AU30 v5(91.94,85.12)
  BOTTOM w0.114: JDIMM2.157 109.12,50.35 109.12,48.78 108.97,48.63 108.77,48.63 108.54,48.86 108.29,48.86 108.11,48.68 108.11,47.77 107.91,47.56 v3(107.64,47.56)
DDR_B_D43: length 54.4
  IN1 w0.076: 96.55,71.59 94.62,73.52 94.62,80.05 93.77,80.9 93.34,80.9 92.94,81.3 92.94,82.27 92.45,82.76 92.45,85.15 91.94,85.66 v3(91.94,85.75)
  IN1 w0.114: v5(107.7,46.88) 108.08,47.26 108.08,50.89 107.52,51.45 107.52,52.14 108.08,52.69 108.08,57.73 106.95,58.86 106.95,62.1 101.05,68 101.05,68.21 101.33,68.49 101.33,68.85 100.93,69.25 100.42,69.25 100.17,69.49 100.17,69.85 99.89,70.13 99.73,70.13 99.56,69.96 99.3,69.96 99.12,70.14 99.12,70.4 99.32,70.6 99.32,70.86 98.84,71.34 98.42,71.34 98.31,71.22 98.31,71.1 98.19,70.98 97.8,70.98 97.68,71.1 97.68,71.48 97.57,71.59 96.55,71.59
  BOTTOM w0.076: UC1.AT30 v3(91.94,85.75)
  BOTTOM w0.114: v5(107.7,46.88) 107.78,46.88 109.72,48.82 109.72,50.35 JDIMM2.159
DDR_B_D44: length 55.9
  IN1 w0.076: v3(90.11,86.39) 89.73,86.01 89.73,85.49 89.53,85.29 89.53,84.76 90.18,84.11 90.18,82.35 91.32,81.21 91.32,79.29 91.5,79.11 92.37,79.11 92.63,78.84 92.63,78.68
  IN1 w0.114: v5(105.24,44.19) 105.57,44.19 105.68,44.07 105.68,43.51 105.87,43.32 106.14,43.32 106.32,43.51 106.32,45.84 105.9,46.27 105.34,46.27 104.78,46.83 104.78,48.36 105.06,48.64 105.06,50.8 104.5,51.36 104.5,60.29 95.34,69.45 95.34,70.13 92.63,72.84 92.63,78.68
  BOTTOM w0.076: UC1.AR33 90.29,86.53 v3(90.11,86.39)
  BOTTOM w0.114: v5(105.24,44.19) 105.82,43.6 JDIMM2.146
DDR_B_D45: length 56.8
  IN1 w0.076: 92.31,78.33 92.31,78.5 92.13,78.68 91.29,78.68 91.14,78.83 91.14,81.17 89.92,82.39 89.92,84.11 89.32,84.71 89.32,85.3 89.57,85.56 89.57,86.49 90.11,87.02 v3(90.11,87.02)
  IN1 w0.114: 92.31,78.33 92.31,72 92.49,71.82 92.65,71.82 92.8,71.97 92.97,71.97 93.24,71.69 93.24,71.53 93.09,71.38 93.09,71.21 93.37,70.93 93.53,70.93 93.68,71.09 93.85,71.09 94.13,70.81 94.13,70.65 93.97,70.49 93.97,70.33 94.25,70.05 94.41,70.05 94.57,70.21 94.73,70.21 95.01,69.93 95.01,69.76 94.85,69.61 94.85,69.45 104.17,60.14 104.17,50.93 104.29,50.82 104.57,50.82 104.68,50.71 104.68,50.29 104.57,50.17 104.29,50.17 104.17,50.06 104.17,49.64 104.29,49.53 104.57,49.53 104.68,49.41 104.68,48.73 104.17,48.22 104.17,46.65 104.45,46.37 104.45,45.81 104.63,45.63 105.1,45.63 v5(105.27,45.46)
  BOTTOM w0.076: v3(90.11,87.02) 90.29,87.17 UC1.AP33
  BOTTOM w0.114: JDIMM2.148 106.42,44.31 v5(105.27,45.46)
DDR_B_D46: length 55.2
  IN1 w0.076: 99.76,71 98.86,71.9 96.55,71.9 94.86,73.59 94.86,80.09 93.71,81.24 93.71,82.08 92.63,83.17 92.63,85.18 92.32,85.49 92.32,86.01 v3(91.94,86.39)
  IN1 w0.114: v5(110.52,45.63) 109.86,45.63 108.41,47.08 108.41,51.03 107.85,51.59 107.85,52 108.41,52.56 108.41,57.87 107.28,59 107.28,62.24 101.66,67.86 101.66,69.1 99.76,71
  BOTTOM w0.076: UC1.AR30 v3(91.94,86.39)
  BOTTOM w0.114: JDIMM2.158 109.42,43.87 110.52,44.97 v5(110.52,45.63)
DDR_B_D47: length 56
  IN1 w0.076: 99.59,72.04 99.47,72.15 97.08,72.15 95.89,73.34 95.89,79.8 95.48,80.2 94.98,80.2 93.88,81.3 93.88,82.13 92.81,83.2 92.81,85.22 92.47,85.56 92.47,86.49 91.94,87.02 v3(91.94,87.02)
  IN1 w0.114: v5(110.57,44.31) 111.08,44.82 111.08,45.71 110.68,46.11 109.89,46.11 108.74,47.26 108.74,58 107.61,59.14 107.61,62.38 101.99,68 101.99,69.25 101.45,69.79 101.45,70.17 99.59,72.04
  BOTTOM w0.076: UC1.AP30 v3(91.94,87.02)
  BOTTOM w0.114: JDIMM2.160 110.02,43.76 v5(110.57,44.31)
DDR_B_D48: length 56.1
  IN1 w0.076: 98.08,78.7 97.82,78.96 97.62,78.96 95.64,80.93 95.33,80.93 94.75,81.51 94.75,82.25 93.55,83.44 93.55,84.89 v5(93.77,85.1)
  IN1 w0.114: v3(110.52,48.25) 110.78,48.25 110.95,48.43 110.95,56.73 110.84,56.85 110.48,56.85 110.37,56.96 110.37,57.36 110.48,57.47 110.84,57.47 110.95,57.58 110.95,57.98 110.84,58.09 110.48,58.09 110.37,58.21 110.37,58.6 110.48,58.71 110.62,58.71 110.8,58.9 110.8,59.15 110.62,59.34 110.48,59.34 110.37,59.45 110.37,59.76 109.22,60.9 109.22,63.27 105.94,66.55 105.94,66.6 105.92,66.61 105.92,67.17 105.04,68.05 104.64,68.05 103.62,69.07 103.62,70.37 100.79,73.19 98.23,73.19 98.08,73.34 98.08,73.71 98.19,73.83 98.72,73.83 98.84,73.94 98.84,74.31 98.7,74.45 98.19,74.45 98.08,74.56 98.08,74.96 98.19,75.07 98.72,75.07 98.84,75.19 98.84,75.55 98.7,75.69 98.19,75.69 98.08,75.81 98.08,76.2 98.19,76.32 98.72,76.32 98.84,76.43 98.84,76.8 98.7,76.94 98.19,76.94 98.08,77.05 98.08,77.45 98.19,77.56 98.72,77.56 98.84,77.67 98.84,78.04 98.7,78.18 98.19,78.18 98.08,78.3 98.08,78.7
  BOTTOM w0.076: UC1.AU27 v5(93.77,85.1)
  BOTTOM w0.114: v3(110.52,48.25) 111.08,48.81 111.08,49.21 110.92,49.38 JDIMM2.163
DDR_B_D49: length 56.7
  IN1 w0.076: 100.85,72.61 100.56,72.89 98.15,72.89 97.82,73.22 97.82,77.84 97.21,78.45 97.21,79.15 95.58,80.78 95.27,80.78 94.47,81.58 94.47,82.3 93.37,83.39 93.37,85.25 93.77,85.64 v3(93.77,85.75)
  IN1 w0.114: v5(110.52,47.54) 110.34,47.54 110.04,47.84 110.04,49.44 110.15,49.56 110.51,49.56 110.62,49.67 110.62,50.07 110.51,50.18 110.15,50.18 110.04,50.29 110.04,50.69 110.15,50.8 110.51,50.8 110.62,50.92 110.62,51.31 110.51,51.42 110.15,51.42 110.04,51.54 110.04,51.93 110.15,52.05 110.51,52.05 110.62,52.16 110.62,52.56 110.51,52.67 110.15,52.67 110.04,52.78 110.04,53.18 110.15,53.29 110.51,53.29 110.62,53.41 110.62,53.8 110.51,53.91 110.15,53.91 110.04,54.03 110.04,54.42 110.15,54.54 110.51,54.54 110.62,54.65 110.62,55.04 110.51,55.16 110.15,55.16 110.04,55.27 110.04,55.67 110.15,55.78 110.51,55.78 110.62,55.9 110.62,56.29 110.51,56.4 110.15,56.4 110.04,56.52 110.04,59.5 109.59,59.95 109.05,59.95 108.89,60.1 108.89,62.91 103.28,68.52 103.28,70.17 100.85,72.61
  BOTTOM w0.076: UC1.AT27 v3(93.77,85.75)
  BOTTOM w0.114: v5(110.52,47.54) 111.52,48.54 JDIMM2.165
DDR_B_D50: length 55.2
  IN1 w0.076: 105.29,70.94 105.29,71.29 104.92,71.66 104.06,71.66 101.28,74.44 101.28,78.02 100.26,79.03 99.29,79.03 97.62,80.71 96.97,80.71 96.43,81.25 96.43,82.03 95.06,83.4 95.06,85.28 94.68,85.66 v3(94.68,85.75)
  IN1 w0.114: 105.29,70.94 105.29,70.65 111.25,64.7 111.25,61.46 112.88,59.82 112.88,55.82 113,55.7 113.99,55.7 114.1,55.59 114.1,55.2 113.99,55.08 113,55.08 112.88,54.97 112.88,54.57 113,54.46 113.99,54.46 114.1,54.34 114.1,53.95 113.99,53.84 113,53.84 112.88,53.72 112.88,53.48 113.05,53.31 113.82,53.31 114.18,52.96 114.18,49.27 114.84,48.6 v5(115.45,48.6)
  BOTTOM w0.076: UC1.AT25 v3(94.68,85.75)
  BOTTOM w0.114: v5(115.45,48.6) 115.27,48.6 114.52,49.36 JDIMM2.175
DDR_B_D51: length 54.6
  IN1 w0.076: 105.11,70.17 100.92,74.36 100.92,77.99 100.11,78.81 99.22,78.81 97.54,80.48 96.96,80.48 96.25,81.19 96.25,81.96 94.84,83.37 94.84,84.32 94.68,84.48 v3(94.68,85.12)
  IN1 w0.114: v5(115.45,47.31) 114.71,47.31 114.13,46.73 113.49,46.73 113.16,47.06 113.16,48.71 113.85,49.39 113.85,52.82 113.69,52.98 112.7,52.98 112.55,53.13 112.55,59.68 110.66,61.57 110.66,63.88 107.4,67.15 107.4,67.88 105.11,70.17
  BOTTOM w0.076: UC1.AU25 v3(94.68,85.12)
  BOTTOM w0.114: JDIMM2.177 115.12,49.57 116.01,48.68 116.01,47.87 v5(115.45,47.31)
DDR_B_D52: length 56.9
  IN1 w0.076: 100.51,72.41 100.31,72.61 97.34,72.61 96.7,73.24 96.7,79.44 95.52,80.63 95.2,80.63 94.3,81.53 94.3,82.26 93.19,83.36 93.19,85.28 93.38,85.48 93.38,86.57 93.77,86.95 v3(93.77,87.02)
  IN1 w0.114: v5(112.35,45.73) 112.35,46.06 111.33,47.08 110.32,47.08 109.7,47.7 109.7,59.29 109.37,59.62 108.91,59.62 108.56,59.96 108.56,62.77 102.95,68.38 102.95,69.97 100.51,72.41
  BOTTOM w0.076: UC1.AP27 v3(93.77,87.02)
  BOTTOM w0.114: JDIMM2.164 111.22,44.6 v5(112.35,45.73)
DDR_B_D53: length 57.8
  IN1 w0.076: 100.18,72.15 99.96,72.38 97.24,72.38 96.25,73.37 96.25,79.68 95.55,80.38 95.08,80.38 94.13,81.33 94.13,82.21 93.04,83.3 93.04,85.35 93.23,85.54 93.23,87.13 93.76,87.66 v3(93.77,87.66)
  IN1 w0.114: v5(112.35,44.44) 112.54,44.44 112.73,44.63 112.73,44.91 112.54,45.1 111.94,45.1 111.7,45.34 111.7,46 110.97,46.73 110.15,46.73 109.37,47.52 109.37,58.45 108.23,59.58 108.23,62.64 102.62,68.24 102.62,69.71 100.18,72.15
  BOTTOM w0.076: UC1.AN27 v3(93.77,87.66)
  BOTTOM w0.114: v5(112.35,44.44) 111.82,43.91 JDIMM2.166
DDR_B_D54: length 57
  IN1 w0.076: 100.01,79.49 99.58,79.49 95.44,83.63 95.44,85.33 95.21,85.56 95.21,87.13 v3(94.68,87.66)
  IN1 w0.114: 100.01,79.49 100.94,79.49 103.43,77 103.43,73.95 107,70.39 107,70.05 111.91,65.15 111.91,61.73 113.54,60.09 113.54,57.3 114.89,55.96 114.89,50.66 116.36,49.19 116.36,46.5 116.24,46.37 116.24,45.71 115.45,44.92 v5(115.45,44.41)
  BOTTOM w0.076: UC1.AN25 v3(94.68,87.66)
  BOTTOM w0.114: JDIMM2.174 114.22,43.63 115.01,44.41 v5(115.45,44.41)
DDR_B_D55: length 56.6
  IN1 w0.076: v3(94.68,87.02) 94.68,86.95 95.06,86.57 95.06,85.49 95.25,85.3 95.25,83.46 96.65,82.06 96.65,81.25 96.99,80.91 97.77,80.91 99.42,79.26 100.44,79.26 101.56,78.14 101.56,76.11
  IN1 w0.114: 101.56,76.11 102.94,74.73 102.94,73.99 106.46,70.47 106.46,70.09 111.58,64.97 111.58,61.6 113.21,59.96 113.21,57.16 114.53,55.84 114.53,50.48 116.03,48.99 116.03,46.8 115.91,46.67 115.91,46.09 v5(115.5,45.68)
  BOTTOM w0.076: UC1.AP25 v3(94.68,87.02)
  BOTTOM w0.114: v5(115.5,45.68) 115.96,45.23 115.96,44.21 115.7,43.96 115.07,43.96 114.82,43.71 JDIMM2.176
DDR_B_D56: length 60.2
  IN1 w0.076: v3(96.51,85.75) 96.51,85.64 96.08,85.21 96.08,83.9 99.77,80.2 101.61,80.2 103.41,78.4 104.63,78.4 105.49,77.54 105.49,73.43 108.75,70.17
  IN1 w0.114: 108.75,70.17 110.14,68.78 111.66,68.78 112.12,68.32 112.12,66.75 113.19,65.68 113.19,63.71 114.83,62.07 114.83,57.83 115.85,56.81 117.37,56.81 117.56,56.63 117.56,56.37 117.37,56.19 116.29,56.19 116.17,56.07 116.17,55.68 116.29,55.56 117.82,55.56 117.94,55.45 117.94,55.06 117.82,54.94 116.29,54.94 116.17,54.83 116.17,54.59 116.35,54.4 117.6,54.4 118.03,53.98 118.03,50.09 118.24,49.87 118.24,48.66 v5(117.79,48.2)
  BOTTOM w0.076: UC1.AT22 96.89,86.05 v3(96.51,85.75)
  BOTTOM w0.114: v5(117.79,48.2) 117.07,48.2 116.32,48.95 JDIMM2.181
DDR_B_D57: length 59.8
  IN1 w0.076: v3(96.51,85.1) 96.41,85.01 96.41,83.9 99.88,80.43 102.22,80.43 103.67,78.98 104.61,78.98 105.92,77.66 105.92,73.32 108.55,70.69
  IN1 w0.114: 108.55,70.69 108.7,70.69 110.27,69.12 111.8,69.12 112.45,68.46 112.45,66.89 113.52,65.82 113.52,63.85 115.16,62.21 115.16,59.74 118.36,56.54 118.36,50.71 118.57,50.49 118.57,45.19 118.38,45 118.11,45 117.91,45.19 117.91,46.78 v5(117.79,46.9)
  BOTTOM w0.076: v3(96.51,85.1) 96.89,85.4 UC1.AU22
  BOTTOM w0.114: JDIMM2.183 116.92,49.06 117.35,48.63 118.04,48.63 118.27,48.4 118.27,47.39 v5(117.79,46.9)
DDR_B_D58: length 58.8
  IN1 w0.076: 109.18,71.52 108.64,71.52 107.27,72.89 107.27,77.92 105.33,79.86 103.78,79.86 102.52,81.12 101.17,81.12 97.42,84.87 v3(97.42,85.1)
  IN1 w0.114: 109.18,71.52 111.45,71.52 113.89,69.07 113.89,67.49 115.06,66.33 115.06,65.14 115.47,64.72 115.47,63.94 115.49,63.92 115.49,63.92 116.6,62.81 116.6,60.85 120.55,56.9 120.55,52.34 120.67,52.22 121.25,52.22 121.37,52.11 121.37,51.71 121.25,51.6 120.38,51.6 120.2,51.42 120.2,51.16 120.38,50.98 120.75,50.98 120.94,50.79 120.94,50.54 120.75,50.35 120.4,50.35 120.05,50 120.05,47.16 120.3,46.9 v5(120.53,46.9)
  BOTTOM w0.076: UC1.AU21 v3(97.42,85.1)
  BOTTOM w0.114: v5(120.53,46.9) 119.32,48.11 JDIMM2.191
DDR_B_D59: length 59.5
  IN1 w0.076: v3(97.42,85.75) 97.42,85.68 97.82,85.28 97.82,84.85 101.28,81.4 102.65,81.4 103.91,80.13 105.36,80.13 107.5,77.99 107.5,72.96 108.72,71.74 109.18,71.74
  IN1 w0.114: 109.18,71.74 111.69,71.74 116.03,67.4 116.03,67.4 116.36,67.07 116.36,66 116.25,65.88 115.66,65.88 115.55,65.77 115.55,65.35 115.66,65.23 116.25,65.23 116.36,65.12 116.36,64.7 116.25,64.59 115.94,64.59 115.82,64.47 115.82,64.05 115.94,63.94 116.25,63.94 116.36,63.82 116.36,63.51 116.93,62.95 116.93,60.99 121.04,56.88 121.04,55.56 121.15,55.45 121.49,55.45 121.67,55.27 121.67,55.01 121.49,54.83 121.15,54.83 121.04,54.71 121.04,54.32 121.15,54.21 121.79,54.21 121.9,54.09 121.9,53.7 121.79,53.58 121.15,53.58 121.04,53.47 121.04,53.07 121.15,52.96 121.79,52.96 121.9,52.85 121.9,49.79 121.32,49.21 121.32,49.01 v5(120.53,48.22)
  BOTTOM w0.076: UC1.AT21 v3(97.42,85.75)
  BOTTOM w0.114: JDIMM2.193 119.92,48.83 v5(120.53,48.22)
DDR_B_D60: length 61.8
  IN1 w0.076: v3(96.51,87.66) 95.98,87.13 95.98,85.54 95.69,85.26 95.69,83.72 99.72,79.69 99.98,79.69
  IN1 w0.114: v5(117.3,44.38) 117.18,44.26 116.39,44.26 116.14,44.51 116.14,44.74 116.86,45.45 116.86,46.11 116.99,46.24 116.99,50.22 116.72,50.48 116.06,50.48 115.83,50.71 115.83,51.04 116.06,51.27 116.92,51.27 117.2,51.55 117.2,51.95 116.92,52.24 115.7,52.24 115.51,52.43 115.51,56.21 114.17,57.56 114.17,61.8 112.53,63.44 112.53,65.41 104.73,73.21 104.73,77.05 104.18,77.6 103.32,77.6 101.23,79.69 99.98,79.69
  BOTTOM w0.076: v3(96.51,87.66) UC1.AN22
  BOTTOM w0.114: JDIMM2.180 116.02,43.66 116.74,44.38 v5(117.3,44.38)
DDR_B_D61: length 61.5
  IN1 w0.076: v3(96.51,87.02) 96.13,86.64 96.13,85.48 95.87,85.22 95.87,83.81 99.74,79.95 99.91,79.95
  IN1 w0.114: v5(117.35,45.68) 117.35,46.36 117.32,46.39 117.32,50.08 117.7,50.46 117.7,52.17 117.2,52.67 116.11,52.67 115.84,52.94 115.84,53.34 115.96,53.45 116.97,53.45 117.15,53.63 117.15,53.89 116.97,54.07 115.96,54.07 115.84,54.19 115.84,56.35 114.5,57.7 114.5,61.94 112.86,63.58 112.86,65.55 111.79,66.61 111.79,68.19 111.52,68.45 110,68.45 105.11,73.34 105.11,77.38 104.44,78.06 103.27,78.06 101.38,79.95 99.91,79.95
  BOTTOM w0.076: v3(96.51,87.02) 96.89,87.34 UC1.AP22
  BOTTOM w0.114: JDIMM2.182 116.62,43.53 117.05,43.96 117.62,43.96 117.79,44.12 117.79,45.38 117.48,45.68 v5(117.35,45.68)
DDR_B_D62: length 60.6
  IN1 w0.076: v3(97.42,87.02) 97.82,86.63 97.82,85.52 99.04,84.29 99.51,84.29 101.54,82.26 102.14,82.26 104.02,80.38 106.21,80.38 107.7,78.88 107.7,73.12 108.82,72 109.13,72
  IN1 w0.114: v5(120.88,45.68) 121.67,46.47 121.67,49.1 122.36,49.78 122.36,56.22 117.26,61.32 117.26,63.08 117,63.34 116.8,63.55 116.8,67.11 111.91,72 109.13,72
  BOTTOM w0.076: UC1.AP21 v3(97.42,87.02)
  BOTTOM w0.114: v5(120.88,45.68) 120.43,45.23 120.43,44.59 119.62,43.78 JDIMM2.192
DDR_B_D63: length 61.4
  IN1 w0.076: v3(97.42,87.66) 97.97,87.11 97.97,85.6 99.1,84.47 99.55,84.47 101.58,82.44 102.34,82.44 104.1,80.68 106.2,80.68 107.98,78.91 107.98,73.19 108.82,72.35 109.08,72.35
  IN1 w0.114: 109.08,72.35 112.02,72.35 117.13,67.24 117.13,63.68 117.33,63.48 117.59,63.22 117.59,61.89 122.69,56.79 122.69,49.65 122.03,48.99 122.03,45.47 v5(120.92,44.36)
  BOTTOM w0.076: UC1.AN21 v3(97.42,87.66)
  BOTTOM w0.114: v5(120.92,44.36) 120.22,43.66 JDIMM2.194
DDR_B_DQS0: length 69.1
  IN1 w0.076: v3(73.27,90.13) 73.21,90.13 72.7,89.63 72.57,89.63 72.55,89.6 71.46,89.6 70.46,88.61 70.13,88.61 67.81,86.28 67.81,85.37 67.33,84.89 65.15,84.89 64.94,84.69 64.94,84.69 64.93,84.67
  IN1 w0.114: v5(66.69,47.58) 67,47.89 67.15,47.89 67.38,48.12 67.38,49.48 58.52,58.34 58.52,77.62 58.02,78.11 57.7,78.11 57.34,77.75 57.07,77.75 56.88,77.94 56.88,78.21 57.24,78.57 57.24,78.9 56.95,79.18 56.95,79.37 57.23,79.64 57.41,79.64 59.37,77.68 59.7,77.68 60.11,78.09 60.11,78.42 59.95,78.57 59.95,78.73 60.25,79.03 60.41,79.03 60.57,78.88 60.89,78.88 63.26,81.25 63.26,83.01 63.52,83.26 63.52,83.59 62.79,84.32 62.79,84.48 63.08,84.78 63.24,84.78 63.98,84.05 64.3,84.05 64.93,84.67
  BOTTOM w0.076: UC1.AH65 v3(73.27,90.13)
  BOTTOM w0.127: JDIMM2.29 68.32,49.48 68.12,49.28 68.12,48.72 67.16,47.77 66.87,47.77 v5(66.69,47.58)
DDR_B_DQS1: length 73.2
  IN1 w0.076: 62.87,91.3 62.89,91.3 62.91,91.28 65.48,91.28 65.77,90.99 65.77,90.81 v3(65.97,90.62)
  IN1 w0.114: 62.87,91.3 57.36,91.3 52.08,86.02 52.08,71.37 53.94,69.5 53.94,54.03 58.32,49.65 59.6,49.65 60.25,49 60.25,48.58 61.19,47.64 61.19,46.12 62.16,45.15 62.16,44.97 62.01,44.82 61.74,44.82 v5(61.54,45.02)
  BOTTOM w0.076: v3(65.97,90.62) 65.75,90.41 65.75,90.3 65.89,90.17 66.83,90.17 67.59,90.92 68.72,90.92 68.72,90.92 69.2,90.92 69.3,90.87 69.46,90.87 69.57,90.92 69.84,90.92 69.92,90.88 70.17,90.88 70.21,90.92 70.36,90.92 70.39,90.94 70.39,91.1 70.34,91.15 UC1.AG70
  BOTTOM w0.127: JDIMM2.12 63.22,43.33 62.99,43.56 62.99,44.34 62.51,44.81 61.75,44.81 v5(61.54,45.02)
DDR_B_DQS2: length 54.8
  IN1 w0.076: v3(72.73,86.39) 72.53,86.18 72.53,86.1 72.36,85.93 72.36,84.18 71.98,83.8 71.24,83.8 70.35,82.91 69.85,82.91 69.7,82.77 69.7,82.26 69.52,82.08 69.27,82.08 69.14,81.96 69.14,81.71 68.97,81.54 68.47,81.54 68.39,81.46 68.39,80.95 68.17,80.73 67.51,80.73 67.22,80.44 67.22,80.12
  IN1 w0.114: v5(71.41,46.83) 71.51,46.83 72.08,47.4 72.08,50.09 64.47,57.7 64.47,74.26 66.73,76.52 66.73,77.38 66.42,77.68 65.67,77.68 65.46,77.89 65.46,78.12 67.22,79.88 67.22,80.12
  BOTTOM w0.076: UC1.AR65 73.1,86.75 v3(72.73,86.39)
  BOTTOM w0.127: JDIMM2.47 73.72,49.45 73.36,49.09 73.36,48.45 71.89,46.98 71.56,46.98 v5(71.41,46.83)
DDR_B_DQS3: length 52.8
  IN1 w0.076: v3(75.48,86.39) 75.1,86.01 75.1,84.79 75.22,84.66 75.22,83.49 74.08,82.34 74.08,81.56 73.61,81.08 73.07,81.08 71.08,79.08 71.08,75.45 70.57,74.95 70.57,73.59 70.59,73.57 70.59,73.55
  IN1 w0.114: v5(78.49,45.02) 78.31,44.85 77.99,44.85 77.45,45.38 77.45,49.16 76.74,49.87 76.74,51.22 69.62,58.34 69.62,72.07 70.59,73.04 70.59,73.55
  BOTTOM w0.076: UC1.AR60 75.84,86.75 v3(75.48,86.39)
  BOTTOM w0.127: v5(78.49,45.02) 78.71,44.81 79.04,44.81 79.3,44.54 79.3,44.06 78.66,43.41 78.66,43.08 78.82,42.92 JDIMM2.64
DDR_B_DQS4: length 52.2
  IN1 w0.076: v3(87.36,86.39) 87.9,85.86 87.9,82.86 89.4,81.36 89.4,80.83 89.62,80.6 89.62,71.18 90.33,70.47 90.33,70.21 90.35,70.19 90.35,70.17
  IN1 w0.114: v5(101.8,47.48) 102.02,47.69 102.25,47.69 102.57,48.02 102.57,49.27 102.3,49.55 101.66,49.55 101.5,49.71 101.5,50.04 101.64,50.18 102.34,50.18 102.57,50.41 102.57,51.04 102.37,51.23 101.47,51.23 101.34,51.36 101.34,58.93 90.35,69.91 90.35,70.17
  BOTTOM w0.076: UC1.AR38 v3(87.36,86.39)
  BOTTOM w0.127: JDIMM2.137 103.12,49.48 102.94,49.3 102.94,48.06 102.67,47.79 102.12,47.79 v5(101.8,47.48)
DDR_B_DQS5: length 54.9
  IN1 w0.076: v5(91.02,86.39) 90.49,85.86 90.49,84.66 90.89,84.27 90.89,83.3 92.25,81.94 92.25,80.44 92.52,80.17 93.79,80.17 94.08,79.88 94.08,72.95 96.23,70.8 96.57,70.8 97.15,70.21 97.15,70.18 97.17,70.17
  IN1 w0.114: v3(108.73,44.2) 108.54,44.39 107.9,44.39 107.28,45.01 107.28,46.01 106.36,46.92 106.36,57.69 105.8,58.26 105.8,61.54 97.17,70.17
  BOTTOM w0.076: UC1.AR32 v5(91.02,86.39)
  BOTTOM w0.127: JDIMM2.154 108.22,43.03 108.04,43.21 108.04,44.24 108.26,44.46 108.47,44.46 v3(108.73,44.2)
DDR_B_DQS6: length 56.2
  IN1 w0.076: 104.25,70.17 104.25,70.2 104.27,70.21 104.27,70.36 100.39,74.24 100.39,77.89 99.88,78.4 98.94,78.4 97.3,80.04 96.84,80.04 95.8,81.08 95.39,81.08 95,81.47 95,82.41 93.81,83.61 93.81,84.47 94.14,84.8 94.14,86.01 v3(93.77,86.39)
  IN1 w0.114: 104.25,70.17 104.25,69.76 106.56,67.45 106.56,66.81 109.84,63.53 109.84,61.18 111.59,59.43 111.59,52.39 111.82,52.16 112.9,52.16 113.02,52.05 113.02,51.68 112.87,51.54 111.82,51.54 111.59,51.31 111.59,50.75 111.82,50.52 112.57,50.52 112.76,50.34 112.76,50.08 112.57,49.9 111.82,49.9 111.59,49.67 111.59,48.12 111.86,47.85 112.09,47.85 v5(112.36,47.58)
  BOTTOM w0.076: UC1.AR27 v3(93.77,86.39)
  BOTTOM w0.127: v5(112.36,47.58) 112.61,47.83 112.86,47.83 113.18,48.15 113.18,49.3 113.32,49.45 JDIMM2.171
DDR_B_DQS7: length 60
  IN1 w0.076: 110.26,70.31 110.24,70.32 110.22,70.32 109.66,70.88 109.66,70.88 109.29,71.24 108.58,71.24 106.97,72.85 106.97,77.83 105.3,79.5 103.81,79.5 102.43,80.87 100.94,80.87 97.05,84.76 97.05,86.01 v3(97.42,86.39)
  IN1 w0.114: v5(119.16,44.15) 119.46,44.45 119.7,44.45 119.84,44.59 120.07,44.82 120.07,45.81 119.41,46.47 119.41,51.5 119.18,51.73 119.18,53.55 119.93,54.31 119.93,56.64 115.98,60.6 115.98,62.55 114.35,64.18 114.35,66.15 113.27,67.23 113.27,68.82 112.03,70.06 110.5,70.06 110.26,70.31
  BOTTOM w0.076: UC1.AR21 v3(97.42,86.39)
  BOTTOM w0.127: v5(119.16,44.15) 118.87,44.43 118.44,44.43 118.29,44.29 118.29,43.12 118.42,42.99 JDIMM2.188
DDR_B_DQS#0: length 69
  IN1 w0.076: v5(72.64,90.13) 72.7,90.07 72.7,89.86 72.63,89.79 72.51,89.79 72.48,89.76 71.83,89.76 71.76,89.83 71.53,89.83 71.47,89.76 71.39,89.76 71.28,89.66 71.16,89.66 70.99,89.49 70.99,89.36 70.82,89.19 70.69,89.19 70.52,89.02 70.52,88.89 70.4,88.77 70.07,88.77 69.92,88.62 69.79,88.62 69.62,88.45 69.62,88.33 69.45,88.16 69.33,88.16 69.16,87.98 69.16,87.86 68.98,87.69 68.86,87.69 68.69,87.52 68.69,87.39 68.52,87.22 68.39,87.22 68.22,87.05 68.22,86.92 68.05,86.75 67.92,86.75 67.75,86.58 67.75,86.46 67.65,86.35 67.65,86.15 67.57,86.08 67.57,85.82 67.65,85.75 67.65,85.43 67.27,85.05 65.08,85.05 64.88,84.85 64.83,84.85
  IN1 w0.114: v3(66.69,48.31) 66.91,48.09 67.07,48.09 67.18,48.21 67.18,49.4 58.32,58.26 58.32,77.53 57.94,77.91 57.78,77.91 57.42,77.55 56.99,77.55 56.68,77.86 56.68,78.29 57.04,78.65 57.04,78.81 56.76,79.1 56.76,79.45 57.14,79.84 57.5,79.84 59.45,77.88 59.61,77.88 59.91,78.18 59.91,78.34 59.76,78.49 59.76,78.82 60.17,79.23 60.5,79.23 60.65,79.08 60.81,79.08 63.07,81.33 63.07,83.09 63.32,83.35 63.32,83.51 62.59,84.24 62.59,84.57 63,84.98 63.33,84.98 64.06,84.25 64.22,84.25 64.83,84.85
  BOTTOM w0.076: UC1.AH66 v5(72.64,90.13)
  BOTTOM w0.127: v3(66.69,48.31) 66.69,48.12 66.83,47.98 67.08,47.98 67.91,48.81 67.91,49.33 67.72,49.52 JDIMM2.27
DDR_B_DQS#1: length 73.2
  IN1 w0.076: v3(65.32,90.62) 65.51,90.62 65.61,90.73 65.61,90.92 65.41,91.12 62.91,91.12 62.89,91.11 62.87,91.11
  IN1 w0.114: v3(61.54,44.25) 61.54,44.43 61.73,44.62 62.09,44.62 62.36,44.89 62.36,45.23 61.39,46.2 61.39,47.72 60.45,48.66 60.45,49.08 59.69,49.84 58.41,49.84 54.14,54.11 54.14,69.59 52.27,71.45 52.27,85.94 57.44,91.11 62.87,91.11
  BOTTOM w0.076: UC1.AG69 70.68,91 70.51,90.83 70.5,90.83 70.43,90.76 70.27,90.76 70.24,90.72 69.89,90.72 69.82,90.75 69.6,90.75 69.5,90.7 69.26,90.7 69.16,90.75 68.63,90.75 68.63,90.75 68.55,90.75 67.65,90.75 66.9,90.01 65.82,90.01 65.59,90.23 65.59,90.41 65.38,90.62 v3(65.32,90.62)
  BOTTOM w0.127: v3(61.54,44.25) 61.54,44.43 61.68,44.57 62.41,44.57 62.74,44.24 62.74,43.55 62.62,43.43 JDIMM2.10
DDR_B_DQS#2: length 54.8
  IN1 w0.076: v3(71.82,86.39) 72.15,86.72 72.26,86.72 72.37,86.62 72.37,86.16 72.2,86 72.2,84.24 71.91,83.96 71.18,83.96 70.29,83.07 69.78,83.07 69.54,82.83 69.54,82.33 69.46,82.24 69.2,82.24 68.98,82.02 68.98,81.78 68.91,81.7 68.4,81.7 68.23,81.53 68.23,81.02 68.1,80.89 67.44,80.89 67.06,80.51 67.06,80.22 67.04,80.2 67.04,80.15 67.02,80.13 67.02,80.12
  IN1 w0.114: v3(71.41,47.46) 71.41,47.46 71.55,47.32 71.72,47.32 71.88,47.48 71.88,50.01 64.27,57.62 64.27,74.34 66.53,76.6 66.53,77.29 66.34,77.48 65.59,77.48 65.26,77.81 65.26,78.2 67.02,79.96 67.02,80.12
  BOTTOM w0.076: v3(71.82,86.39) 72.18,86.75 UC1.AR66
  BOTTOM w0.127: JDIMM2.45 73.12,48.55 71.79,47.22 71.65,47.22 v3(71.41,47.46)
DDR_B_DQS#3: length 52.8
  IN1 w0.076: v3(74.56,86.39) 74.94,86.01 74.94,84.72 75.06,84.6 75.06,83.55 73.92,82.41 73.92,81.62 73.54,81.24 73.01,81.24 70.92,79.15 70.92,75.52 70.41,75.02 70.41,73.59 70.4,73.57 70.4,73.55
  IN1 w0.114: v3(78.49,44.36) 78.21,44.65 77.9,44.65 77.25,45.3 77.25,49.08 76.54,49.79 76.54,51.14 69.42,58.26 69.42,72.15 70.4,73.12 70.4,73.55
  BOTTOM w0.076: v3(74.56,86.39) 74.93,86.75 UC1.AR61
  BOTTOM w0.127: JDIMM2.62 78.22,42.92 78.42,43.12 78.42,43.51 79.06,44.16 79.06,44.44 78.94,44.57 78.7,44.57 v3(78.49,44.36)
DDR_B_DQS#4: length 52.1
  IN1 w0.076: 90.16,70.17 90.16,70.19 90.17,70.21 90.17,70.4 89.46,71.11 89.46,71.72 89.39,71.8 89.39,72.13 89.46,72.2 89.46,72.53 89.39,72.61 89.39,72.94 89.46,73.02 89.46,73.35 89.39,73.42 89.39,73.75 89.46,73.83 89.46,74.16 89.39,74.24 89.39,74.57 89.46,74.64 89.46,74.97 89.39,75.05 89.39,75.38 89.46,75.45 89.46,75.78 89.39,75.86 89.39,76.19 89.46,76.27 89.46,76.6 89.39,76.67 89.39,77 89.46,77.08 89.46,77.41 89.39,77.49 89.39,77.82 89.46,77.89 89.46,78.22 89.39,78.3 89.39,78.63 89.46,78.71 89.46,79.04 89.39,79.11 89.39,79.44 89.46,79.52 89.46,79.85 89.39,79.92 89.39,80.26 89.46,80.33 89.46,80.53 89.24,80.76 89.24,81.29 89.05,81.48 88.92,81.48 88.69,81.71 88.69,81.84 88.24,82.29 88.18,82.29 88.18,82.29 88.12,82.29 87.88,82.52 87.88,82.59 87.88,82.65 87.74,82.79 87.74,83.56 87.66,83.63 87.66,83.97 87.74,84.04 87.74,84.37 87.66,84.45 87.66,84.78 87.74,84.85 87.74,85.74 87.61,85.87 87.48,85.87 v5(87.36,85.75)
  IN1 w0.114: 90.16,70.17 90.16,69.83 101.14,58.84 101.14,51.28 101.38,51.04 102.29,51.04 102.37,50.95 102.37,50.5 102.26,50.38 101.56,50.38 101.3,50.13 101.3,49.62 101.57,49.35 102.21,49.35 102.37,49.19 102.37,48.1 102.16,47.89 101.96,47.89 101.8,48.05 v3(101.8,48.21)
  BOTTOM w0.076: UC1.AT38 v5(87.36,85.75)
  BOTTOM w0.127: v3(101.8,48.21) 101.98,48.03 102.57,48.03 102.7,48.16 102.7,49.29 102.52,49.47 JDIMM2.135
DDR_B_DQS#5: length 54.9
  IN1 w0.076: 97.31,70.31 97.29,70.32 97.27,70.32 96.63,70.96 96.3,70.96 94.24,73.01 94.24,79.95 93.86,80.33 92.59,80.33 92.41,80.51 92.41,81.32 92.49,81.39 92.49,81.72 92.41,81.8 92.41,82 92.15,82.27 92.15,82.33 92.15,82.39 91.92,82.63 91.85,82.63 91.79,82.63 91.55,82.86 91.55,82.92 91.55,82.99 91.32,83.22 91.26,83.22 91.19,83.22 91.05,83.37 91.05,84.33 90.65,84.73 90.65,85.73 90.77,85.85 90.93,85.85 v3(91.02,85.75)
  IN1 w0.114: v5(108.73,44.94) 108.73,44.81 108.51,44.59 107.98,44.59 107.47,45.09 107.47,46.09 106.56,47 106.56,57.78 106,58.34 106,61.62 97.31,70.31
  BOTTOM w0.076: UC1.AT32 v3(91.02,85.75)
  BOTTOM w0.127: JDIMM2.152 107.62,43.04 107.8,43.22 107.8,44.34 108.16,44.71 108.5,44.71 v5(108.73,44.94)
DDR_B_DQS#6: length 56.1
  IN1 w0.076: v5(94.68,86.39) 94.59,86.48 94.39,86.48 94.3,86.39 94.3,84.74 93.97,84.4 93.97,83.67 95.16,82.48 95.16,81.54 95.46,81.24 95.87,81.24 96.91,80.2 97.36,80.2 99.01,78.56 99.95,78.56 100.55,77.96 100.55,74.3 104.43,70.42 104.43,70.21 104.45,70.19 104.45,70.17
  IN1 w0.114: v3(112.36,48.32) 112.09,48.05 111.94,48.05 111.79,48.2 111.79,49.59 111.91,49.7 112.66,49.7 112.95,50 112.95,50.42 112.66,50.72 111.91,50.72 111.79,50.84 111.79,51.23 111.91,51.34 112.96,51.34 113.21,51.6 113.21,52.13 112.98,52.36 111.91,52.36 111.79,52.48 111.79,52.77 111.92,52.9 111.92,53.39 111.79,53.52 111.79,54.02 111.92,54.14 111.92,54.64 111.79,54.76 111.79,55.26 111.92,55.39 111.92,55.88 111.79,56.01 111.79,59.51 110.04,61.27 110.04,63.61 106.76,66.89 106.76,67.53 104.45,69.84 104.45,70.17
  BOTTOM w0.076: UC1.AR25 v5(94.68,86.39)
  BOTTOM w0.127: v3(112.36,48.32) 112.61,48.07 112.76,48.07 112.93,48.25 112.93,49.21 112.72,49.43 JDIMM2.169
DDR_B_DQS#7: length 60
  IN1 w0.076: v5(96.51,86.39) 96.89,86.01 96.89,84.69 100.87,80.71 102.37,80.71 103.74,79.34 105.24,79.34 106.81,77.76 106.81,72.79 108.51,71.08 109.23,71.08 109.5,70.81 110.1,70.21 110.1,70.18 110.12,70.17
  IN1 w0.114: 110.12,70.17 110.42,69.86 111.94,69.86 113.07,68.73 113.07,67.15 114.15,66.07 114.15,64.09 115.78,62.47 115.78,60.51 119.73,56.56 119.73,54.39 118.98,53.63 118.98,51.65 119.21,51.42 119.21,46.39 119.87,45.73 119.87,44.9 119.7,44.73 119.62,44.65 119.46,44.65 v3(119.16,44.96)
  BOTTOM w0.076: UC1.AR22 v5(96.51,86.39)
  BOTTOM w0.127: JDIMM2.186 117.82,43.02 118.05,43.26 118.05,44.34 118.38,44.67 118.87,44.67 v3(119.16,44.96)
DDR_B_MA0: length 51.9
  IN1 w0.076: 79.94,71.95 79.94,72.84 80.07,72.96 80.96,72.96 v3(81.55,73.56)
  IN1 w0.165: v5(90.23,45.61) 90.23,45.66 90.66,46.09 90.66,48.9 90.28,49.29 90,49.29 89.86,49.43 89.86,50.03 88.91,50.99 88.91,53.94 79.94,62.9 79.94,71.95
  BOTTOM w0.076: 83.74,78.54 84.08,78.88 84.08,80.7 84.08,81.2 84.17,81.29 84.17,82.54 83.91,82.81 UC1.BA46
  BOTTOM w0.102: v3(81.55,73.56) 82.46,73.56 82.68,73.78 82.68,74.69 82.79,74.8 83.06,74.8 83.15,74.71 83.15,73.81 83.25,73.71 83.52,73.71 83.62,73.81 83.62,78.42 83.74,78.54
  BOTTOM w0.178: v5(90.23,45.61) 90.94,45.61 91.42,45.13 JDIMM2.98
DDR_B_MA1: length 52.3
  IN1 w0.076: 79.05,71.95 79.05,72.73 80.93,74.61 80.93,75.07 80.85,75.15 80.45,75.15 80.3,75.3 80.3,75.78 80.42,75.91 81.26,75.91 81.55,75.62 v3(81.55,75.51)
  IN1 w0.165: v5(90.18,47.23) 90.18,46.24 89.54,45.61 89.13,45.61 88.97,45.77 88.97,49.67 87.37,51.27 87.37,53.48 82.19,58.66 82.19,59.34 79.05,62.48 79.05,71.95
  BOTTOM w0.076: 83.24,78.58 83.24,78.59 83.74,79.1 83.74,80.84 83.75,80.84 83.75,81.31 83.74,81.31 83.74,81.33 83.84,81.43 83.84,81.98 83.64,82.18 83.64,82.44 83.7,82.56 83.7,82.7 83.63,82.93 83.63,83.06 83.71,83.28 83.81,83.38 UC1.AY46
  BOTTOM w0.102: v3(81.55,75.51) 83.2,77.16 83.2,78.54 83.24,78.58
  BOTTOM w0.178: v5(90.18,47.23) 90.38,47.23 91.12,47.97 JDIMM2.97
DDR_B_MA2: length 52.2
  IN1 w0.076: v3(81.55,76.16) 81.39,76.32 80.42,76.32 80.07,75.96 80.07,74.11 78.61,72.65 78.61,71.95
  IN1 w0.165: v3(90.23,44.87) 89.95,44.87 89.13,44.04 88.64,44.04 88.53,44.16 88.53,49.48 86.92,51.08 86.92,53.29 81.74,58.47 81.74,59.16 78.61,62.3 78.61,71.95
  BOTTOM w0.076: UC1.AY47 83.51,83.66 83.51,83.23 83.46,83.07 83.46,82.93 83.52,82.71 83.52,82.59 83.49,82.51 83.48,82.48 83.48,82.11 83.68,81.91 83.68,81.5 83.58,81.4 83.58,81.24 83.58,79.2 82.95,78.57 82.95,78.54
  BOTTOM w0.102: 82.95,78.54 82.95,77.56 v3(81.55,76.16)
  BOTTOM w0.178: JDIMM2.96 90.82,44.28 v3(90.23,44.87)
DDR_B_MA3: length 50.5
  IN1 w0.076: v3(81.55,74.21) 81.55,74.38 81.44,74.49 81.08,74.49 80.78,74.18 80.78,73.9 80.91,73.78 80.91,73.52 80.7,73.32 79.91,73.32 79.5,72.9 79.5,71.95
  IN1 w0.165: v3(90.15,48.02) 90.15,47.91 89.99,47.74 89.61,47.74 89.41,47.93 89.41,49.85 87.81,51.45 87.81,51.62 88.01,51.82 88.23,51.82 88.42,52.01 88.42,52.29 88.23,52.49 88.01,52.49 87.81,52.69 87.81,52.9 88.45,53.54 88.45,53.77 88.2,54.01 87.97,54.01 87.83,53.87 87.6,53.87 87.55,53.92 87.36,54.12 87.36,54.35 87.49,54.49 87.49,54.72 87.25,54.96 87.02,54.96 86.88,54.83 86.65,54.83 86.4,55.07 86.4,55.3 86.54,55.44 86.54,55.67 86.3,55.92 86.07,55.92 85.93,55.78 85.7,55.78 85.45,56.02 85.45,56.25 85.59,56.39 85.59,56.63 85.35,56.87 85.11,56.87 84.98,56.73 84.74,56.73 84.5,56.97 84.5,57.21 84.64,57.34 84.64,57.58 84.4,57.82 84.16,57.82 84.02,57.68 83.79,57.68 83.55,57.92 83.55,58.16 83.69,58.3 83.69,58.53 83.44,58.77 83.21,58.77 83.07,58.63 82.84,58.63 82.63,58.84 82.63,59.53 79.5,62.66 79.5,71.95
  BOTTOM w0.076: UC1.BB46 84.01,82.23 84.01,81.36 83.91,81.26 83.91,80.77 83.91,80.77 83.91,78.98 83.47,78.54
  BOTTOM w0.102: v3(81.55,74.21) 83.43,76.08 83.43,78.5 83.47,78.54
  BOTTOM w0.178: v3(90.15,48.02) 90.66,48.53 90.66,49.16 90.52,49.3 JDIMM2.95
DDR_B_MA4: length 52.7
  IN1 w0.076: v3(81.55,76.81) 80.66,76.81 79.89,76.04 79.89,74.21 78.16,72.48 78.16,71.95
  IN1 w0.165: v5(90.2,44.21) 89.92,44.21 89.29,43.58 88.35,43.58 88.08,43.84 88.08,49.3 86.48,50.9 86.48,53.11 81.3,58.29 81.3,58.97 78.16,62.11 78.16,71.95
  BOTTOM w0.076: UC1.BA47 83.02,83.09 83.02,82.87 83.02,82.85 83.01,82.85 83.01,82.85 82.98,82.76 82.98,82.56 83.01,82.47 83.01,82.07 82.89,81.95 82.89,81.34 82.79,81.24 82.79,80.84 82.68,80.73 82.68,79.51 82.14,78.97 82.14,78.54
  BOTTOM w0.102: 82.14,78.54 82.29,78.39 82.65,78.39 82.71,78.33 82.71,78.07 82.6,77.96 82.07,77.96 81.95,77.84 81.95,77.67 82.07,77.56 82.28,77.56 82.36,77.48 82.36,77.31 81.85,76.81 v3(81.55,76.81)
  BOTTOM w0.178: JDIMM2.92 89.62,43.76 90.07,44.21 v5(90.2,44.21)
DDR_B_MA5: length 52.1
  IN1 w0.076: v3(81.55,78.11) 80.31,78.11 80.07,78.35 80.07,78.75 80.55,79.24 80.55,80.02 80.47,80.1 79.99,80.1 78.92,79.03 78.92,73.8 77.72,72.59 77.72,71.95
  IN1 w0.165: 77.72,71.95 77.72,61.93 80.85,58.79 80.85,58.1 86.04,52.92 86.04,50.71 87.61,49.14 v3(87.61,47.44)
  BOTTOM w0.076: v3(81.55,78.11) 81.94,78.5 81.94,79 82.51,79.58 82.51,80.8 82.63,80.91 82.63,81.31 82.73,81.4 82.73,82.06 82.85,82.18 82.85,82.44 82.81,82.53 82.81,82.54 82.81,82.79 82.85,82.88 82.85,83.09 82.82,83.17 82.78,83.27 82.78,83.44 UC1.AY48
  BOTTOM w0.178: v3(87.61,47.44) 87.69,47.51 88.55,47.51 89.32,48.28 JDIMM2.91
DDR_B_MA6: length 52.2
  IN1 w0.076: 76.83,71.95 76.83,72.8 77.53,73.5 77.53,78.7 79.71,80.89 81.29,80.89 81.55,80.63 v3(81.55,79.41)
  IN1 w0.165: 76.83,71.95 76.83,61.56 79.97,58.42 79.97,57.74 85.15,52.55 85.15,50.29 86.14,49.3 86.14,47.61 v3(87.59,46.17)
  BOTTOM w0.076: v3(81.55,79.41) 82.18,80.04 82.18,80.94 82.3,81.05 82.3,81.44 82.4,81.54 82.4,82.09 82.31,82.17 82.31,82.49 82.58,82.76 UC1.BA48
  BOTTOM w0.178: JDIMM2.90 89.02,44.73 v3(87.59,46.17)
DDR_B_MA7: length 54.1
  IN1 w0.076: v5(81.88,87.02) 81.5,86.64 81.5,84.86 81.14,84.51 81.14,83.16 76.92,78.93 76.92,73.47 75.94,72.49 75.94,71.95
  IN1 w0.165: 75.94,71.95 75.94,61.19 79.08,58.05 79.08,57.37 84.26,52.19 84.26,49.93 85.25,48.93 85.25,45.93 85.43,45.76 85.43,44.87 85.71,44.59 86.09,44.59 v3(86.59,45.1)
  BOTTOM w0.076: UC1.AP48 v5(81.88,87.02)
  BOTTOM w0.178: v3(86.59,45.1) 87.82,43.87 JDIMM2.86
DDR_B_MA8: length 50
  IN1 w0.076: 77.27,71.95 77.27,72.76 77.88,73.37 77.88,78.6 79.84,80.56 81.11,80.56 81.24,80.43 81.24,80.23 80.91,79.9 80.91,79.75 81.16,79.49 81.16,79.29 80.83,78.96 80.83,78.5 80.96,78.37 81.16,78.37 v3(81.55,78.76)
  IN1 w0.165: 77.27,71.95 77.27,61.74 80.41,58.61 80.41,57.92 85.59,52.74 85.59,50.5 86.59,49.51 86.59,48.36 86.75,48.2 v3(87.08,48.2)
  BOTTOM w0.076: UC1.BB48 82.58,82.15 82.56,82.13 82.56,81.47 82.46,81.37 82.46,80.98 82.35,80.87 82.35,79.81 81.94,79.41 81.94,79.24 81.78,79.08 81.78,78.99 v3(81.55,78.76)
  BOTTOM w0.178: v3(87.08,48.2) 88.5,48.2 88.72,48.42 JDIMM2.89
DDR_B_MA9: length 49.3
  IN1 w0.076: v3(80.96,87.02) 81.27,87.02 81.34,86.95 81.34,84.94 80.92,84.52 80.92,84.05 79.1,82.23 79.1,81.52 76.64,79.06 76.64,73.42 75.49,72.28 75.49,71.95
  IN1 w0.165: 75.49,71.95 75.49,61 77.66,58.83 77.66,58.6 77.36,58.3 77.36,58.06 77.61,57.82 77.84,57.82 78.14,58.12 78.37,58.12 78.62,57.88 78.62,57.65 78.32,57.35 78.32,57.11 82.47,52.96 82.47,51.92 82.66,51.73 83.5,51.73 v5(83.78,52)
  BOTTOM w0.076: UC1.AP50 v3(80.96,87.02)
  BOTTOM w0.178: v5(83.78,52) 86.91,52 87.52,51.39 JDIMM2.85
DDR_B_MA10: length 51.7
  IN1 w0.076: 82.61,70.17 82.61,70.19
  IN1 w0.165: 82.61,70.17 82.61,65.25 82.87,64.98 82.87,64.75 82.61,64.48 82.61,64.07 82.81,63.87 83.05,63.87 83.4,64.22 83.63,64.22 83.88,63.98 83.88,63.74 83.52,63.39 83.52,63.16 83.77,62.91 84,62.91 84.35,63.27 84.59,63.27 84.83,63.02 84.83,62.79 84.48,62.44 84.48,62.2 84.72,61.96 84.95,61.96 85.31,62.32 85.54,62.32 85.78,62.07 85.78,61.84 85.43,61.49 85.43,61.25 85.67,61.01 85.9,61.01 86.26,61.36 86.49,61.36 86.73,61.12 86.73,60.89 86.43,60.59 86.43,60.35 91.86,54.93 91.86,54.02 92.02,53.85 92.8,53.85 93.05,53.61 93.05,53.25 92.69,52.9 92.69,52.53 92.86,52.36 v5(92.92,52.36) ; v3(84.21,74.86) 83.89,74.86 83.8,74.94 83.8,75.97 83.64,76.14 83.29,76.14 83.13,75.97 83.13,74.42 83.22,74.33 84.23,74.33 84.33,74.23 84.33,73.83 84.16,73.65 83.31,73.65 83.14,73.48 83.14,72.79 82.28,71.92 82.28,70.52 82.61,70.19
  BOTTOM w0.076: 84.01,78.54 84.24,78.77 84.24,80.64 84.24,81.13 84.34,81.23 84.34,82.98 84.1,83.22 84.1,83.71 84,83.91 83.81,84.1 UC1.AW46
  BOTTOM w0.102: 84.01,78.54 83.81,78.34 83.81,75.26 v3(84.21,74.86)
  BOTTOM w0.178: v5(92.92,52.36) 93.48,52.36 94.12,51.72 JDIMM2.107
DDR_B_MA11: length 54.7
  IN1 w0.076: 76.38,71.95 76.38,72.63 77.22,73.47 77.22,78.83 81.5,83.11 81.5,84.19 82.34,85.02 82.34,87.2 v3(81.88,87.66)
  IN1 w0.165: 76.38,71.95 76.38,61.37 79.52,58.24 79.52,57.55 84.7,52.37 84.7,50.11 85.7,49.11 85.7,46.12 85.87,45.94 85.87,45.76 85.96,45.67 87.04,45.67 87.26,45.46 87.26,44.49 87.08,44.31 v5(86.62,44.31)
  BOTTOM w0.076: UC1.AN48 v3(81.88,87.66)
  BOTTOM w0.178: JDIMM2.84 87.22,43.71 v5(86.62,44.31)
DDR_B_MA12: length 53.6
  IN1 w0.076: 75.05,71.95 75.05,72.21 75.72,72.89 75.72,79.08 77.63,80.99 78.26,80.99 78.85,81.57 78.85,82.29 80.58,84.02 80.58,87.28 v3(80.96,87.66)
  IN1 w0.165: 75.05,71.95 75.05,60.15 75.23,59.97 75.84,59.97 76.03,59.77 76.03,59.5 75.81,59.27 75.81,58.99 76,58.79 76.28,58.79 76.51,59.02 76.79,59.02 76.99,58.82 76.99,58.54 76.76,58.31 76.76,58.04 82,52.8 82,51.53 84.79,48.73 v3(84.79,47.13)
  BOTTOM w0.076: UC1.AN50 v3(80.96,87.66)
  BOTTOM w0.178: JDIMM2.83 86.92,49.39 84.79,47.26 v3(84.79,47.13)
DDR_B_MA13: length 50.3
  IN1 w0.076: 85.01,72.88 85.12,72.99 85.12,75.45 85.35,75.68 85.35,76.11 85.12,76.34 85.12,76.75 85.2,76.82 85.45,76.82 85.79,76.49 v3(85.79,76.36)
  IN1 w0.165: 85.01,72.88 83.94,71.81 83.94,65.81 84.15,65.61 84.38,65.61 84.57,65.79 84.8,65.79 85.05,65.55 85.05,65.32 84.86,65.13 84.86,64.9 85.1,64.65 85.33,64.65 85.52,64.84 85.75,64.84 86,64.6 86,64.37 85.81,64.18 85.81,63.94 88.63,61.12 88.63,60.89 88.33,60.59 88.33,60.35 88.57,60.11 88.8,60.11 89.11,60.41 89.34,60.41 89.58,60.17 89.58,59.94 89.28,59.64 89.28,59.4 89.52,59.16 89.75,59.16 90.06,59.46 90.29,59.46 90.53,59.22 90.53,58.99 90.23,58.68 90.23,58.45 90.47,58.21 90.71,58.21 91.01,58.51 91.24,58.51 91.49,58.27 91.49,58.03 91.18,57.73 91.18,57.5 91.43,57.26 91.66,57.26 91.96,57.56 92.19,57.56 92.44,57.32 92.44,57.08 92.13,56.78 92.13,56.55 92.38,56.3 92.61,56.3 92.91,56.61 93.15,56.61 93.39,56.36 93.39,56.13 93.09,55.83 93.09,55.59 94.47,54.21 94.47,52.87 v5(94.82,52.52)
  BOTTOM w0.076: UC1.BA43 85.83,83.08 85.83,82.84 85.84,82.81 85.88,82.72 85.88,82.61 85.83,82.47 85.83,82.22 85.83,82.21 85.83,82.09 85.97,81.95 85.97,81.46 85.7,81.19 85.7,81.13 85.23,80.65 85.23,80.22 85.23,80.22 85.23,79.27 85.38,79.12 85.38,78.54
  BOTTOM w0.102: v3(85.79,76.36) 85.38,76.77 85.38,78.54
  BOTTOM w0.178: v5(94.82,52.52) 94.93,52.62 96.98,52.62 97.72,51.88 JDIMM2.119
DDR_B_MA14: length 53.7
  IN1 w0.076: v3(80.05,87.66) 80.43,87.28 80.43,84.27 75.37,79.21 75.37,72.91 74.61,72.15 74.61,71.95
  IN1 w0.165: 74.61,71.95 74.61,59.55 81.54,52.62 81.54,51.35 84.16,48.73 84.16,45.38 v5(84.89,44.64)
  BOTTOM w0.076: UC1.AN52 80.44,88.05 v3(80.05,87.66)
  BOTTOM w0.178: JDIMM2.80 86.02,43.92 85.3,44.64 v5(84.89,44.64)
DDR_B_MA15: length 53.3
  IN1 w0.076: 73.72,71.97 73.72,72.25 74.61,73.52 74.61,79.11 77.5,82.01 79.15,84.57 79.52,84.93 79.52,86.6 v3(79.13,87.66)
  IN1 w0.165: 73.72,71.97 73.72,59.15 80.63,52.24 80.63,50.85 82.23,49.25 82.23,46.9 v5(83.67,45.05)
  BOTTOM w0.076: UC1.AN53 v3(79.13,87.66)
  BOTTOM w0.178: v5(83.67,45.05) 84.66,44.06 85.12,44.06 85.42,43.76 JDIMM2.78
DDR_B_RAS#: length 51.3
  IN1 w0.076: v3(84.21,78.17) 84.21,79.06 84.29,79.14 84.74,79.14 84.87,79.01 84.87,73.24 84.65,73.03
  IN1 w0.165: 84.65,73.03 83.5,71.87 83.5,65.62 87.62,61.5 87.62,60.43 94.01,54.04 94.01,51.98 94.87,51.12 94.87,47.71 93.66,46.5 v5(93.66,45.81)
  BOTTOM w0.076: UC1.AW44 85.03,84.13 84.87,83.96 84.76,83.75 84.74,83.68 84.74,83.21 84.5,82.98 84.5,81.16 84.41,81.06 84.41,80.57 84.41,78.36 v3(84.21,78.17)
  BOTTOM w0.178: v5(93.66,45.81) 93.78,45.81 95.02,44.57 JDIMM2.110
DDR_B_WE#: length 52.4
  IN1 w0.076: 86.16,73.09 86.16,74.69 v3(85.79,75.06)
  IN1 w0.165: v5(96.15,48.22) 95.97,48.22 95.79,48.4 95.79,49.11 95.95,49.27 96.25,49.27 96.45,49.47 96.45,49.75 96.25,49.94 95.95,49.94 95.79,50.11 95.79,50.45 95.95,50.62 96.28,50.62 96.48,50.81 96.48,51.09 96.28,51.29 95.95,51.29 95.79,51.46 95.79,52.9 95.38,53.3 95.38,53.84 95.59,54.04 95.59,55.52 93.13,57.98 93.13,58.21 93.79,58.88 93.79,59.14 93.56,59.37 93.33,59.37 92.65,58.69 92.42,58.69 92.17,58.93 92.17,59.17 92.86,59.86 92.86,60.14 92.65,60.36 92.41,60.36 91.7,59.64 91.46,59.64 91.22,59.88 91.22,60.12 91.94,60.83 91.94,61.07 91.72,61.28 91.44,61.28 90.75,60.59 90.51,60.59 86.92,64.18 86.92,64.99 84.83,67.08 84.83,71.76 86.16,73.09
  BOTTOM w0.076: UC1.AY44 85.03,83.39 85.14,83.29 85.14,83.28 85.21,83.06 85.21,82.93 85.15,82.7 85.15,82.56 85.2,82.44 85.2,82.17 85,81.97 85,81.2 85,80.92 84.9,80.82 84.9,80.36 84.9,80.36 84.9,79.02 85,78.92 85,78.54
  BOTTOM w0.102: v3(85.79,75.06) 85,75.85 85,78.54
  BOTTOM w0.178: JDIMM2.113 95.92,48.45 v5(96.15,48.22)
DDR_PG_CTRL: length 120.6
  TOP w0.114: QD1.3 108.26,21.35 RD24.1 106.05,20.49 v3(104.78,21.76)
  IN3 w0.114: v5(63.07,24.22) 63.56,23.73 75.26,23.73 76.38,22.62 80.73,22.62 82.51,20.84 103.87,20.84 v3(104.78,21.76)
  BOTTOM w0.076: 66.92,79.57 66.92,80.19 67.44,80.71 68.12,80.71 68.5,81.09 71.06,81.09 71.28,81.31 71.28,81.62 71.52,81.86 71.65,81.86 71.92,82.13 71.92,82.47 71.86,82.61 71.86,82.72 71.92,82.85 71.92,83.13 71.89,83.18 71.88,83.2 71.88,83.81 71.69,84.01 71.68,84.01 71.46,84.23 71.46,84.24 UC1.AW67
  BOTTOM w0.114: v5(63.07,24.22) 62.54,24.22 59.32,27.45 59.32,34.63 57.84,36.11 57.84,42.58 55.94,44.49 55.94,66.37 66.92,77.36 66.92,79.57
DDRA_CKE0_DIMMA: length 65.6
  IN3 w0.076: v3(76.19,73.98) 75.5,73.98 73.21,71.69 73.21,70.55 72.83,70.17
  IN3 w0.165: v5(84.66,34.86) 84.26,34.86 84.11,35.02 84.11,36.26 84.23,36.38 84.36,36.38 84.49,36.51 84.49,36.95 84.35,37.08 84.23,37.08 84.11,37.21 84.11,37.54 82.73,38.91 82.73,41.72 81.46,42.99 81.46,45.25 80.83,45.88 80.83,46.9 81.46,47.54 81.46,49.01 80.8,49.67 80.8,52.09 72.83,60.06 72.83,64.64 72.67,64.8 71.9,64.8 71.74,64.97 71.74,65.33 71.9,65.5 72.67,65.5 72.83,65.66 72.83,66.03 72.67,66.2 71.9,66.2 71.74,66.36 71.74,66.73 71.9,66.9 72.67,66.9 72.83,67.06 72.83,67.43 72.67,67.59 71.87,67.59 71.71,67.76 71.71,68.05 71.95,68.29 72.67,68.29 72.83,68.46 72.83,70.17
  BOTTOM w0.076: 75.44,78.39 75.44,78.56 77.69,80.8 77.69,81.27 77.56,81.39 77.56,82.07 77.5,82.14 77.5,82.44 77.5,82.44 77.62,82.69 77.62,82.69 77.63,82.7 77.77,82.84 UC1.BA56
  BOTTOM w0.102: v3(76.19,73.98) 75.37,74.79 75.37,77.39 75.44,77.46 75.44,78.39
  BOTTOM w0.178: v5(84.66,34.86) 84.56,34.86 83.92,35.51 JDIMM1.73
DDRA_CKE1_DIMMA: length 65
  IN3 w0.076: 72.74,71.83 74.69,73.79 74.69,74.73 75.25,75.28 v3(76.19,75.28)
  IN3 w0.165: v5(83.98,32.63) 83.65,32.96 83.65,37.36 82.29,38.72 82.29,41.53 81.02,42.8 81.02,45.06 80.36,45.72 80.36,51.9 72.37,59.89 72.37,62.07 72.24,62.19 71.41,62.19 71.25,62.36 71.25,62.73 71.41,62.89 71.75,62.89 71.91,63.06 71.91,63.43 71.75,63.59 71.41,63.59 71.25,63.76 71.25,68.25 71.75,68.75 72.22,68.75 72.39,68.92 72.39,70.49 72.5,70.6 72.81,70.6 72.93,70.73 72.93,71.19 72.81,71.3 72.61,71.3 72.5,71.41 72.5,71.59 72.74,71.83
  BOTTOM w0.076: 75.7,78.39 75.7,78.58 77.85,80.74 77.85,81.34 77.73,81.46 77.73,82.3 UC1.BB56
  BOTTOM w0.102: 75.7,78.39 75.7,77.3 75.58,77.18 75.58,75.89 v3(76.19,75.28)
  BOTTOM w0.178: v5(83.98,32.63) 83.98,30.72 84.22,30.48 JDIMM1.74
DDRA_CS0_DIMMA#: length 70.5
  IN3 w0.076: v3(83.71,85.12) 84.03,84.8 84.35,84.8 84.99,84.16 84.99,83.37 86.3,82.06 86.3,71.05 86.15,70.89
  IN3 w0.165: 86.15,70.89 85.64,70.38 85.64,66.37 98.08,53.93 98.08,52.34 98.69,51.73 98.69,50.48 99.68,49.48 100.27,49.48 100.86,48.9 100.86,46.2 100.92,46.14 100.92,43.74 97.77,40.59 97.77,39.51 98.4,38.88 98.4,38.55 98.59,38.36 98.59,36.4 98.25,36.06 98.25,34.29 98.59,33.95 98.59,32.94 98.2,32.55 98.2,31.24 98.04,31.08 97.67,31.08 97.5,31.24 97.5,31.99 97.3,32.2 97.01,32.2 96.8,31.99 96.8,31 96.49,30.69 v5(96.25,30.45)
  BOTTOM w0.076: UC1.AU45 v3(83.71,85.12)
  BOTTOM w0.178: JDIMM1.114 96.22,28.95 96.22,30.45 v5(96.25,30.45)
DDRA_CS1_DIMMA#: length 71.9
  IN3 w0.076: 86.49,70.65 86.62,70.78 86.62,79.92 87.29,80.59 87.29,81.73 85.27,83.74 85.27,84.59 84.74,85.12 v3(84.62,85.12)
  IN3 w0.165: v5(98.92,39.59) 99.42,39.59 99.56,39.73 99.56,39.96 98.86,40.66 98.86,41.01 101.38,43.52 101.38,46.39 101.3,46.47 101.3,49.08 100.74,49.64 100.74,50.04 100.95,50.24 101.86,50.24 102.06,50.45 102.06,50.74 101.86,50.94 100.49,50.94 99.86,50.31 99.48,50.31 99.19,50.6 99.19,51.44 99.4,51.64 101.12,51.64 101.33,51.85 101.33,52.14 101.12,52.34 98.81,52.34 98.61,52.54 98.61,52.83 98.81,53.04 101.22,53.04 101.43,53.24 101.43,53.53 101.22,53.74 99.16,53.74 86.29,66.61 86.29,70.45 86.49,70.65
  BOTTOM w0.076: UC1.AU43 v3(84.62,85.12)
  BOTTOM w0.178: JDIMM1.121 98.32,38.29 98.16,38.46 98.16,39.2 98.55,39.59 v5(98.92,39.59)
DDRA_ODT0_DIMMA#: length 70.6
  IN3 w0.076: 85.2,70.25 85.2,70.46 85.39,70.65 85.39,78.84 85.09,79.13 85.09,82.59 83.31,84.37 83.31,85.36 v3(83.71,85.75)
  IN3 w0.165: 85.2,70.25 85.2,66.18 97.63,53.75 97.63,52.16 98.24,51.55 98.24,50.38 97.78,49.93 97.78,49.53 98.05,49.27 98.41,49.27 98.69,49.54 98.99,49.54 99.4,49.14 99.4,47.67 99.23,47.51 98.99,47.51 98.79,47.3 98.79,47.02 98.99,46.81 99.39,46.81 99.68,46.52 99.68,46.09 99.35,45.76 99.35,45.46 99.65,45.15 99.65,43.1 97.32,40.77 97.32,39.32 97.75,38.9 97.75,38.37 98.15,37.97 98.15,36.58 97.81,36.25 97.81,34.1 98.15,33.76 98.15,33.31 97.52,32.68 96.14,32.68 95.99,32.53 95.99,32.17 v5(96.27,31.89)
  BOTTOM w0.076: UC1.AT45 v3(83.71,85.75)
  BOTTOM w0.178: JDIMM1.116 96.82,31.34 v5(96.27,31.89)
DDRA_ODT1_DIMMA#: length 71.9
  IN3 w0.165: v3(84.62,85.75) 85.6,84.77 85.6,83.94 87.56,81.98 87.56,80.46 86.9,79.8 86.9,66.9 99.56,54.23 101.57,54.23 102.58,53.22 102.58,50.14 102.29,49.85 102.29,46.44 101.82,45.98 101.82,43.12 99.64,40.93 99.64,40.51 100.12,40.03 100.12,38.99 99.03,37.91 99.03,36.22 98.7,35.88 98.7,34.47 99.03,34.13 99.03,31.36 99.73,30.67 99.73,30.14 99.34,29.76 98.79,29.76 98.41,30.14 v5(98.41,30.72)
  BOTTOM w0.076: UC1.AT43 v3(84.62,85.75)
  BOTTOM w0.178: JDIMM1.120 98.02,30.34 v5(98.41,30.72)
DDRB_CKE0_DIMMB: length 50.3
  IN1 w0.076: 72.6,71.92 72.6,72.28 73.97,73.65 73.97,79.26 76.5,81.79 77.64,83.77 77.78,84.11 77.78,87.19 v3(77.31,87.66)
  IN1 w0.165: 72.6,71.92 72.6,58.66 79.51,51.75 79.51,50.39 80.45,49.45 80.45,48.53 v5(80.96,48.02)
  BOTTOM w0.076: UC1.AN56 v3(77.31,87.66)
  BOTTOM w0.178: v5(80.96,48.02) 82.56,48.02 83.92,49.38 JDIMM2.73
DDRB_CKE1_DIMMB: length 52.1
  IN1 w0.076: v3(78.22,87.02) 78.64,86.5 78.64,84.88 78.62,84.81 78.27,84 76.98,81.84 74.25,79.11 74.25,73.55 73.04,72.09 73.04,71.77
  IN1 w0.165: v5(83.7,43.75) 83.57,43.75 83.14,44.19 81.45,46.75 81.45,49.07 79.95,50.57 79.95,51.96 73.04,58.87 73.04,71.77
  BOTTOM w0.076: UC1.AP55 v3(78.22,87.02)
  BOTTOM w0.178: JDIMM2.74 84.22,42.15 84.22,43.23 v5(83.7,43.75)
